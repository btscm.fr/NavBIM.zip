Properties of the parts of a building model (IFC2X3), part 17 of 32

# IfcBeam: TUBE-C-120*120*4 (16)
Name | Material | Center of gravity Z (mm) | Center of gravity Y (mm) | Center of gravity X (mm) | Bottom elevation | Top elevation | Part mark | Assembly mark | Phase | Class | Finish | Grade | Name | Net weight (kg) = NetWeight (kg) | Gross weight (kg) = Weight (kg) | Net volume (m3) = NetVolume (m3) | Gross volume (m3) | Gross footprint area (m2) | Net surface area (m2) | Gross area (m2) = OuterSurfaceArea (m2) | Tekla Quantity, Length (mm) = BaseQuantities, Length (mm)
SOLIVE | STEEL/S235JR | 5760 | 21906.5 | 20187.5 | +5.700 | +5.820 | 880 | S1 | 2 | 2007 | GALVANISE | S235JR | SOLIVE | 16.5365 | 16.287 | 0.00210656 | 0.00207478 | 0.1362 | 0.54672 | 0.52891 | 1135
SOLIVE | STEEL/S235JR | 5760 | 12513.5 | 20187.5 | +5.700 | +5.820 | 880 | S1 | 2 | 2007 | GALVANISE | S235JR | SOLIVE | 16.5365 | 16.287 | 0.00210656 | 0.00207478 | 0.1362 | 0.54672 | 0.52891 | 1135
SOLIVE | STEEL/S235JR | 5760 | 45306.5 | 20187.5 | +5.700 | +5.820 | 880 | S1 | 2 | 2007 | GALVANISE | S235JR | SOLIVE | 16.5365 | 16.287 | 0.00210656 | 0.00207478 | 0.1362 | 0.54672 | 0.52891 | 1135
SOLIVE | STEEL/S235JR | 5760 | 82.0019 | 20185 | +5.700 | +5.820 | 881 | S2 | 2 | 2007 | GALVANISE | S235JR | SOLIVE | 16.4636 | 16.2153 | 0.00209728 | 0.00206564 | 0.1356 | 0.54432 | 0.52658 | 1130
SOLIVE | STEEL/S235JR | 5760 | 27106.5 | 20187.5 | +5.700 | +5.820 | 880 | S1 | 2 | 2007 | GALVANISE | S235JR | SOLIVE | 16.5365 | 16.287 | 0.00210656 | 0.00207478 | 0.1362 | 0.54672 | 0.52891 | 1135
SOLIVE | STEEL/S235JR | 5760 | 17233.5 | 20187.5 | +5.700 | +5.820 | 880 | S1 | 2 | 2007 | GALVANISE | S235JR | SOLIVE | 16.5365 | 16.287 | 0.00210656 | 0.00207478 | 0.1362 | 0.54672 | 0.52891 | 1135
SOLIVE | STEEL/S235JR | 5760 | 9866.5 | 20187.5 | +5.700 | +5.820 | 880 | S1 | 2 | 2007 | GALVANISE | S235JR | SOLIVE | 16.5365 | 16.287 | 0.00210656 | 0.00207478 | 0.1362 | 0.54672 | 0.52891 | 1135
SOLIVE | STEEL/S235JR | 5760 | 4956.5 | 20187.5 | +5.700 | +5.820 | 880 | S1 | 2 | 2007 | GALVANISE | S235JR | SOLIVE | 16.5365 | 16.287 | 0.00210656 | 0.00207478 | 0.1362 | 0.54672 | 0.52891 | 1135
LISSE | STEEL/S235JR | 5890 | 13499 | 75485 | +5.830 | +5.950 | 882 | L104 | 1 | 1003 | GRENAILLE-PEINT | S235JR | LISSE | 103.444 | 101.884 | 0.0131776 | 0.0129788 | 0.852 | 3.40992 | 3.3086 | 7100
BUTON | STEEL/E24-2 | 4556.07 | -82.5 | 22580.8 | +4.081 | +5.031 | 878 | B7 | 3 | 3001 | GRENAILLE-PEINT | E24-2 | BUTON | 46.6896 | 45.9852 | 0.00594772 | 0.00585799 | 0 | 1.54012 | 1.49334 | 3204.59
BUTON | STEEL/E24-2 | 4556.07 | -82.5 | 34255.8 | +4.081 | +5.031 | 878 | B7 | 3 | 3001 | GRENAILLE-PEINT | E24-2 | BUTON | 46.6896 | 45.9852 | 0.00594772 | 0.00585799 | 0 | 1.54012 | 1.49334 | 3204.59
BUTON | STEEL/E24-2 | 4556.07 | -82.5 | 57605.8 | +4.081 | +5.031 | 878 | B7 | 1 | 1002 | GRENAILLE-PEINT | E24-2 | BUTON | 46.6896 | 45.9852 | 0.00594772 | 0.00585799 | 0 | 1.54012 | 1.49334 | 3204.59
BUTON | STEEL/E24-2 | 4526.13 | -82.5 | 69169.7 | +4.081 | +4.971 | 879 | B8 | 1 | 1002 | GRENAILLE-PEINT | E24-2 | BUTON | 43.336 | 42.6823 | 0.00552051 | 0.00543723 | 0 | 1.42964 | 1.38608 | 2974.41

# IfcBeam: TUBE-C-150*150*4 (3)
In: Undefined
Description: TUBE-C-150*150*4
Tekla Common - Profile: TUBE-C-150*150*4; sets with these values: 2
Tekla Quantity - Area per tons: 32.3439 m2; Height: 150 mm; Width: 150 mm; sets with these values: 2
Name | Material | Center of gravity Z (mm) | Center of gravity Y (mm) | Center of gravity X (mm) | Bottom elevation | Top elevation | Part mark | Assembly mark | Phase | Class | Finish | Grade | Name | Net weight (kg) = NetWeight (kg) | Gross weight (kg) = Weight (kg) | Net volume (m3) = NetVolume (m3) | Gross volume (m3) | Gross footprint area (m2) | Net surface area (m2) | Gross area (m2) = OuterSurfaceArea (m2) | Tekla Quantity, Length (mm) = BaseQuantities, Length (mm)
LISSE | STEEL/S235JR | 4125 | 44387.5 | -732 | +4.050 | +4.200 | 477 | L7 | 4 | 4000 | GALVANISE | S235JR | LISSE | 154.678 | 152.824 | 0.0197042 | 0.019468 | 1.26525 | 5.0634 | 4.94291 | 8435
LISSE | STEEL/S235JR | 4875 | 44387.5 | -732 | +4.800 | +4.950 | 477 | L6 | 4 | 4000 | GALVANISE | S235JR | LISSE | 154.678 | 152.824 | 0.0197042 | 0.019468 | 1.26525 | 5.0634 | 4.94291 | 8435
BUTON | STEEL/E24-2 | 3169.87 | -82.5 | 47062.6 | +2.239 | +4.101 | 476 | B5 | 1 | 1002 | GRENAILLE-PEINT | E24-2 | BUTON | 103.055 | 101.82 | 0.0131281 | 0.0129707 | 0 | 3.37433 | 3.29326 | 5619.89

# IfcBeam: TUBE-C-60*60*3 (66)
In: Undefined
Description: TUBE-C-60*60*3; Material: STEEL/E24-2
Tekla Common - Finish: GRENAILLE-PEINT; Grade: E24-2; Profile: TUBE-C-60*60*3; sets with these values: 2
Tekla Quantity - Area per tons: 42.9 m2; Height: 60 mm; Width: 60 mm; sets with these values: 2
Name | Center of gravity Z (mm) | Center of gravity Y (mm) | Center of gravity X (mm) | Bottom elevation | Top elevation | Part mark | Assembly mark | Phase | Class | Name | Net weight (kg) = NetWeight (kg) | Gross weight (kg) = Weight (kg) | Net volume (m3) = NetVolume (m3) | Gross volume (m3) | Gross footprint area (m2) | Net surface area (m2) | Gross area (m2) = OuterSurfaceArea (m2) | Tekla Quantity, Length (mm) = BaseQuantities, Length (mm)
LINTEAU | 180 | 19570 | 74677.5 | +0.150 | +0.210 | 1172 | L41 | 7 | 7001 | LINTEAU | 3.64582 | 3.6245 | 0.000464436 | 0.00046172 | 0.04074 | 0.16368 | 0.155491 | 679
LINTEAU | 1720 | 19570 | 74677.5 | +1.690 | +1.750 | 1172 | L41 | 7 | 7001 | LINTEAU | 3.64582 | 3.6245 | 0.000464436 | 0.00046172 | 0.04074 | 0.16368 | 0.155491 | 679
LINTEAU | 3562.96 | 20670 | 78865 | +3.533 | +3.593 | 1171 | L40 | 7 | 7001 | LINTEAU | 5.01502 | 4.98569 | 0.000638856 | 0.00063512 | 0.05604 | 0.22488 | 0.213886 | 934
CV | 4724.12 | 48880.5 | 28040.8 | +4.691 | +4.758 | 1173 | W6 | 3 | 3003 | CV | 9.01495 | 8.96224 | 0.0011484 | 0.00114169 | 0 | 0.403668 | 0.38448 | 1678.95
CV | 4474.95 | 48880.5 | 30080.8 | +4.442 | +4.508 | 1173 | W6 | 3 | 3003 | CV | 9.01495 | 8.96224 | 0.0011484 | 0.00114169 | 0 | 0.403668 | 0.38448 | 1678.95
CV | 4225.78 | 48880.5 | 32120.8 | +4.192 | +4.259 | 1173 | W6 | 3 | 3003 | CV | 9.01495 | 8.96224 | 0.0011484 | 0.00114169 | 0 | 0.403668 | 0.38448 | 1678.95
LISSE | 5003.82 | 49590 | 32420 | +4.163 | +5.845 | 1176 | L46 | 3 | 3003 | LISSE | 9.03155 | 8.97873 | 0.00115052 | 0.00114379 | 0.000684 | 0.40441 | 0.385187 | 1682.04
LISSE | 4760 | 28550 | 55770 | +4.730 | +4.790 | 1184 | L47 | 1 | 1003 | LISSE | 12.2798 | 12.208 | 0.00156431 | 0.00155516 | 0.13722 | 0.5496 | 0.523723 | 2287
LISSE | 5620 | 28550 | 55770 | +5.590 | +5.650 | 1184 | L47 | 1 | 1003 | LISSE | 12.2798 | 12.208 | 0.00156431 | 0.00155516 | 0.13722 | 0.5496 | 0.523723 | 2287
LISSE | 4760 | 20750 | 55770 | +4.730 | +4.790 | 1184 | L47 | 1 | 1003 | LISSE | 12.2798 | 12.208 | 0.00156431 | 0.00155516 | 0.13722 | 0.5496 | 0.523723 | 2287
LISSE | 5620 | 20750 | 55770 | +5.590 | +5.650 | 1184 | L47 | 1 | 1003 | LISSE | 12.2798 | 12.208 | 0.00156431 | 0.00155516 | 0.13722 | 0.5496 | 0.523723 | 2287
 | 5620 | 62450 | 55770 | +5.590 | +5.650 | 1177 | N38 | 1 | 1006 |  | 12.3657 | 12.2934 | 0.00157525 | 0.00156604 | 0.13818 | 0.55344 | 0.527387 | 2303
 | 4760 | 13550 | 55770 | +4.730 | +4.790 | 1178 | N47 | 1 | 1006 |  | 11.0771 | 11.0123 | 0.00141109 | 0.00140284 | 0.12378 | 0.49584 | 0.472427 | 2063
 | 5620 | 13550 | 55770 | +5.590 | +5.650 | 1178 | N47 | 1 | 1006 |  | 11.0771 | 11.0123 | 0.00141109 | 0.00140284 | 0.12378 | 0.49584 | 0.472427 | 2063
LISSE | 5002.5 | 33.0001 | 44095 | +4.420 | +5.585 | 1174 | L43 | 3 | 3003 | LISSE | 6.25535 | 6.21877 | 0.00079686 | 0.0007922 | 0.000684 | 0.28032 | 0.266785 | 1165
 | 5620 | 44150 | 55770 | +5.590 | +5.650 | 1177 | N41 | 1 | 1006 |  | 12.3657 | 12.2934 | 0.00157525 | 0.00156604 | 0.13818 | 0.55344 | 0.527387 | 2303
 | 4760 | 62450 | 55770 | +4.730 | +4.790 | 1177 | N38 | 1 | 1006 |  | 12.3657 | 12.2934 | 0.00157525 | 0.00156604 | 0.13818 | 0.55344 | 0.527387 | 2303
 | 4760 | 44150 | 55770 | +4.730 | +4.790 | 1177 | N41 | 1 | 1006 |  | 12.3657 | 12.2934 | 0.00157525 | 0.00156604 | 0.13818 | 0.55344 | 0.527387 | 2303
LISSE | 5620 | 20750 | 32420 | +5.590 | +5.650 | 1184 | L47 | 3 | 3003 | LISSE | 12.2798 | 12.208 | 0.00156431 | 0.00155516 | 0.13722 | 0.5496 | 0.523723 | 2287
LISSE | 5620 | 28550 | 32420 | +5.590 | +5.650 | 1184 | L47 | 3 | 3003 | LISSE | 12.2798 | 12.208 | 0.00156431 | 0.00155516 | 0.13722 | 0.5496 | 0.523723 | 2287
LISSE | 4760 | 28550 | 32420 | +4.730 | +4.790 | 1184 | L47 | 3 | 3003 | LISSE | 12.2798 | 12.208 | 0.00156431 | 0.00155516 | 0.13722 | 0.5496 | 0.523723 | 2287
LISSE | 4760 | 38944.2 | 20745 | +4.730 | +4.790 | 1185 | L48 | 2 | 2003 | LISSE | 12.2181 | 12.1466 | 0.00155644 | 0.00154734 | 0.13653 | 0.54684 | 0.521089 | 2275.5
LISSE | 5620 | 38944.2 | 20745 | +5.590 | +5.650 | 1185 | L48 | 2 | 2003 | LISSE | 12.2181 | 12.1466 | 0.00155644 | 0.00154734 | 0.13653 | 0.54684 | 0.521089 | 2275.5
 | 5620 | 46750 | 32420 | +5.590 | +5.650 | 1177 | N43 | 3 | 3003 |  | 12.3657 | 12.2934 | 0.00157525 | 0.00156604 | 0.13818 | 0.55344 | 0.527387 | 2303
 | 4760 | 13550 | 44095 | +4.730 | +4.790 | 1178 | N47 | 1 | 1006 |  | 11.0771 | 11.0123 | 0.00141109 | 0.00140284 | 0.12378 | 0.49584 | 0.472427 | 2063
 | 5620 | 13550 | 44095 | +5.590 | +5.650 | 1178 | N47 | 1 | 1006 |  | 11.0771 | 11.0123 | 0.00141109 | 0.00140284 | 0.12378 | 0.49584 | 0.472427 | 2063
LISSE | 4947.5 | 61268.5 | 44095 | +4.240 | +5.655 | 1175 | N39 | 1 | 1006 | LISSE | 7.5977 | 7.55327 | 0.00096786 | 0.0009622 | 0.000684 | 0.34032 | 0.324035 | 1415
 | 5620 | 44150 | 44095 | +5.590 | +5.650 | 1177 | N41 | 1 | 1006 |  | 12.3657 | 12.2934 | 0.00157525 | 0.00156604 | 0.13818 | 0.55344 | 0.527387 | 2303
 | 4760 | 44150 | 44095 | +4.730 | +4.790 | 1177 | N41 | 1 | 1006 |  | 12.3657 | 12.2934 | 0.00157525 | 0.00156604 | 0.13818 | 0.55344 | 0.527387 | 2303
 | 5620 | 54550 | 44095 | +5.590 | +5.650 | 1177 | N42 | 1 | 1006 |  | 12.3657 | 12.2934 | 0.00157525 | 0.00156604 | 0.13818 | 0.55344 | 0.527387 | 2303
 | 4760 | 54550 | 44095 | +4.730 | +4.790 | 1177 | N42 | 1 | 1006 |  | 12.3657 | 12.2934 | 0.00157525 | 0.00156604 | 0.13818 | 0.55344 | 0.527387 | 2303
LISSE | 4947.5 | 61268.5 | 55770 | +4.240 | +5.655 | 1175 | N38 | 1 | 1006 | LISSE | 7.5977 | 7.55327 | 0.00096786 | 0.0009622 | 0.000684 | 0.34032 | 0.324035 | 1415
LISSE | 4760 | 28550 | 44095 | +4.730 | +4.790 | 1184 | L47 | 1 | 1003 | LISSE | 12.2798 | 12.208 | 0.00156431 | 0.00155516 | 0.13722 | 0.5496 | 0.523723 | 2287
LISSE | 5620 | 28550 | 44095 | +5.590 | +5.650 | 1184 | L47 | 1 | 1003 | LISSE | 12.2798 | 12.208 | 0.00156431 | 0.00155516 | 0.13722 | 0.5496 | 0.523723 | 2287
 | 4760 | 62450 | 44095 | +4.730 | +4.790 | 1177 | N39 | 1 | 1006 |  | 12.3657 | 12.2934 | 0.00157525 | 0.00156604 | 0.13818 | 0.55344 | 0.527387 | 2303
LISSE | 4760 | 20750 | 32420 | +4.730 | +4.790 | 1184 | L47 | 3 | 3003 | LISSE | 12.2798 | 12.208 | 0.00156431 | 0.00155516 | 0.13722 | 0.5496 | 0.523723 | 2287
 | 5620 | 62450 | 44095 | +5.590 | +5.650 | 1177 | N39 | 1 | 1006 |  | 12.3657 | 12.2934 | 0.00157525 | 0.00156604 | 0.13818 | 0.55344 | 0.527387 | 2303
LISSE | 5620 | 20750 | 44095 | +5.590 | +5.650 | 1184 | L47 | 1 | 1003 | LISSE | 12.2798 | 12.208 | 0.00156431 | 0.00155516 | 0.13722 | 0.5496 | 0.523723 | 2287
LISSE | 4760 | 20750 | 44095 | +4.730 | +4.790 | 1184 | L47 | 1 | 1003 | LISSE | 12.2798 | 12.208 | 0.00156431 | 0.00155516 | 0.13722 | 0.5496 | 0.523723 | 2287
 | 5620 | 13550 | 32420 | +5.590 | +5.650 | 1178 | N48 | 3 | 3006 |  | 11.0771 | 11.0123 | 0.00141109 | 0.00140284 | 0.12378 | 0.49584 | 0.472427 | 2063
 | 4760 | 13550 | 32420 | +4.730 | +4.790 | 1178 | N48 | 3 | 3006 |  | 11.0771 | 11.0123 | 0.00141109 | 0.00140284 | 0.12378 | 0.49584 | 0.472427 | 2063
 | 4760 | 36350 | 32420 | +4.730 | +4.790 | 1177 | N40 | 3 | 3006 |  | 12.3657 | 12.2934 | 0.00157525 | 0.00156604 | 0.13818 | 0.55344 | 0.527387 | 2303
 | 5620 | 36350 | 32420 | +5.590 | +5.650 | 1177 | N40 | 3 | 3006 |  | 12.3657 | 12.2934 | 0.00157525 | 0.00156604 | 0.13818 | 0.55344 | 0.527387 | 2303
 | 4760 | 44150 | 32420 | +4.730 | +4.790 | 1177 | N43 | 3 | 3003 |  | 12.3657 | 12.2934 | 0.00157525 | 0.00156604 | 0.13818 | 0.55344 | 0.527387 | 2303
 | 5620 | 44150 | 32420 | +5.590 | +5.650 | 1177 | N43 | 3 | 3003 |  | 12.3657 | 12.2934 | 0.00157525 | 0.00156604 | 0.13818 | 0.55344 | 0.527387 | 2303
 | 4760 | 46750 | 32420 | +4.730 | +4.790 | 1177 | N43 | 3 | 3003 |  | 12.3657 | 12.2934 | 0.00157525 | 0.00156604 | 0.13818 | 0.55344 | 0.527387 | 2303
LISSE | 4760 | 28550 | 20745 | +4.730 | +4.790 | 1184 | L47 | 2 | 2003 | LISSE | 12.2798 | 12.208 | 0.00156431 | 0.00155516 | 0.13722 | 0.5496 | 0.523723 | 2287
LISSE | 5620 | 28550 | 20745 | +5.590 | +5.650 | 1184 | L47 | 2 | 2003 | LISSE | 12.2798 | 12.208 | 0.00156431 | 0.00155516 | 0.13722 | 0.5496 | 0.523723 | 2287
 | 4760 | 15910 | 20745 | +4.730 | +4.790 | 1178 | N49 | 2 | 2006 |  | 11.0771 | 11.0123 | 0.00141109 | 0.00140284 | 0.12378 | 0.49584 | 0.472427 | 2063
 | 5620 | 15910 | 20745 | +5.590 | +5.650 | 1178 | N49 | 2 | 2006 |  | 11.0771 | 11.0123 | 0.00141109 | 0.00140284 | 0.12378 | 0.49584 | 0.472427 | 2063
 | 5620 | 23350 | 20745 | +5.590 | +5.650 | 1177 | N45 | 2 | 2006 |  | 12.3657 | 12.2934 | 0.00157525 | 0.00156604 | 0.13818 | 0.55344 | 0.527387 | 2303
 | 4760 | 23350 | 20745 | +4.730 | +4.790 | 1177 | N45 | 2 | 2006 |  | 12.3657 | 12.2934 | 0.00157525 | 0.00156604 | 0.13818 | 0.55344 | 0.527387 | 2303
 | 5620 | 33750 | 20745 | +5.590 | +5.650 | 1177 | N44 | 2 | 2006 |  | 12.3657 | 12.2934 | 0.00157525 | 0.00156604 | 0.13818 | 0.55344 | 0.527387 | 2303
 | 4760 | 33750 | 20745 | +4.730 | +4.790 | 1177 | N44 | 2 | 2006 |  | 12.3657 | 12.2934 | 0.00157525 | 0.00156604 | 0.13818 | 0.55344 | 0.527387 | 2303
 | 5620 | 46750 | 20745 | +5.590 | +5.650 | 1177 | N46 | 2 | 2006 |  | 12.3657 | 12.2934 | 0.00157525 | 0.00156604 | 0.13818 | 0.55344 | 0.527387 | 2303
LISSE | 5002.5 | 33.0001 | 55770 | +4.420 | +5.585 | 1174 | L42 | 1 | 1003 | LISSE | 6.25535 | 6.21877 | 0.00079686 | 0.0007922 | 0.000684 | 0.28032 | 0.266785 | 1165
LISSE | 5002.5 | 33.0001 | 67445 | +4.420 | +5.585 | 1174 | L42 | 1 | 1003 | LISSE | 6.25535 | 6.21877 | 0.00079686 | 0.0007922 | 0.000684 | 0.28032 | 0.266785 | 1165
BUTON | 10124.8 | 51273.3 | 29361.1 | +10.094 | +10.156 | 1182 | B10 | 2 | 2004 | BUTON | 13.5345 | 13.4553 | 0.00172414 | 0.00171405 | 0 | 0.60568 | 0.577233 | 2520.67
BUTON | 10124.8 | 65166.7 | 29361.1 | +10.094 | +10.156 | 1182 | B10 | 2 | 2004 | BUTON | 13.5345 | 13.4553 | 0.00172414 | 0.00171405 | 0 | 0.60568 | 0.577233 | 2520.67
BUTON | 10322.2 | 51298.3 | 22993.6 | +10.291 | +10.353 | 1183 | B11 | 2 | 2004 | BUTON | 13.266 | 13.1884 | 0.00168994 | 0.00168005 | 0 | 0.59368 | 0.565783 | 2470.67
BUTON | 10322.2 | 65166.7 | 22993.6 | +10.291 | +10.353 | 1182 | B10 | 2 | 2004 | BUTON | 13.5345 | 13.4553 | 0.00172414 | 0.00171405 | 0 | 0.60568 | 0.577233 | 2520.67
 | 4853.5 | 10980 | 20745 | +3.817 | +5.890 | 1180 | N49 | 2 | 2006 |  | 11.1308 | 11.0657 | 0.00141793 | 0.00140964 | 0.000684 | 0.49824 | 0.474717 | 2073
LISSE | 4760 | 46850.2 | 20745 | +4.730 | +4.790 | 1181 | N46 | 2 | 2006 | LISSE | 13.4423 | 13.3637 | 0.00171239 | 0.00170238 | 0.15021 | 0.60156 | 0.573302 | 2503.5
 | 5340 | 47931.5 | 20745 | +4.790 | +5.890 | 1179 | N46 | 2 | 2006 |  | 5.90634 | 5.8718 | 0.0007524 | 0.000748 | 0.000684 | 0.26472 | 0.2519 | 1100
LINTEAU | 2130 | 20670 | 78835 | +2.100 | +2.160 | 1170 | L39 | 7 | 7001 | LINTEAU | 4.69286 | 4.66541 | 0.000597816 | 0.00059432 | 0.05244 | 0.21048 | 0.200146 | 874
LINTEAU | 3145.98 | 20670 | 78835 | +3.116 | +3.176 | 1169 | L38 | 7 | 7001 | LINTEAU | 4.69286 | 4.66541 | 0.000597816 | 0.00059432 | 0.05244 | 0.21048 | 0.200146 | 874

# IfcBeam: TUBE-C-70*70*3 (61)
In: Undefined
Description: TUBE-C-70*70*3
Tekla Common - Finish: GRENAILLE-PEINT; Profile: TUBE-C-70*70*3; sets with these values: 2
Tekla Quantity - Area per tons: 42.8344 m2; Height: 70 mm; Width: 70 mm; sets with these values: 2
Name | Material | Center of gravity Z (mm) | Center of gravity Y (mm) | Center of gravity X (mm) | Bottom elevation | Top elevation | Part mark | Assembly mark | Phase | Class | Grade | Name | Net weight (kg) = NetWeight (kg) | Gross weight (kg) = Weight (kg) | Net volume (m3) = NetVolume (m3) | Gross volume (m3) | Gross footprint area (m2) | Net surface area (m2) | Gross area (m2) = OuterSurfaceArea (m2) | Tekla Quantity, Length (mm) = BaseQuantities, Length (mm)
LISSE | STEEL/E24-2 | 3150.98 | 20120 | 78290 | +3.116 | +3.186 | 929 | L110 | 7 | 7001 | E24-2 | LISSE | 7.22024 | 7.18432 | 0.000919776 | 0.0009152 | 0.08008 | 0.32116 | 0.307736 | 1144
LISSE | STEEL/E24-2 | 3695.29 | 20841.7 | 78290 | +3.660 | +3.730 | 930 | L109 | 7 | 7001 | E24-2 | LISSE | 12.7562 | 12.6927 | 0.00162499 | 0.0016169 | 0.141479 | 0.566756 | 0.543684 | 2021.13
MONTANT | STEEL/E24-2 | 4201.89 | 27915 | 55032.6 | +4.088 | +4.316 | 911 | M21 | 4 | 4001 | E24-2 | MONTANT | 8.23283 | 8.21872 | 0.00104877 | 0.00104697 | 0 | 0.366086 | 0.352044 | 1308.71
MONTANT | STEEL/E24-2 | 5423 | 27915 | 57202.5 | +5.245 | +5.601 | 913 | M20 | 4 | 4001 | E24-2 | MONTANT | 14.7823 | 14.7088 | 0.0018831 | 0.00187373 | 0 | 0.656646 | 0.630043 | 2342.17
MONTANT | STEEL/E24-2 | 3535 | 27915 | 56375 | +3.500 | +3.570 | 910 | M19 | 4 | 4001 | E24-2 | MONTANT | 24.2989 | 24.178 | 0.0030954 | 0.00308 | 0.2695 | 1.07884 | 1.03565 | 3850
MONTANT | STEEL/E24-2 | 5423 | 23985 | 57202.5 | +5.245 | +5.601 | 913 | M20 | 4 | 4001 | E24-2 | MONTANT | 14.7823 | 14.7088 | 0.0018831 | 0.00187373 | 0 | 0.656646 | 0.630043 | 2342.17
MONTANT | STEEL/E24-2 | 3535 | 23985 | 56375 | +3.500 | +3.570 | 910 | M19 | 4 | 4001 | E24-2 | MONTANT | 24.2989 | 24.178 | 0.0030954 | 0.00308 | 0.2695 | 1.07884 | 1.03565 | 3850
LISSE | STEEL/E24-2 | 4352 | 67806.8 | 44030 | +4.317 | +4.387 | 928 | L79 | 4 | 4001 | E24-2 | LISSE | 16.451 | 16.3691 | 0.00209567 | 0.00208524 | 0.182458 | 0.730674 | 0.701162 | 2606.55
LISSE | STEEL/E24-2 | 4352 | 62440 | 44030 | +4.317 | +4.387 | 927 | L78 | 4 | 4001 | E24-2 | LISSE | 16.0313 | 15.9515 | 0.0020422 | 0.00203204 | 0.177804 | 0.712054 | 0.683273 | 2540.05
LISSE | STEEL/E24-2 | 4282 | 59715.5 | 44030 | +4.247 | +4.317 | 926 | L77 | 4 | 4001 | E24-2 | LISSE | 15.267 | 15.191 | 0.00194484 | 0.00193516 | 0.169327 | 0.678146 | 0.650698 | 2418.95
LISSE | STEEL/E24-2 | 4352 | 65106.8 | 44030 | +4.317 | +4.387 | 925 | L76 | 4 | 4001 | E24-2 | LISSE | 16.451 | 16.3691 | 0.00209567 | 0.00208524 | 0.182459 | 0.730674 | 0.701162 | 2606.55
LISSE | STEEL/E24-2 | 4352 | 57156.8 | 44030 | +4.317 | +4.387 | 921 | L72 | 4 | 4001 | E24-2 | LISSE | 15.8198 | 15.7411 | 0.00201527 | 0.00200524 | 0.175458 | 0.702674 | 0.674262 | 2506.55
LISSE | STEEL/E24-2 | 4352 | 54556.8 | 44030 | +4.317 | +4.387 | 921 | L72 | 4 | 4001 | E24-2 | LISSE | 15.8198 | 15.7411 | 0.00201527 | 0.00200524 | 0.175458 | 0.702674 | 0.674262 | 2506.55
LISSE | STEEL/E24-2 | 4352 | 51956.8 | 44030 | +4.317 | +4.387 | 921 | L72 | 4 | 4001 | E24-2 | LISSE | 15.8198 | 15.7411 | 0.00201527 | 0.00200524 | 0.175458 | 0.702674 | 0.674262 | 2506.55
LISSE | STEEL/E24-2 | 4352 | 49356.8 | 44030 | +4.317 | +4.387 | 921 | L72 | 4 | 4001 | E24-2 | LISSE | 15.8198 | 15.7411 | 0.00201527 | 0.00200524 | 0.175458 | 0.702674 | 0.674262 | 2506.55
LISSE | STEEL/E24-2 | 4352 | 46756.8 | 44030 | +4.317 | +4.387 | 921 | L72 | 4 | 4001 | E24-2 | LISSE | 15.8198 | 15.7411 | 0.00201527 | 0.00200524 | 0.175458 | 0.702674 | 0.674262 | 2506.55
LISSE | STEEL/E24-2 | 4352 | 44156.8 | 44030 | +4.317 | +4.387 | 921 | L72 | 4 | 4001 | E24-2 | LISSE | 15.8198 | 15.7411 | 0.00201527 | 0.00200524 | 0.175458 | 0.702674 | 0.674262 | 2506.55
LISSE | STEEL/E24-2 | 4282 | 41582 | 44030 | +4.247 | +4.317 | 924 | L75 | 4 | 4001 | E24-2 | LISSE | 15.2985 | 15.2224 | 0.00194886 | 0.00193916 | 0.169676 | 0.679546 | 0.652042 | 2423.95
LISSE | STEEL/E24-2 | 4352 | 38918 | 44030 | +4.317 | +4.387 | 923 | L74 | 4 | 4001 | E24-2 | LISSE | 15.2985 | 15.2224 | 0.00194886 | 0.00193916 | 0.169677 | 0.679546 | 0.652043 | 2423.95
LISSE | STEEL/E24-2 | 4352 | 36356.8 | 44030 | +4.317 | +4.387 | 921 | L72 | 4 | 4001 | E24-2 | LISSE | 15.8198 | 15.7411 | 0.00201527 | 0.00200524 | 0.175458 | 0.702674 | 0.674262 | 2506.55
LISSE | STEEL/E24-2 | 4352 | 33756.8 | 44030 | +4.317 | +4.387 | 921 | L72 | 4 | 4001 | E24-2 | LISSE | 15.8198 | 15.7411 | 0.00201527 | 0.00200524 | 0.175458 | 0.702674 | 0.674262 | 2506.55
LISSE | STEEL/E24-2 | 4352 | 31156.8 | 44030 | +4.317 | +4.387 | 921 | L72 | 4 | 4001 | E24-2 | LISSE | 15.8198 | 15.7411 | 0.00201527 | 0.00200524 | 0.175458 | 0.702674 | 0.674262 | 2506.55
LISSE | STEEL/E24-2 | 4352 | 28556.8 | 44030 | +4.317 | +4.387 | 921 | L72 | 4 | 4001 | E24-2 | LISSE | 15.8198 | 15.7411 | 0.00201527 | 0.00200524 | 0.175458 | 0.702674 | 0.674262 | 2506.55
LISSE | STEEL/E24-2 | 4352 | 25956.8 | 44030 | +4.317 | +4.387 | 921 | L72 | 4 | 4001 | E24-2 | LISSE | 15.8198 | 15.7411 | 0.00201527 | 0.00200524 | 0.175458 | 0.702674 | 0.674262 | 2506.55
LISSE | STEEL/E24-2 | 4282 | 20788.5 | 44030 | +4.247 | +4.317 | 922 | L73 | 4 | 4001 | E24-2 | LISSE | 15.3812 | 15.3047 | 0.00195939 | 0.00194964 | 0.170594 | 0.683214 | 0.655566 | 2437.05
LISSE | STEEL/E24-2 | 4352 | 23356.8 | 44030 | +4.317 | +4.387 | 921 | L72 | 4 | 4001 | E24-2 | LISSE | 15.8198 | 15.7411 | 0.00201527 | 0.00200524 | 0.175459 | 0.702674 | 0.674262 | 2506.55
LISSE | STEEL/E24-2 | 4352 | 18236.8 | 44030 | +4.317 | +4.387 | 920 | L71 | 4 | 4001 | E24-2 | LISSE | 13.7999 | 13.7312 | 0.00175795 | 0.0017492 | 0.153055 | 0.61306 | 0.588169 | 2186.5
LISSE | STEEL/E24-2 | 4352 | 15916.8 | 44030 | +4.317 | +4.387 | 919 | L70 | 4 | 4001 | E24-2 | LISSE | 14.3051 | 14.2339 | 0.00182231 | 0.00181324 | 0.158658 | 0.635474 | 0.609702 | 2266.55
LISSE | STEEL/E24-2 | 4352 | 13556.8 | 44030 | +4.317 | +4.387 | 919 | L70 | 4 | 4001 | E24-2 | LISSE | 14.3051 | 14.2339 | 0.00182231 | 0.00181324 | 0.158658 | 0.635474 | 0.609702 | 2266.55
LISSE | STEEL/E24-2 | 3635 | 66697.5 | 44030 | +3.600 | +3.670 | 906 | L65 | 4 | 4001 | E24-2 | LISSE | 33.7537 | 33.5858 | 0.00429984 | 0.00427845 | 0.374364 | 1.4983 | 1.43863 | 5348.06
LISSE | STEEL/E24-2 | 3635 | 61549.5 | 44030 | +3.600 | +3.670 | 904 | L64 | 4 | 4001 | E24-2 | LISSE | 31.0272 | 30.8729 | 0.00395251 | 0.00393285 | 0.344124 | 1.37734 | 1.32242 | 4916.06
LISSE | STEEL/E24-2 | 3635 | 56299.5 | 44030 | +3.600 | +3.670 | 902 | L62 | 4 | 4001 | E24-2 | LISSE | 35.0405 | 34.8662 | 0.00446376 | 0.00444155 | 0.388636 | 1.55538 | 1.49347 | 5551.94
LISSE | STEEL/E24-2 | 3635 | 50915.5 | 44030 | +3.600 | +3.670 | 901 | L61 | 4 | 4001 | E24-2 | LISSE | 32.7183 | 32.5555 | 0.00416794 | 0.0041472 | 0.36288 | 1.45236 | 1.3945 | 5184
LISSE | STEEL/E24-2 | 3635 | 45715.5 | 44030 | +3.600 | +3.670 | 901 | L61 | 4 | 4001 | E24-2 | LISSE | 32.7183 | 32.5555 | 0.00416794 | 0.0041472 | 0.36288 | 1.45236 | 1.3945 | 5184
LISSE | STEEL/E24-2 | 3635 | 40699.5 | 44030 | +3.600 | +3.670 | 903 | L63 | 4 | 4001 | E24-2 | LISSE | 30.3961 | 30.2449 | 0.00387211 | 0.00385285 | 0.337124 | 1.34934 | 1.29552 | 4816.06
LISSE | STEEL/E24-2 | 3635 | 35499.5 | 44030 | +3.600 | +3.670 | 902 | L62 | 4 | 4001 | E24-2 | LISSE | 35.0405 | 34.8662 | 0.00446376 | 0.00444155 | 0.388636 | 1.55538 | 1.49347 | 5551.94
LISSE | STEEL/E24-2 | 3635 | 30115.5 | 44030 | +3.600 | +3.670 | 901 | L61 | 4 | 4001 | E24-2 | LISSE | 32.7183 | 32.5555 | 0.00416794 | 0.0041472 | 0.36288 | 1.45236 | 1.3945 | 5184
LISSE | STEEL/E24-2 | 3635 | 24915.5 | 44030 | +3.600 | +3.670 | 901 | L61 | 4 | 4001 | E24-2 | LISSE | 32.7183 | 32.5555 | 0.00416794 | 0.0041472 | 0.36288 | 1.45236 | 1.3945 | 5184
LISSE | STEEL/E24-2 | 3635 | 19835.5 | 44030 | +3.600 | +3.670 | 900 | L60 | 4 | 4001 | E24-2 | LISSE | 31.2036 | 31.0483 | 0.00397498 | 0.0039552 | 0.34608 | 1.38516 | 1.32994 | 4944
LISSE | STEEL/E24-2 | 3635 | 14995.5 | 44030 | +3.600 | +3.670 | 899 | L59 | 4 | 4001 | E24-2 | LISSE | 29.6888 | 29.5411 | 0.00378202 | 0.0037632 | 0.32928 | 1.31796 | 1.26538 | 4704
CV | STEEL/E24-2 | 3093.88 | -1342.6 | 22796 | +3.044 | +3.144 | 895 | W7 | 3 | 3003 | E24-2 | CV | 25.1779 | 25.0527 | 0.00320738 | 0.00319142 | 0 | 1.11784 | 1.07312 | 3989.28
LISSE | STEEL/S235JR | 5522.59 | 13474 | 77308.6 | +5.434 | +5.611 | 894 | L105 | 1 | 1003 | S235JR | LISSE | 21.6903 | 21.5824 | 0.00276309 | 0.00274935 | 0 | 0.963111 | 0.924468 | 3436.69
LISSE | STEEL/E24-2 | 3635 | 1293.75 | 44030 | +3.600 | +3.670 | 896 | L56 | 4 | 4001 | E24-2 | LISSE | 19.1078 | 19.0127 | 0.00243411 | 0.002422 | 0.211925 | 0.84854 | 0.814397 | 3027.5
LISSE | STEEL/E24-2 | 4352 | 1275 | 44030 | +4.317 | +4.387 | 915 | L66 | 4 | 4001 | E24-2 | LISSE | 15.5892 | 15.5116 | 0.00198588 | 0.001976 | 0.1729 | 0.69244 | 0.66443 | 2470
LISSE | STEEL/E24-2 | 3635 | 5336.25 | 44030 | +3.600 | +3.670 | 897 | L57 | 4 | 4001 | E24-2 | LISSE | 31.7179 | 31.5601 | 0.0040405 | 0.0040204 | 0.351785 | 1.40798 | 1.35186 | 5025.5
LISSE | STEEL/E24-2 | 4352 | 3832.5 | 44030 | +4.317 | +4.387 | 916 | L67 | 4 | 4001 | E24-2 | LISSE | 15.5134 | 15.4362 | 0.00197623 | 0.0019664 | 0.17206 | 0.68908 | 0.661202 | 2458
LISSE | STEEL/E24-2 | 4282 | 6346.75 | 44030 | +4.247 | +4.317 | 917 | L68 | 4 | 4001 | E24-2 | LISSE | 15.0622 | 14.9872 | 0.00191875 | 0.0019092 | 0.167055 | 0.66906 | 0.641969 | 2386.5
LISSE | STEEL/E24-2 | 4352 | 8865.75 | 44030 | +4.317 | +4.387 | 918 | L69 | 4 | 4001 | E24-2 | LISSE | 13.9577 | 13.8882 | 0.00177805 | 0.0017692 | 0.154805 | 0.62006 | 0.594894 | 2211.5
LISSE | STEEL/E24-2 | 3635 | 10246.3 | 44030 | +3.600 | +3.670 | 898 | L58 | 4 | 4001 | E24-2 | LISSE | 30.058 | 29.9085 | 0.00382905 | 0.00381 | 0.333375 | 1.33434 | 1.28111 | 4762.5
LISSE | STEEL/E24-2 | 4352 | 11196.8 | 44030 | +4.317 | +4.387 | 919 | L70 | 4 | 4001 | E24-2 | LISSE | 14.3051 | 14.2339 | 0.00182231 | 0.00181324 | 0.158659 | 0.635474 | 0.609702 | 2266.55
LISSE | STEEL/E24-2 | 4203.38 | 25950 | 54410 | +4.168 | +4.238 | 907 | L19 | 4 | 4001 | E24-2 | LISSE | 24.8038 | 25.12 | 0.00315972 | 0.0032 | 0.28 | 1.10159 | 1.076 | 4000
LISSE | STEEL/E24-2 | 3534.62 | 25950 | 54410 | +3.500 | +3.570 | 907 | L19 | 4 | 4001 | E24-2 | LISSE | 24.8038 | 25.12 | 0.00315972 | 0.0032 | 0.2702 | 1.10159 | 1.076 | 4000
LISSE | STEEL/E24-2 | 3869 | 27917.2 | 54410 | +3.500 | +4.238 | 905 | L19 | 4 | 4001 | E24-2 | LISSE | 4.21602 | 4.63464 | 0.000537072 | 0.0005904 | 0 | 0.188228 | 0.198522 | 738
LISSE | STEEL/E24-2 | 3869 | 23982.8 | 54410 | +3.500 | +4.238 | 905 | L19 | 4 | 4001 | E24-2 | LISSE | 4.21602 | 4.63464 | 0.000537072 | 0.0005904 | 0 | 0.188228 | 0.198522 | 738
LISSE | STEEL/E24-2 | 3534.62 | 25950 | 58340 | +3.500 | +3.570 | 907 | L18 | 4 | 4001 | E24-2 | LISSE | 24.8038 | 25.12 | 0.00315972 | 0.0032 | 0.2702 | 1.10159 | 1.076 | 4000
LISSE | STEEL/E24-2 | 5113.38 | 25950 | 58340 | +5.078 | +5.148 | 907 | L18 | 4 | 4001 | E24-2 | LISSE | 24.8038 | 25.12 | 0.00315972 | 0.0032 | 0.28 | 1.10159 | 1.076 | 4000
MONTANT | STEEL/E24-2 | 4741.1 | 23985 | 55985 | +3.880 | +5.602 | 909 | M17 | 4 | 4001 | E24-2 | MONTANT | 10.8695 | 10.8154 | 0.00138465 | 0.00137776 | 0.000804 | 0.483056 | 0.463272 | 1722.2
MONTANT | STEEL/E24-2 | 4088.5 | 23985 | 55715 | +3.880 | +4.297 | 914 | M22 | 4 | 4001 | E24-2 | MONTANT | 2.63185 | 2.61876 | 0.000335268 | 0.0003336 | 0.000804 | 0.1176 | 0.112173 | 417
MONTANT | STEEL/E24-2 | 4201.89 | 23985 | 55032.6 | +4.088 | +4.316 | 912 | M22 | 4 | 4001 | E24-2 | MONTANT | 8.23283 | 8.21872 | 0.00104877 | 0.00104697 | 0 | 0.366086 | 0.352044 | 1308.71
LISSE | STEEL/E24-2 | 135 | 20120 | 78290 | +0.100 | +0.170 | 929 | L110 | 7 | 7001 | E24-2 | LISSE | 7.22024 | 7.18432 | 0.000919776 | 0.0009152 | 0.08008 | 0.32116 | 0.307736 | 1144
LISSE | STEEL/E24-2 | 1785 | 20120 | 78290 | +1.750 | +1.820 | 929 | L110 | 7 | 7001 | E24-2 | LISSE | 7.22024 | 7.18432 | 0.000919776 | 0.0009152 | 0.08008 | 0.32116 | 0.307736 | 1144

# IfcBeam: TUBE-C-80*80*3 (36)
In: Undefined
Description: TUBE-C-80*80*3; Material: STEEL/E24-2
Tekla Common - Finish: GRENAILLE-PEINT; Grade: E24-2; Profile: TUBE-C-80*80*3; sets with these values: 2
Tekla Quantity - Area per tons: 42.8325 m2; Height: 80 mm; Width: 80 mm; sets with these values: 2
Name | Center of gravity Z (mm) | Center of gravity Y (mm) | Center of gravity X (mm) | Bottom elevation | Top elevation | Part mark | Assembly mark | Phase | Class | Name | Net weight (kg) = NetWeight (kg) | Gross weight (kg) = Weight (kg) | Net volume (m3) = NetVolume (m3) | Gross volume (m3) | Gross footprint area (m2) | Net surface area (m2) | Gross area (m2) = OuterSurfaceArea (m2) | Tekla Quantity, Length (mm) = BaseQuantities, Length (mm)
SUSPENTE | 3296.98 | 24514.8 | 3234.92 | +3.040 | +3.518 | 468 | S88 | 6 | 6001 | SUSPENTE | 3.16419 | 3.44573 | 0.000403081 | 0.000438946 | 0 | 0.140754 | 0.147589 | 477.635
SUSPENTE | 3420.03 | 15190 | 649.941 | +3.128 | +3.713 | 467 | S8 | 6 | 6001 | SUSPENTE | 4.23646 | 4.22363 | 0.000539676 | 0.000538042 | 0 | 0.187861 | 0.180909 | 585.465
SUSPENTE | 3420.03 | 10930 | 649.941 | +3.128 | +3.713 | 467 | S8 | 6 | 6001 | SUSPENTE | 4.23646 | 4.22363 | 0.000539676 | 0.000538042 | 0 | 0.187861 | 0.180909 | 585.465
SUSPENTE | 3373.39 | 10930 | 3314.93 | +3.128 | +3.620 | 466 | S6 | 6 | 6001 | SUSPENTE | 3.55986 | 3.5507 | 0.000453485 | 0.000452318 | 0 | 0.158011 | 0.152085 | 492.185
BUTON | 4988.31 | 11189.7 | 77328 | +4.897 | +5.079 | 461 | B15 | 1 | 1002 | BUTON | 28.163 | 28.017 | 0.00358764 | 0.00356905 | 0 | 1.24343 | 1.20004 | 3883.62
BUTON | 5101.77 | 11190.3 | 73668 | +5.009 | +5.194 | 460 | B14 | 1 | 1002 | BUTON | 28.695 | 28.5397 | 0.00365541 | 0.00363563 | 0 | 1.2669 | 1.22243 | 3956.08
BUTON | 5044.36 | 12904.8 | 75520 | +5.003 | +5.086 | 459 | B13 | 1 | 1002 | BUTON | 6.11788 | 6.08478 | 0.000779348 | 0.000775132 | 0 | 0.270864 | 0.260626 | 843.451
BUTON | 3765.09 | 14591.6 | 75520 | +3.724 | +3.806 | 458 | B12 | 1 | 1002 | BUTON | 13.4709 | 13.3981 | 0.00171604 | 0.00170676 | 0 | 0.595261 | 0.573872 | 1857.19
BUTON | 2126.85 | 10599.7 | 79225 | +2.087 | +2.167 | 457 | B4 | 1 | 1002 | BUTON | 42.3674 | 42.3788 | 0.00539712 | 0.00539857 | 0.464591 | 1.87336 | 1.81519 | 5874.4
LISSE | 3080 | 12757.5 | 650 | +3.040 | +3.120 | 475 | L87 | 6 | 6001 | LISSE | 35.1717 | 34.9814 | 0.00448048 | 0.00445623 | 0.38792 | 1.55264 | 1.49834 | 4849
LISSE | 3080 | 17320 | 650 | +3.040 | +3.120 | 472 | L84 | 6 | 6001 | LISSE | 30.7834 | 30.6169 | 0.00392146 | 0.00390024 | 0.33952 | 1.35904 | 1.3114 | 4244
LISSE | 3080 | 21981.3 | 650 | +3.040 | +3.120 | 473 | L85 | 6 | 6001 | LISSE | 36.6043 | 36.4062 | 0.00466297 | 0.00463773 | 0.40372 | 1.61584 | 1.55937 | 5046.5
LISSE | 3080 | 27043.8 | 650 | +3.040 | +3.120 | 473 | L85 | 6 | 6001 | LISSE | 36.6043 | 36.4062 | 0.00466297 | 0.00463773 | 0.40372 | 1.61584 | 1.55937 | 5046.5
LISSE | 3080 | 31527.5 | 650 | +3.040 | +3.120 | 464 | L81 | 6 | 6001 | LISSE | 28.2085 | 28.0558 | 0.00359344 | 0.00357399 | 0.31112 | 1.24544 | 1.2017 | 3889
LISSE | 3080 | 12607.5 | 3315 | +3.040 | +3.120 | 474 | L86 | 6 | 6001 | LISSE | 37.3478 | 37.1457 | 0.00475768 | 0.00473193 | 0.41192 | 1.64864 | 1.59104 | 5149
LISSE | 3080 | 17320 | 3315 | +3.040 | +3.120 | 472 | L84 | 6 | 6001 | LISSE | 30.7834 | 30.6169 | 0.00392146 | 0.00390024 | 0.33952 | 1.35904 | 1.3114 | 4244
LISSE | 3080 | 21856.2 | 3315 | +3.040 | +3.120 | 471 | L83 | 6 | 6001 | LISSE | 34.7909 | 34.6027 | 0.00443197 | 0.00440798 | 0.38372 | 1.53584 | 1.48212 | 4796.5
SUSPENTE | 3320.72 | 13060 | 6324.91 | +3.128 | +3.515 | 465 | S3 | 6 | 6001 | SUSPENTE | 2.79571 | 2.79069 | 0.000356142 | 0.000355501 | 0 | 0.124299 | 0.119532 | 386.835
SUSPENTE | 3373.39 | 13060 | 3314.93 | +3.128 | +3.620 | 466 | S5 | 6 | 6001 | SUSPENTE | 3.55986 | 3.5507 | 0.000453485 | 0.000452318 | 0 | 0.158011 | 0.152085 | 492.185
LISSE | 3080 | 12547.5 | 6325 | +3.040 | +3.120 | 470 | L82 | 6 | 6001 | LISSE | 36.4773 | 36.28 | 0.0046468 | 0.00462165 | 0.40232 | 1.61024 | 1.55396 | 5029
SUSPENTE | 3420.03 | 13060 | 649.941 | +3.128 | +3.713 | 467 | S7 | 6 | 6001 | SUSPENTE | 4.23646 | 4.22363 | 0.000539676 | 0.000538042 | 0 | 0.187861 | 0.180909 | 585.465
SUSPENTE | 3320.72 | 10930 | 6324.91 | +3.128 | +3.515 | 465 | S4 | 6 | 6001 | SUSPENTE | 2.79571 | 2.79069 | 0.000356142 | 0.000355501 | 0 | 0.124299 | 0.119532 | 386.835
SUSPENTE | 3373.39 | 15190 | 3314.93 | +3.128 | +3.620 | 466 | S6 | 6 | 6001 | SUSPENTE | 3.55986 | 3.5507 | 0.000453485 | 0.000452318 | 0 | 0.158011 | 0.152085 | 492.185
SUSPENTE | 3373.39 | 17320 | 3314.93 | +3.128 | +3.620 | 466 | S5 | 6 | 6001 | SUSPENTE | 3.55986 | 3.5507 | 0.000453485 | 0.000452318 | 0 | 0.158011 | 0.152085 | 492.185
SUSPENTE | 3420.03 | 17320 | 649.941 | +3.128 | +3.713 | 467 | S7 | 6 | 6001 | SUSPENTE | 4.23646 | 4.22363 | 0.000539676 | 0.000538042 | 0 | 0.187861 | 0.180909 | 585.465
SUSPENTE | 3420.03 | 19450 | 649.941 | +3.128 | +3.713 | 467 | S8 | 6 | 6001 | SUSPENTE | 4.23646 | 4.22363 | 0.000539676 | 0.000538042 | 0 | 0.187861 | 0.180909 | 585.465
SUSPENTE | 3373.39 | 19450 | 3314.93 | +3.128 | +3.620 | 466 | S6 | 6 | 6001 | SUSPENTE | 3.55986 | 3.5507 | 0.000453485 | 0.000452318 | 0 | 0.158011 | 0.152085 | 492.185
SUSPENTE | 3420.03 | 21981.2 | 649.941 | +3.128 | +3.713 | 467 | S7 | 6 | 6001 | SUSPENTE | 4.23646 | 4.22363 | 0.000539676 | 0.000538042 | 0 | 0.187861 | 0.180909 | 585.465
SUSPENTE | 3373.39 | 21981.2 | 3314.93 | +3.128 | +3.620 | 466 | S5 | 6 | 6001 | SUSPENTE | 3.55986 | 3.5507 | 0.000453485 | 0.000452318 | 0 | 0.158011 | 0.152085 | 492.185
SUSPENTE | 3420.03 | 24512.5 | 649.941 | +3.128 | +3.713 | 467 | S8 | 6 | 6001 | SUSPENTE | 4.23646 | 4.22363 | 0.000539676 | 0.000538042 | 0 | 0.187861 | 0.180909 | 585.465
SUSPENTE | 3420.03 | 29575 | 649.941 | +3.128 | +3.713 | 469 | S9 | 6 | 6001 | SUSPENTE | 4.23646 | 4.22363 | 0.000539676 | 0.000538042 | 0 | 0.187861 | 0.180909 | 585.465
SUSPENTE | 3420.03 | 27043.8 | 649.941 | +3.128 | +3.713 | 469 | S10 | 6 | 6001 | SUSPENTE | 4.23646 | 4.22363 | 0.000539676 | 0.000538042 | 0 | 0.187861 | 0.180909 | 585.465
SUSPENTE | 3420.03 | 32243.8 | 649.941 | +3.128 | +3.713 | 469 | S10 | 6 | 6001 | SUSPENTE | 4.23646 | 4.22363 | 0.000539676 | 0.000538042 | 0 | 0.187861 | 0.180909 | 585.465
SUSPENTE | 3296.98 | 15192.3 | 6244.92 | +3.040 | +3.518 | 468 | S87 | 6 | 6001 | SUSPENTE | 3.16419 | 3.44573 | 0.000403081 | 0.000438946 | 0 | 0.140754 | 0.147589 | 477.635
LISSE | 3078.33 | 24217.3 | 3235 | +3.040 | +3.120 | 463 | S88 | 6 | 6001 | LISSE | 4.29401 | 4.55934 | 0.000547008 | 0.000580808 | 0.04416 | 0.190599 | 0.195288 | 632
LISSE | 3077.86 | 14960.1 | 6245 | +3.040 | +3.120 | 462 | S87 | 6 | 6001 | LISSE | 3.35107 | 3.6215 | 0.000426888 | 0.000461338 | 0.03376 | 0.148999 | 0.155118 | 502

# IfcBeam: TUBE-C-90*90*3 (37)
In: Undefined
Description: TUBE-C-90*90*3
Tekla Common - Finish: GRENAILLE-PEINT; Profile: TUBE-C-90*90*3; sets with these values: 2
Tekla Quantity - Area per tons: 42.7076 m2; Height: 90 mm; Width: 90 mm; sets with these values: 2
Name | Material | Center of gravity Z (mm) | Center of gravity Y (mm) | Center of gravity X (mm) | Bottom elevation | Top elevation | Part mark | Assembly mark | Phase | Class | Grade | Name | Net weight (kg) = NetWeight (kg) | Gross weight (kg) = Weight (kg) | Net volume (m3) = NetVolume (m3) | Gross volume (m3) | Gross footprint area (m2) | Net surface area (m2) | Gross area (m2) = OuterSurfaceArea (m2) | Tekla Quantity, Length (mm) = BaseQuantities, Length (mm)
LISSE | STEEL/S235JR | 5822.95 | 69197 | 33091.2 | +5.751 | +5.890 | 977 | L106 | 3 | 3003 | S235JR | LISSE | 1.0979 | 1.13966 | 0.00013986 | 0.00014518 | 0.001044 | 0.0493115 | 0.0486721 | 139.462
LISSE | STEEL/S235JR | 5323.55 | 69197 | 39839.4 | +4.762 | +5.885 | 981 | L22 | 3 | 3003 | S235JR | LISSE | 69.7757 | 69.665 | 0.00888862 | 0.00887452 | 0 | 3.06613 | 2.97522 | 8525
LISSE | STEEL/S235JR | 5935 | 69197 | 38570 | +5.890 | +5.980 | 987 | L106 | 3 | 3003 | S235JR | LISSE | 92.1491 | 91.8843 | 0.0117387 | 0.011705 | 1.01196 | 4.04892 | 3.92416 | 11244
LISSE | STEEL/S235JR | 5935 | 69197 | 50037.5 | +5.890 | +5.980 | 991 | L98 | 1 | 1003 | S235JR | LISSE | 95.5502 | 95.2756 | 0.012172 | 0.012137 | 1.04931 | 4.19832 | 4.06899 | 11659
LISSE | STEEL/S235JR | 5323.55 | 69197 | 51514.4 | +4.762 | +5.885 | 981 | L22 | 1 | 1003 | S235JR | LISSE | 69.7757 | 69.665 | 0.00888862 | 0.00887452 | 0 | 3.06613 | 2.97522 | 8525
LISSE | STEEL/S235JR | 5935 | 69197 | 61712.5 | +5.890 | +5.980 | 991 | L98 | 1 | 1003 | S235JR | LISSE | 95.5502 | 95.2756 | 0.012172 | 0.012137 | 1.04931 | 4.19832 | 4.06899 | 11659
LISSE | STEEL/S235JR | 5323.55 | 69197 | 63189.4 | +4.762 | +5.885 | 981 | L22 | 1 | 1003 | S235JR | LISSE | 69.7757 | 69.665 | 0.00888862 | 0.00887452 | 0 | 3.06613 | 2.97522 | 8525
LISSE | STEEL/S235JR | 5845 | 37650 | 79090 | +5.800 | +5.890 | 995 | L99 | 1 | 1003 | S235JR | LISSE | 42.5341 | 42.4119 | 0.00541836 | 0.00540279 | 0.4671 | 1.86948 | 1.81131 | 5190
LISSE | STEEL/S235JR | 5845 | 45450 | 79090 | +5.800 | +5.890 | 986 | L94 | 1 | 1003 | S235JR | LISSE | 85.1502 | 84.9055 | 0.0108472 | 0.010816 | 0.9351 | 3.74148 | 3.62611 | 10390
LISSE | STEEL/S235JR | 5845 | 65146 | 79090 | +5.800 | +5.890 | 988 | L95 | 1 | 1003 | S235JR | LISSE | 67.0548 | 66.8621 | 0.00854201 | 0.00851746 | 0.73638 | 2.9466 | 2.85552 | 8182
LISSE | STEEL/S235JR | 5845 | 55850 | 79090 | +5.800 | +5.890 | 986 | L94 | 1 | 1003 | S235JR | LISSE | 85.1502 | 84.9055 | 0.0108472 | 0.010816 | 0.9351 | 3.74148 | 3.62611 | 10390
LISSE | STEEL/S235JR | 5478.82 | 3828 | 79090 | +5.434 | +5.524 | 985 | L93 | 1 | 1003 | S235JR | LISSE | 62.5637 | 62.3839 | 0.0079699 | 0.00794699 | 0.68706 | 2.74932 | 2.66427 | 7634
LISSE | STEEL/S235JR | 5478.82 | 10600 | 79090 | +5.434 | +5.524 | 994 | L88 | 1 | 1003 | S235JR | LISSE | 48.2709 | 48.1322 | 0.00614916 | 0.00613149 | 0.5301 | 2.12148 | 2.05561 | 5890
LISSE | STEEL/S235JR | 5845 | 3828 | 79090 | +5.800 | +5.890 | 985 | L93 | 1 | 1003 | S235JR | LISSE | 62.5637 | 62.3839 | 0.0079699 | 0.00794699 | 0.68706 | 2.74932 | 2.66427 | 7634
LISSE | STEEL/S235JR | 5845 | 10600 | 79090 | +5.800 | +5.890 | 994 | L90 | 1 | 1003 | S235JR | LISSE | 48.2709 | 48.1322 | 0.00614916 | 0.00613149 | 0.5301 | 2.12148 | 2.05561 | 5890
LISSE | STEEL/S235JR | 4171.04 | 16467.5 | 79090 | +4.126 | +4.216 | 993 | L89 | 1 | 1003 | S235JR | LISSE | 48.8036 | 48.6634 | 0.00621702 | 0.00619915 | 0.53595 | 2.14488 | 2.07829 | 5955
LISSE | STEEL/S235JR | 4171.04 | 22790 | 79090 | +4.126 | +4.216 | 984 | L92 | 1 | 1003 | S235JR | LISSE | 54.6633 | 54.5062 | 0.00696348 | 0.00694347 | 0.6003 | 2.40228 | 2.32783 | 6670
LISSE | STEEL/S235JR | 5845 | 29850 | 79090 | +5.800 | +5.890 | 986 | L94 | 1 | 1003 | S235JR | LISSE | 85.1502 | 84.9055 | 0.0108472 | 0.010816 | 0.9351 | 3.74148 | 3.62611 | 10390
LISSE | STEEL/S235JR | 5845 | 19100 | 79090 | +5.800 | +5.890 | 983 | L91 | 1 | 1003 | S235JR | LISSE | 90.887 | 90.6258 | 0.011578 | 0.0115447 | 0.9981 | 3.99348 | 3.87041 | 11090
LISSE | STEEL/S235JR | 5845 | -47 | 73439 | +5.800 | +5.890 | 998 | L55 | 1 | 1003 | S235JR | LISSE | 94.6237 | 94.3518 | 0.012054 | 0.0120193 | 1.03914 | 4.15762 | 4.02954 | 11546
LISSE | STEEL/S235JR | 5555.67 | -47 | 76566.8 | +5.429 | +5.683 | 996 | L100 | 1 | 1003 | S235JR | LISSE | 43.3999 | 43.2752 | 0.00552865 | 0.00551276 | 0 | 1.90751 | 1.84818 | 5295.64
LISSE | STEEL/S235JR | 5323.55 | -47 | 39839.4 | +4.762 | +5.885 | 980 | L21 | 3 | 3003 | S235JR | LISSE | 69.7757 | 69.665 | 0.00888862 | 0.00887452 | 0 | 3.06613 | 2.97522 | 8525
LISSE | STEEL/S235JR | 5935 | -47 | 38362.5 | +5.890 | +5.980 | 990 | L107 | 3 | 3003 | S235JR | LISSE | 95.5502 | 95.2756 | 0.012172 | 0.012137 | 1.04931 | 4.19832 | 4.06899 | 11659
LISSE | STEEL/S235JR | 5323.55 | -47 | 51514.4 | +4.762 | +5.885 | 980 | L21 | 1 | 1003 | S235JR | LISSE | 69.7757 | 69.665 | 0.00888862 | 0.00887452 | 0 | 3.06613 | 2.97522 | 8525
LISSE | STEEL/S235JR | 5935 | -47 | 50037.5 | +5.890 | +5.980 | 990 | L97 | 1 | 1003 | S235JR | LISSE | 95.5502 | 95.2756 | 0.012172 | 0.012137 | 1.04931 | 4.19832 | 4.06899 | 11659
LISSE | STEEL/S235JR | 5935 | -47 | 61712.5 | +5.890 | +5.980 | 990 | L97 | 1 | 1003 | S235JR | LISSE | 95.5502 | 95.2756 | 0.012172 | 0.012137 | 1.04931 | 4.19832 | 4.06899 | 11659
LISSE | STEEL/S235JR | 5323.55 | -47 | 63189.4 | +4.762 | +5.885 | 980 | L21 | 1 | 1003 | S235JR | LISSE | 69.7757 | 69.665 | 0.00888862 | 0.00887452 | 0 | 3.06613 | 2.97522 | 8525
LISSE | STEEL/S235JR | 5323.55 | -47 | 28164.4 | +4.762 | +5.885 | 997 | L24 | 3 | 3003 | S235JR | LISSE | 69.7757 | 69.665 | 0.00888862 | 0.00887452 | 0 | 3.06613 | 2.97522 | 8525
LISSE | STEEL/S235JR | 5935 | -47 | 26687.5 | +5.890 | +5.980 | 992 | L108 | 3 | 3003 | S235JR | LISSE | 95.5502 | 95.2756 | 0.012172 | 0.012137 | 1.04931 | 4.19832 | 4.06899 | 11659
LISSE | STEEL/S235JR | 5326.05 | 69197 | 74843.9 | +4.767 | +5.885 | 982 | L23 | 1 | 1003 | S235JR | LISSE | 69.4372 | 69.3275 | 0.0088455 | 0.00883153 | 0 | 3.05126 | 2.96081 | 8483.69
LISSE | STEEL/S235JR | 5935 | 69197 | 73342.5 | +5.890 | +5.980 | 989 | L96 | 1 | 1003 | S235JR | LISSE | 94.8126 | 94.5401 | 0.012078 | 0.0120433 | 1.04121 | 4.16592 | 4.03758 | 11569
BUTON | STEEL/E24-2 | 10227.5 | 54072.5 | 26177.5 | +10.181 | +10.274 | 979 | B9 | 2 | 2004 | E24-2 | BUTON | 22.4677 | 22.4031 | 0.00286213 | 0.0028539 | 0 | 0.98802 | 0.956784 | 2741.5
BUTON | STEEL/E24-2 | 10227.5 | 56837.5 | 26177.5 | +10.181 | +10.274 | 979 | B9 | 2 | 2004 | E24-2 | BUTON | 22.4677 | 22.4031 | 0.00286213 | 0.0028539 | 0 | 0.98802 | 0.956784 | 2741.5
BUTON | STEEL/E24-2 | 10227.5 | 59602.5 | 26177.5 | +10.181 | +10.274 | 979 | B9 | 2 | 2004 | E24-2 | BUTON | 22.4677 | 22.4031 | 0.00286213 | 0.0028539 | 0 | 0.98802 | 0.956784 | 2741.5
BUTON | STEEL/E24-2 | 10227.5 | 62367.5 | 26177.5 | +10.181 | +10.274 | 979 | B9 | 2 | 2004 | E24-2 | BUTON | 22.4677 | 22.4031 | 0.00286213 | 0.0028539 | 0 | 0.98802 | 0.956784 | 2741.5
BUTON | STEEL/E24-2 | 10227.5 | 65044.4 | 26177.5 | +10.181 | +10.274 | 978 | B6 | 2 | 2004 | E24-2 | BUTON | 21.0232 | 20.9628 | 0.00267812 | 0.00267042 | 0 | 0.92457 | 0.895272 | 2565.25
BUTON | STEEL/E24-2 | 10227.5 | 51395.6 | 26177.5 | +10.181 | +10.274 | 978 | B6 | 2 | 2004 | E24-2 | BUTON | 21.0232 | 20.9628 | 0.00267812 | 0.00267042 | 0 | 0.92457 | 0.895272 | 2565.25

# IfcBeam: UPF-100*50*4 (379)
In: Undefined
Description: UPF-100*50*4
Tekla Common - Profile: UPF-100*50*4; sets with these values: 2
Tekla Quantity - Height: 100 mm; sets with these values: 2
Name | Material | Center of gravity Z (mm) | Center of gravity Y (mm) | Center of gravity X (mm) | Bottom elevation | Top elevation | Part mark | Assembly mark | Phase | Class | Finish | Grade | Name | Net weight (kg) = Weight (kg) = NetWeight (kg) | Gross weight (kg) | Net volume (m3) = NetVolume (m3) | Gross volume (m3) | Gross footprint area (m2) | Area per tons (m2) | Net surface area (m2) = OuterSurfaceArea (m2) | Gross area (m2) | Width (mm) | Tekla Quantity, Length (mm) = BaseQuantities, Length (mm)
CHEVETRE | STEEL/S235JR | 4396.23 | 7261.02 | 32086.2 | +4.328 | +4.464 | 1155 | U11 | 3 | 3003 | GRENAILLE-PEINT | S235JR | CHEVETRE | 1.80864 | 1.80864 | 0.0002304 | 0.0002304 | 0 | 65.8705 | 0.119136 | 0.119136 | 50 | 300
CHEVETRE | STEEL/S235JR | 4416.11 | 6375 | 31923.4 | +4.365 | +4.470 | 1156 | U11 | 3 | 3003 | GRENAILLE-PEINT | S235JR | CHEVETRE | 14.4088 | 14.4088 | 0.00183552 | 0.00183552 | 0 | 65.1278 | 0.938416 | 0.938416 | 50 | 2390
CHEVETRE | STEEL/S235JR | 4376.35 | 6375 | 32248.9 | +4.322 | +4.428 | 1156 | U11 | 3 | 3003 | GRENAILLE-PEINT | S235JR | CHEVETRE | 14.4088 | 14.4088 | 0.00183552 | 0.00183552 | 0 | 65.1278 | 0.938416 | 0.938416 | 50 | 2390
CHEVETRE | STEEL/S235JR | 4396.23 | 19859 | 32086.2 | +4.328 | +4.464 | 1155 | U12 | 3 | 3003 | GRENAILLE-PEINT | S235JR | CHEVETRE | 1.80864 | 1.80864 | 0.0002304 | 0.0002304 | 0 | 65.8705 | 0.119136 | 0.119136 | 50 | 300
CHEVETRE | STEEL/S235JR | 4376.35 | 20760 | 32248.9 | +4.322 | +4.428 | 1157 | U12 | 3 | 3003 | GRENAILLE-PEINT | S235JR | CHEVETRE | 14.5897 | 14.5897 | 0.00185856 | 0.00185856 | 0 | 65.1265 | 0.950176 | 0.950176 | 50 | 2420
CHEVETRE | STEEL/S235JR | 4416.11 | 20760 | 31923.4 | +4.365 | +4.470 | 1157 | U12 | 3 | 3003 | GRENAILLE-PEINT | S235JR | CHEVETRE | 14.5897 | 14.5897 | 0.00185856 | 0.00185856 | 0 | 65.1265 | 0.950176 | 0.950176 | 50 | 2420
CHEVETRE | STEEL/S235JR | 4396.23 | 40659 | 32086.2 | +4.328 | +4.464 | 1155 | U12 | 3 | 3003 | GRENAILLE-PEINT | S235JR | CHEVETRE | 1.80864 | 1.80864 | 0.0002304 | 0.0002304 | 0 | 65.8705 | 0.119136 | 0.119136 | 50 | 300
CHEVETRE | STEEL/S235JR | 4376.35 | 41560 | 32248.9 | +4.322 | +4.428 | 1157 | U12 | 3 | 3003 | GRENAILLE-PEINT | S235JR | CHEVETRE | 14.5897 | 14.5897 | 0.00185856 | 0.00185856 | 0 | 65.1265 | 0.950176 | 0.950176 | 50 | 2420
CHEVETRE | STEEL/S235JR | 4416.11 | 41560 | 31923.4 | +4.365 | +4.470 | 1157 | U12 | 3 | 3003 | GRENAILLE-PEINT | S235JR | CHEVETRE | 14.5897 | 14.5897 | 0.00185856 | 0.00185856 | 0 | 65.1265 | 0.950176 | 0.950176 | 50 | 2420
CHEVETRE | STEEL/S235JR | 4428.23 | 59745 | 43499.1 | +4.377 | +4.482 | 1157 | U13 | 3 | 3003 | GRENAILLE-PEINT | S235JR | CHEVETRE | 14.5897 | 14.5897 | 0.00185856 | 0.00185856 | 0 | 65.1265 | 0.950176 | 0.950176 | 50 | 2420
CHEVETRE | STEEL/S235JR | 4402.29 | 60546 | 43711.5 | +4.328 | +4.476 | 1158 | U13 | 3 | 3003 | GRENAILLE-PEINT | S235JR | CHEVETRE | 2.4115 | 2.4115 | 0.000307198 | 0.000307198 | 0 | 65.6582 | 0.158335 | 0.158335 | 50 | 399.997
CHEVETRE | STEEL/S235JR | 4376.35 | 59745 | 43923.9 | +4.322 | +4.428 | 1157 | U13 | 3 | 3003 | GRENAILLE-PEINT | S235JR | CHEVETRE | 14.5897 | 14.5897 | 0.00185856 | 0.00185856 | 0 | 65.1265 | 0.950176 | 0.950176 | 50 | 2420
CHEVETRE | STEEL/S235JR | 4416.11 | 41560 | 43598.4 | +4.365 | +4.470 | 1157 | U12 | 3 | 3003 | GRENAILLE-PEINT | S235JR | CHEVETRE | 14.5897 | 14.5897 | 0.00185856 | 0.00185856 | 0 | 65.1265 | 0.950176 | 0.950176 | 50 | 2420
CHEVETRE | STEEL/S235JR | 4376.35 | 41560 | 43923.9 | +4.322 | +4.428 | 1157 | U12 | 3 | 3003 | GRENAILLE-PEINT | S235JR | CHEVETRE | 14.5897 | 14.5897 | 0.00185856 | 0.00185856 | 0 | 65.1265 | 0.950176 | 0.950176 | 50 | 2420
CHEVETRE | STEEL/S235JR | 4396.23 | 40659 | 43761.2 | +4.328 | +4.464 | 1155 | U12 | 3 | 3003 | GRENAILLE-PEINT | S235JR | CHEVETRE | 1.80864 | 1.80864 | 0.0002304 | 0.0002304 | 0 | 65.8705 | 0.119136 | 0.119136 | 50 | 300
CHEVETRE | STEEL/S235JR | 4416.11 | 20760 | 43598.4 | +4.365 | +4.470 | 1157 | U12 | 3 | 3003 | GRENAILLE-PEINT | S235JR | CHEVETRE | 14.5897 | 14.5897 | 0.00185856 | 0.00185856 | 0 | 65.1265 | 0.950176 | 0.950176 | 50 | 2420
CHEVETRE | STEEL/S235JR | 4376.35 | 20760 | 43923.9 | +4.322 | +4.428 | 1157 | U12 | 3 | 3003 | GRENAILLE-PEINT | S235JR | CHEVETRE | 14.5897 | 14.5897 | 0.00185856 | 0.00185856 | 0 | 65.1265 | 0.950176 | 0.950176 | 50 | 2420
CHEVETRE | STEEL/S235JR | 4396.23 | 19859 | 43761.2 | +4.328 | +4.464 | 1155 | U12 | 3 | 3003 | GRENAILLE-PEINT | S235JR | CHEVETRE | 1.80864 | 1.80864 | 0.0002304 | 0.0002304 | 0 | 65.8705 | 0.119136 | 0.119136 | 50 | 300
CHEVETRE | STEEL/S235JR | 4376.35 | 6375 | 43923.9 | +4.322 | +4.428 | 1156 | U11 | 3 | 3003 | GRENAILLE-PEINT | S235JR | CHEVETRE | 14.4088 | 14.4088 | 0.00183552 | 0.00183552 | 0 | 65.1278 | 0.938416 | 0.938416 | 50 | 2390
CHEVETRE | STEEL/S235JR | 4416.11 | 6375 | 43598.4 | +4.365 | +4.470 | 1156 | U11 | 3 | 3003 | GRENAILLE-PEINT | S235JR | CHEVETRE | 14.4088 | 14.4088 | 0.00183552 | 0.00183552 | 0 | 65.1278 | 0.938416 | 0.938416 | 50 | 2390
CHEVETRE | STEEL/S235JR | 4396.23 | 7261.02 | 43761.2 | +4.328 | +4.464 | 1155 | U11 | 3 | 3003 | GRENAILLE-PEINT | S235JR | CHEVETRE | 1.80864 | 1.80864 | 0.0002304 | 0.0002304 | 0 | 65.8705 | 0.119136 | 0.119136 | 50 | 300
CHEVETRE | STEEL/E24-2 | 3846.82 | 44387.5 | 4089.57 | +3.796 | +3.897 | 1146 | U6 | 2 | 2003 | GRENAILLE-PEINT | E24-2 | CHEVETRE | 15.6648 | 15.6648 | 0.00199552 | 0.00199552 | 0 | 65.1193 | 1.02008 | 1.02008 | 50 | 2598.33
CHEVETRE | STEEL/E24-2 | 3875.79 | 44387.5 | 3262.12 | +3.825 | +3.927 | 1146 | U6 | 2 | 2003 | GRENAILLE-PEINT | E24-2 | CHEVETRE | 15.6648 | 15.6648 | 0.00199552 | 0.00199552 | 0 | 65.1193 | 1.02008 | 1.02008 | 50 | 2598.33
CHEVETRE | STEEL/E24-2 | 3861.3 | 44651 | 3675.84 | +3.797 | +3.925 | 1145 | U6 | 2 | 2003 | GRENAILLE-PEINT | E24-2 | CHEVETRE | 4.82304 | 4.82304 | 0.000614399 | 0.000614399 | 0 | 65.3397 | 0.315136 | 0.315136 | 50 | 799.999
CHEVETRE | STEEL/E24-2 | 10496.9 | 59602.5 | 21037.3 | +10.446 | +10.547 | 1143 | U5 | 2 | 2003 | GRENAILLE-PEINT | E24-2 | CHEVETRE | 15.6447 | 15.6447 | 0.00199296 | 0.00199296 | 0 | 65.1194 | 1.01878 | 1.01878 | 50 | 2595
CHEVETRE | STEEL/E24-2 | 10508.6 | 59602.5 | 20659.6 | +10.458 | +10.560 | 1143 | U5 | 2 | 2003 | GRENAILLE-PEINT | E24-2 | CHEVETRE | 15.6447 | 15.6447 | 0.00199296 | 0.00199296 | 0 | 65.1194 | 1.01878 | 1.01878 | 50 | 2595
CHEVETRE | STEEL/E24-2 | 10502.8 | 60541 | 20848.5 | +10.447 | +10.558 | 1144 | U5 | 2 | 2003 | GRENAILLE-PEINT | E24-2 | CHEVETRE | 2.11006 | 2.11006 | 0.000268797 | 0.000268797 | 0 | 65.7492 | 0.138734 | 0.138734 | 50 | 349.996
CHEVETRE | STEEL/E24-2 | 10250.1 | 59602.5 | 28999.4 | +10.200 | +10.301 | 1143 | U1 | 2 | 2003 | GRENAILLE-PEINT | E24-2 | CHEVETRE | 15.6447 | 15.6447 | 0.00199296 | 0.00199296 | 0 | 65.1194 | 1.01878 | 1.01878 | 50 | 2595
CHEVETRE | STEEL/E24-2 | 10239.9 | 59602.5 | 29327.2 | +10.189 | +10.290 | 1143 | U1 | 2 | 2003 | GRENAILLE-PEINT | E24-2 | CHEVETRE | 15.6447 | 15.6447 | 0.00199296 | 0.00199296 | 0 | 65.1194 | 1.01878 | 1.01878 | 50 | 2595
CHEVETRE | STEEL/E24-2 | 10245 | 59801 | 29163.3 | +10.190 | +10.300 | 1142 | U1 | 2 | 2003 | GRENAILLE-PEINT | E24-2 | CHEVETRE | 1.80865 | 1.80865 | 0.000230401 | 0.000230401 | 0 | 65.8705 | 0.119137 | 0.119137 | 50 | 300.002
CHEVETRE | STEEL/E24-2 | 10245 | 60129 | 29163.3 | +10.190 | +10.300 | 1142 | U1 | 2 | 2003 | GRENAILLE-PEINT | E24-2 | CHEVETRE | 1.80865 | 1.80865 | 0.000230401 | 0.000230401 | 0 | 65.8705 | 0.119137 | 0.119137 | 50 | 300.002
ATTACHE | STEEL/E24-2 | 3407.81 | 32496.9 | 2455.1 | +3.370 | +3.420 | 1136 | L33 | 2 | 2003 | GRENAILLE-PEINT | E24-2 | ATTACHE | 0.822963 | 0.822963 | 0.000104836 | 0.000104836 | 0.015064 | 66.9472 | 0.055095 | 0.055095 | 50 | 150.64
ATTACHE | STEEL/E24-2 | 3418.98 | 31905.9 | 2472.39 | +2.939 | +3.906 | 1139 | L33 | 2 | 2003 | GRENAILLE-PEINT | E24-2 | ATTACHE | 5.54614 | 5.83286 | 0.000706515 | 0.000743039 | 0.00032 | 65.3605 | 0.362498 | 0.380795 | 50 | 967.499
ATTACHE | STEEL/E24-2 | 3418.98 | 34728 | 2465.21 | +2.939 | +3.906 | 1124 | L33 | 2 | 2003 | GRENAILLE-PEINT | E24-2 | ATTACHE | 5.54614 | 5.83286 | 0.000706515 | 0.000743039 | 0.00032 | 65.3605 | 0.362498 | 0.380795 | 50 | 967.499
LISSE | STEEL/E24-2 | 3896.02 | 30911.7 | 2522.32 | +3.860 | +3.910 | 1126 | L33 | 2 | 2003 | GRENAILLE-PEINT | E24-2 | LISSE | 14.9834 | 14.9834 | 0.00190871 | 0.00190871 | 0.24853 | 65.1239 | 0.975775 | 0.975775 | 4 | 2485.31
ATTACHE | STEEL/E24-2 | 3418.98 | 26855 | 2935.34 | +2.939 | +3.906 | 1124 | L37 | 2 | 2003 | GRENAILLE-PEINT | E24-2 | ATTACHE | 5.54614 | 5.83286 | 0.000706515 | 0.000743039 | 0.00032 | 65.3605 | 0.362498 | 0.380795 | 50 | 967.499
LISSE | STEEL/E24-2 | 3896.02 | 28309.3 | 2746.37 | +3.860 | +3.910 | 1127 | L37 | 2 | 2003 | GRENAILLE-PEINT | E24-2 | LISSE | 14.2314 | 14.2314 | 0.00181291 | 0.00181291 | 0.236056 | 65.1293 | 0.926878 | 0.926878 | 4 | 2360.57
ATTACHE | STEEL/E24-2 | 3181.8 | 32056.8 | 2468.57 | +2.939 | +3.420 | 1114 | L33 | 2 | 2003 | GRENAILLE-PEINT | E24-2 | ATTACHE | 2.69291 | 5.83286 | 0.000343045 | 0.000743039 | 0 | 65.6561 | 0.176806 | 0.380795 | 50 | 481.499
LISSE | STEEL/E24-2 | 3896.02 | 33576.8 | 2451.16 | +3.860 | +3.910 | 1125 | L33 | 2 | 2003 | GRENAILLE-PEINT | E24-2 | LISSE | 15.0039 | 15.0039 | 0.00191133 | 0.00191133 | 0.248871 | 65.1237 | 0.977112 | 0.977112 | 4 | 2488.72
ATTACHE | STEEL/E24-2 | 3418.98 | 29387.6 | 2630.48 | +2.939 | +3.906 | 1124 | L37 | 2 | 2003 | GRENAILLE-PEINT | E24-2 | ATTACHE | 5.54614 | 5.83286 | 0.000706515 | 0.000743039 | 0.00032 | 65.3605 | 0.362498 | 0.380795 | 50 | 967.499
ATTACHE | STEEL/E24-2 | 3393.97 | 24324 | 3389.27 | +2.939 | +3.856 | 1121 | L34 | 2 | 2003 | GRENAILLE-PEINT | E24-2 | ATTACHE | 5.2447 | 5.53142 | 0.000668115 | 0.000704639 | 0.00032 | 65.38 | 0.342898 | 0.361195 | 50 | 917.499
LISSE | STEEL/E24-2 | 3896.02 | 25780.4 | 3113.78 | +3.860 | +3.910 | 1128 | L37 | 2 | 2003 | GRENAILLE-PEINT | E24-2 | LISSE | 14.3007 | 14.3007 | 0.00182174 | 0.00182174 | 0.237206 | 65.1288 | 0.931384 | 0.931384 | 4 | 2372.07
ATTACHE | STEEL/E24-2 | 3363.95 | 19290.1 | 4755.96 | +2.939 | +3.796 | 1120 | L36 | 2 | 2003 | GRENAILLE-PEINT | E24-2 | ATTACHE | 4.88297 | 5.16969 | 0.000622035 | 0.000658559 | 0.00032 | 65.4065 | 0.319378 | 0.337675 | 50 | 857.499
LISSE | STEEL/E24-2 | 3846.02 | 20710.8 | 4309.92 | +3.810 | +3.860 | 1130 | L34 | 2 | 2003 | GRENAILLE-PEINT | E24-2 | LISSE | 14.6359 | 14.6359 | 0.00186444 | 0.00186444 | 0.242766 | 65.1263 | 0.95318 | 0.95318 | 4 | 2427.67
ATTACHE | STEEL/E24-2 | 3393.97 | 21793.6 | 3996.87 | +2.939 | +3.856 | 1121 | L34 | 2 | 2003 | GRENAILLE-PEINT | E24-2 | ATTACHE | 5.2447 | 5.53142 | 0.000668115 | 0.000704639 | 0.00032 | 65.38 | 0.342898 | 0.361195 | 50 | 917.499
LISSE | STEEL/E24-2 | 3846.02 | 23246.5 | 3633.18 | +3.810 | +3.860 | 1129 | L34 | 2 | 2003 | GRENAILLE-PEINT | E24-2 | LISSE | 14.4871 | 14.4871 | 0.00184549 | 0.00184549 | 0.240298 | 65.1274 | 0.943504 | 0.943504 | 4 | 2402.99
ATTACHE | STEEL/E24-2 | 3363.95 | 17135.7 | 5541.45 | +2.939 | +3.796 | 1120 | L36 | 2 | 2003 | GRENAILLE-PEINT | E24-2 | ATTACHE | 4.88297 | 5.16969 | 0.000622035 | 0.000658559 | 0.00032 | 65.4065 | 0.319378 | 0.337675 | 50 | 857.499
LISSE | STEEL/E24-2 | 3786.02 | 18388.3 | 5072.21 | +3.750 | +3.800 | 1131 | L36 | 2 | 2003 | GRENAILLE-PEINT | E24-2 | LISSE | 12.3152 | 12.3152 | 0.00156882 | 0.00156882 | 0.204273 | 65.146 | 0.802287 | 0.802287 | 4 | 2042.74
ATTACHE | STEEL/E24-2 | 3328.92 | 15009.1 | 6444.27 | +2.939 | +3.726 | 1118 | L35 | 2 | 2003 | GRENAILLE-PEINT | E24-2 | ATTACHE | 4.46096 | 4.74767 | 0.000568275 | 0.000604799 | 0.00032 | 65.443 | 0.291938 | 0.310235 | 50 | 787.499
LISSE | STEEL/E24-2 | 3786.02 | 16248.2 | 5905.31 | +3.750 | +3.800 | 1132 | L36 | 2 | 2003 | GRENAILLE-PEINT | E24-2 | LISSE | 12.4915 | 12.4915 | 0.00159128 | 0.00159128 | 0.207198 | 65.1443 | 0.813752 | 0.813752 | 4 | 2071.98
ATTACHE | STEEL/E24-2 | 3328.92 | 12881.1 | 7482.88 | +2.939 | +3.726 | 1118 | L35 | 2 | 2003 | GRENAILLE-PEINT | E24-2 | ATTACHE | 4.46096 | 4.74767 | 0.000568275 | 0.000604799 | 0.00032 | 65.443 | 0.291938 | 0.310235 | 50 | 787.499
LISSE | STEEL/E24-2 | 3716.02 | 11991.9 | 7963.02 | +3.680 | +3.730 | 1134 | L35 | 2 | 2003 | GRENAILLE-PEINT | E24-2 | LISSE | 13.1102 | 13.1102 | 0.00167008 | 0.00167008 | 0.217459 | 65.1385 | 0.853976 | 0.853976 | 4 | 2174.6
ATTACHE | STEEL/E24-2 | 3313.91 | 10754.8 | 8667.06 | +2.939 | +3.696 | 1116 | L35 | 2 | 2003 | GRENAILLE-PEINT | E24-2 | ATTACHE | 4.28009 | 4.56681 | 0.000545235 | 0.000581759 | 0.00032 | 65.4608 | 0.280178 | 0.298475 | 50 | 757.499
LISSE | STEEL/E24-2 | 3716.02 | 14129.2 | 6859.83 | +3.680 | +3.730 | 1133 | L35 | 2 | 2003 | GRENAILLE-PEINT | E24-2 | LISSE | 12.7662 | 12.7662 | 0.00162626 | 0.00162626 | 0.211753 | 65.1416 | 0.831609 | 0.831609 | 4 | 2117.54
ATTACHE | STEEL/E24-2 | 3407.8 | 31988.5 | 2468.69 | +3.370 | +3.420 | 1136 | L33 | 2 | 2003 | GRENAILLE-PEINT | E24-2 | ATTACHE | 0.824286 | 0.824286 | 0.000105005 | 0.000105005 | 0.015086 | 66.9441 | 0.0551811 | 0.0551811 | 50 | 150.86
ATTACHE | STEEL/E24-2 | 3406.88 | 19778.1 | 4594.38 | +3.370 | +3.420 | 1137 | L34 | 2 | 2003 | GRENAILLE-PEINT | E24-2 | ATTACHE | 1.72618 | 1.72618 | 0.000219895 | 0.000219895 | 0.0300503 | 65.94 | 0.113824 | 0.113824 | 50 | 300.503
SOLIVE | STEEL/S235JR | 4315 | 12632.5 | 571.021 | +4.265 | +4.365 | S42 | S42 | 2 | 2007 | GALVANISE | S235JR | SOLIVE | 30.777 | 30.777 | 0.00392064 | 0.00392064 | 0.25525 | 65.0711 | 2.0027 | 2.0027 | 50 | 5105
SOLIVE | STEEL/S235JR | 4315 | 17320 | 571.021 | +4.265 | +4.365 | S64 | S64 | 2 | 2007 | GALVANISE | S235JR | SOLIVE | 25.6224 | 25.6224 | 0.003264 | 0.003264 | 0.2125 | 65.0812 | 1.66754 | 1.66754 | 50 | 4250
SOLIVE | STEEL/S235JR | 4315 | 21981.2 | 571.021 | +4.265 | +4.365 | S63 | S63 | 2 | 2007 | GALVANISE | S235JR | SOLIVE | 30.4605 | 30.4605 | 0.00388032 | 0.00388032 | 0.252625 | 65.0717 | 1.98212 | 1.98212 | 50 | 5052.5
SOLIVE | STEEL/S235JR | 4315 | 27043.7 | 571.021 | +4.265 | +4.365 | S63 | S63 | 2 | 2007 | GALVANISE | S235JR | SOLIVE | 30.4605 | 30.4605 | 0.00388032 | 0.00388032 | 0.252625 | 65.0717 | 1.98212 | 1.98212 | 50 | 5052.5
SOLIVE | STEEL/S235JR | 10915 | 50534 | 21550.5 | +10.865 | +10.965 | S84 | S84 | 2 | 2007 | GALVANISE | S235JR | SOLIVE | 20.3834 | 20.3834 | 0.00259661 | 0.00259661 | 0.16905 | 65.0966 | 1.32689 | 1.32689 | 50 | 3381
SOLIVE | STEEL/S235JR | 10915 | 50094 | 22937 | +10.865 | +10.965 | S74 | S74 | 2 | 2007 | GALVANISE | S235JR | SOLIVE | 37.1012 | 37.1012 | 0.00472627 | 0.00472627 | 0.3077 | 65.0626 | 2.4139 | 2.4139 | 50 | 6154
SOLIVE | STEEL/S235JR | 10915 | 50094 | 29349.5 | +10.865 | +10.965 | S73 | S73 | 2 | 2007 | GALVANISE | S235JR | SOLIVE | 40.0975 | 40.0975 | 0.00510797 | 0.00510797 | 0.33255 | 65.0595 | 2.60873 | 2.60873 | 50 | 6651
SOLIVE | STEEL/S235JR | 10915 | 54058.5 | 22937 | +10.865 | +10.965 | S74 | S74 | 2 | 2007 | GALVANISE | S235JR | SOLIVE | 37.1012 | 37.1012 | 0.00472627 | 0.00472627 | 0.3077 | 65.0626 | 2.4139 | 2.4139 | 50 | 6154
SOLIVE | STEEL/S235JR | 10915 | 54058.5 | 29349.5 | +10.865 | +10.965 | S73 | S73 | 2 | 2007 | GALVANISE | S235JR | SOLIVE | 40.0975 | 40.0975 | 0.00510797 | 0.00510797 | 0.33255 | 65.0595 | 2.60873 | 2.60873 | 50 | 6651
SOLIVE | STEEL/S235JR | 10915 | 56823.5 | 22937 | +10.865 | +10.965 | S74 | S74 | 2 | 2007 | GALVANISE | S235JR | SOLIVE | 37.1012 | 37.1012 | 0.00472627 | 0.00472627 | 0.3077 | 65.0626 | 2.4139 | 2.4139 | 50 | 6154
SOLIVE | STEEL/S235JR | 10915 | 56823.5 | 29349.5 | +10.865 | +10.965 | S73 | S73 | 2 | 2007 | GALVANISE | S235JR | SOLIVE | 40.0975 | 40.0975 | 0.00510797 | 0.00510797 | 0.33255 | 65.0595 | 2.60873 | 2.60873 | 50 | 6651
SOLIVE | STEEL/S235JR | 10815 | 52735 | 20621 | +10.765 | +10.865 | S50 | S50 | 2 | 2007 | GALVANISE | S235JR | SOLIVE | 32.7364 | 32.7364 | 0.00417024 | 0.00417024 | 0.2715 | 65.0682 | 2.1301 | 2.1301 | 50 | 5430
SOLIVE | STEEL/S235JR | 10815 | 58220 | 20621 | +10.765 | +10.865 | S61 | S61 | 2 | 2007 | GALVANISE | S235JR | SOLIVE | 33.279 | 33.279 | 0.00423936 | 0.00423936 | 0.276 | 65.0674 | 2.16538 | 2.16538 | 50 | 5520
SOLIVE | STEEL/S235JR | 10815 | 63730 | 20621 | +10.765 | +10.865 | S51 | S51 | 2 | 2007 | GALVANISE | S235JR | SOLIVE | 33.0378 | 33.0378 | 0.00420864 | 0.00420864 | 0.274 | 65.0677 | 2.1497 | 2.1497 | 50 | 5480
SOLIVE | STEEL/S235JR | 10915 | 59588.5 | 29349.5 | +10.865 | +10.965 | S73 | S73 | 2 | 2007 | GALVANISE | S235JR | SOLIVE | 40.0975 | 40.0975 | 0.00510797 | 0.00510797 | 0.33255 | 65.0595 | 2.60873 | 2.60873 | 50 | 6651
SOLIVE | STEEL/S235JR | 10915 | 59588.5 | 22937 | +10.865 | +10.965 | S74 | S74 | 2 | 2007 | GALVANISE | S235JR | SOLIVE | 37.1012 | 37.1012 | 0.00472627 | 0.00472627 | 0.3077 | 65.0626 | 2.4139 | 2.4139 | 50 | 6154
SOLIVE | STEEL/S235JR | 4315 | 41629.2 | 5677.69 | +4.265 | +4.365 | S82 | S82 | 2 | 2007 | GALVANISE | S235JR | SOLIVE | 15.8457 | 15.8457 | 0.00201856 | 0.00201856 | 0.131416 | 65.1182 | 1.03184 | 1.03184 | 50 | 2628.33
SOLIVE | STEEL/S235JR | 4315 | 41629.2 | 8326.02 | +4.265 | +4.365 | S82 | S82 | 2 | 2007 | GALVANISE | S235JR | SOLIVE | 15.8457 | 15.8457 | 0.00201856 | 0.00201856 | 0.131416 | 65.1182 | 1.03184 | 1.03184 | 50 | 2628.33
SOLIVE | STEEL/S235JR | 4415 | 40236 | 2663.33 | +4.365 | +4.465 | 1082 | S53 | 2 | 2007 | GALVANISE | S235JR | SOLIVE | 36.4542 | 36.4542 | 0.00464384 | 0.00464384 | 0.302333 | 65.0634 | 2.37183 | 2.37183 | 50 | 6046.67
