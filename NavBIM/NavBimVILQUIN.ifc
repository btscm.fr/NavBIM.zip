Properties of the parts of a building model (IFC2X3), part 26 of 32

# IfcPlate: PL10*70 (973)
Name | Material | Center of gravity Z (mm) | Center of gravity Y (mm) | Center of gravity X (mm) | Bottom elevation | Top elevation | Part mark | Assembly mark | Phase | Class | Finish | Grade | Name | Net weight (kg) = Weight (kg) | Gross weight (kg) | Net volume (m3) = Gross volume (m3) | Gross footprint area (m2) | Area per tons (m2) | Net surface area (m2) | Gross area (m2) | Height (mm) | Length (mm)
PLAT | STEEL/E36-3 | 4088.5 | 22193.5 | 20811.6 | +3.950 | +4.227 | 221 | N45 | 2 | 2006 | GRENAILLE-PEINT | E36-3 | PLAT | 1.50225 | 1.51992 | 0.00019137 | 0.000549999 | 29.9751 | 0.0450302 | 0.019362 | 70 | 276.6
PLAT | STEEL/E36-3 | 4088.5 | 22193.5 | 20888.4 | +3.950 | +4.227 | 221 | N45 | 2 | 2006 | GRENAILLE-PEINT | E36-3 | PLAT | 1.50225 | 1.51992 | 0.00019137 | 0.000549999 | 29.9751 | 0.0450302 | 0.019362 | 70 | 276.6
PLAT | STEEL/E36-3 | 4088.5 | 22050 | 20811.1 | +3.950 | +4.227 | 222 | N45 | 2 | 2006 | GRENAILLE-PEINT | E36-3 | PLAT | 2.01837 | 2.08889 | 0.000257117 | 0 | 29.7642 | 0.0600752 | 0.0266101 | 70 | 380.144
PLAT | STEEL/E36-3 | 4088.5 | 21906.5 | 20811.6 | +3.950 | +4.227 | 221 | N45 | 2 | 2006 | GRENAILLE-PEINT | E36-3 | PLAT | 1.50225 | 1.51992 | 0.00019137 | 0.000549999 | 29.9751 | 0.0450302 | 0.019362 | 70 | 276.6
PLAT | STEEL/E36-3 | 4088.5 | 21906.5 | 20888.4 | +3.950 | +4.227 | 221 | N45 | 2 | 2006 | GRENAILLE-PEINT | E36-3 | PLAT | 1.50225 | 1.51992 | 0.00019137 | 0.000549999 | 29.9751 | 0.0450302 | 0.019362 | 70 | 276.6
PLAT | STEEL/E36-3 | 4088.5 | 22050 | 20888.9 | +3.950 | +4.227 | 222 | N45 | 2 | 2006 | GRENAILLE-PEINT | E36-3 | PLAT | 2.01837 | 2.08889 | 0.000257117 | 0 | 29.7642 | 0.0600752 | 0.0266101 | 70 | 380.144
PLAT | STEEL/E36-3 | 4088.5 | 24650 | 20888.9 | +3.950 | +4.227 | 222 | N45 | 2 | 2006 | GRENAILLE-PEINT | E36-3 | PLAT | 2.01837 | 2.08889 | 0.000257117 | 0 | 29.7642 | 0.0600752 | 0.0266101 | 70 | 380.144
PLAT | STEEL/E36-3 | 4088.5 | 24506.5 | 20888.4 | +3.950 | +4.227 | 221 | N45 | 2 | 2006 | GRENAILLE-PEINT | E36-3 | PLAT | 1.50225 | 1.51992 | 0.00019137 | 0.000549999 | 29.9751 | 0.0450302 | 0.019362 | 70 | 276.6
PLAT | STEEL/E36-3 | 4088.5 | 24506.5 | 20811.6 | +3.950 | +4.227 | 221 | N45 | 2 | 2006 | GRENAILLE-PEINT | E36-3 | PLAT | 1.50225 | 1.51992 | 0.00019137 | 0.000549999 | 29.9751 | 0.0450302 | 0.019362 | 70 | 276.6
PLAT | STEEL/E36-3 | 4088.5 | 24650 | 20811.1 | +3.950 | +4.227 | 222 | N45 | 2 | 2006 | GRENAILLE-PEINT | E36-3 | PLAT | 2.01837 | 2.08889 | 0.000257117 | 0 | 29.7642 | 0.0600752 | 0.0266101 | 70 | 380.144
PLAT | STEEL/E36-3 | 4088.5 | 24793.5 | 20888.4 | +3.950 | +4.227 | 221 | N45 | 2 | 2006 | GRENAILLE-PEINT | E36-3 | PLAT | 1.50225 | 1.51992 | 0.00019137 | 0.000549999 | 29.9751 | 0.0450302 | 0.019362 | 70 | 276.6
PLAT | STEEL/E36-3 | 4088.5 | 24793.5 | 20811.6 | +3.950 | +4.227 | 221 | N45 | 2 | 2006 | GRENAILLE-PEINT | E36-3 | PLAT | 1.50225 | 1.51992 | 0.00019137 | 0.000549999 | 29.9751 | 0.0450302 | 0.019362 | 70 | 276.6
PLAT | STEEL/E36-3 | 5741.5 | 24793.5 | 20811.6 | +5.603 | +5.880 | 221 | N45 | 2 | 2006 | GRENAILLE-PEINT | E36-3 | PLAT | 1.50225 | 1.51992 | 0.00019137 | 0.000549999 | 29.9751 | 0.0450302 | 0.019362 | 70 | 276.6
PLAT | STEEL/E36-3 | 5741.5 | 24793.5 | 20888.4 | +5.603 | +5.880 | 221 | N45 | 2 | 2006 | GRENAILLE-PEINT | E36-3 | PLAT | 1.50225 | 1.51992 | 0.00019137 | 0.000549999 | 29.9751 | 0.0450302 | 0.019362 | 70 | 276.6
PLAT | STEEL/E36-3 | 5741.5 | 24650 | 20811.1 | +5.603 | +5.880 | 222 | N45 | 2 | 2006 | GRENAILLE-PEINT | E36-3 | PLAT | 2.01837 | 2.08889 | 0.000257117 | 0 | 29.7642 | 0.0600752 | 0.0266101 | 70 | 380.144
PLAT | STEEL/E36-3 | 5741.5 | 24650 | 20888.9 | +5.603 | +5.880 | 222 | N45 | 2 | 2006 | GRENAILLE-PEINT | E36-3 | PLAT | 2.01837 | 2.08889 | 0.000257117 | 0 | 29.7642 | 0.0600752 | 0.0266101 | 70 | 380.144
PLAT | STEEL/E36-3 | 5741.5 | 24506.5 | 20811.6 | +5.603 | +5.880 | 221 | N45 | 2 | 2006 | GRENAILLE-PEINT | E36-3 | PLAT | 1.50225 | 1.51992 | 0.00019137 | 0.000549999 | 29.9751 | 0.0450302 | 0.019362 | 70 | 276.6
PLAT | STEEL/E36-3 | 5741.5 | 24506.5 | 20888.4 | +5.603 | +5.880 | 221 | N45 | 2 | 2006 | GRENAILLE-PEINT | E36-3 | PLAT | 1.50225 | 1.51992 | 0.00019137 | 0.000549999 | 29.9751 | 0.0450302 | 0.019362 | 70 | 276.6
PLAT | STEEL/E36-3 | 4088.5 | 37650 | 20811.1 | +3.950 | +4.227 | 222 | N44 | 2 | 2006 | GRENAILLE-PEINT | E36-3 | PLAT | 2.01837 | 2.08889 | 0.000257117 | 0 | 29.7642 | 0.0600752 | 0.0266101 | 70 | 380.144
PLAT | STEEL/E36-3 | 4088.5 | 37650 | 20888.9 | +3.950 | +4.227 | 222 | N44 | 2 | 2006 | GRENAILLE-PEINT | E36-3 | PLAT | 2.01837 | 2.08889 | 0.000257117 | 0 | 29.7642 | 0.0600752 | 0.0266101 | 70 | 380.144
PLAT | STEEL/E36-3 | 5741.5 | 37650 | 20888.9 | +5.603 | +5.880 | 222 | N44 | 2 | 2006 | GRENAILLE-PEINT | E36-3 | PLAT | 2.01837 | 2.08889 | 0.000257117 | 0 | 29.7642 | 0.0600752 | 0.0266101 | 70 | 380.144
PLAT | STEEL/E36-3 | 5741.5 | 37650 | 20811.1 | +5.603 | +5.880 | 222 | N44 | 2 | 2006 | GRENAILLE-PEINT | E36-3 | PLAT | 2.01837 | 2.08889 | 0.000257117 | 0 | 29.7642 | 0.0600752 | 0.0266101 | 70 | 380.144
PLAT | STEEL/E36-3 | 5741.5 | 37506.5 | 20811.6 | +5.603 | +5.880 | 221 | N44 | 2 | 2006 | GRENAILLE-PEINT | E36-3 | PLAT | 1.50225 | 1.51992 | 0.00019137 | 0.000549999 | 29.9751 | 0.0450302 | 0.019362 | 70 | 276.6
PLAT | STEEL/E36-3 | 5741.5 | 37506.5 | 20888.4 | +5.603 | +5.880 | 221 | N44 | 2 | 2006 | GRENAILLE-PEINT | E36-3 | PLAT | 1.50225 | 1.51992 | 0.00019137 | 0.000549999 | 29.9751 | 0.0450302 | 0.019362 | 70 | 276.6
PLAT | STEEL/E36-3 | 5741.5 | 37793.5 | 20811.6 | +5.603 | +5.880 | 221 | N44 | 2 | 2006 | GRENAILLE-PEINT | E36-3 | PLAT | 1.50225 | 1.51992 | 0.00019137 | 0.000549999 | 29.9751 | 0.0450302 | 0.019362 | 70 | 276.6
PLAT | STEEL/E36-3 | 5741.5 | 37793.5 | 20888.4 | +5.603 | +5.880 | 221 | N44 | 2 | 2006 | GRENAILLE-PEINT | E36-3 | PLAT | 1.50225 | 1.51992 | 0.00019137 | 0.000549999 | 29.9751 | 0.0450302 | 0.019362 | 70 | 276.6
PLAT | STEEL/E36-3 | 4088.5 | 37506.5 | 20888.4 | +3.950 | +4.227 | 221 | N44 | 2 | 2006 | GRENAILLE-PEINT | E36-3 | PLAT | 1.50225 | 1.51992 | 0.00019137 | 0.000549999 | 29.9751 | 0.0450302 | 0.019362 | 70 | 276.6
PLAT | STEEL/E36-3 | 4088.5 | 37506.5 | 20811.6 | +3.950 | +4.227 | 221 | N44 | 2 | 2006 | GRENAILLE-PEINT | E36-3 | PLAT | 1.50225 | 1.51992 | 0.00019137 | 0.000549999 | 29.9751 | 0.0450302 | 0.019362 | 70 | 276.6
PLAT | STEEL/E36-3 | 4088.5 | 37793.5 | 20888.4 | +3.950 | +4.227 | 221 | N44 | 2 | 2006 | GRENAILLE-PEINT | E36-3 | PLAT | 1.50225 | 1.51992 | 0.00019137 | 0.000549999 | 29.9751 | 0.0450302 | 0.019362 | 70 | 276.6
PLAT | STEEL/E36-3 | 4088.5 | 37793.5 | 20811.6 | +3.950 | +4.227 | 221 | N44 | 2 | 2006 | GRENAILLE-PEINT | E36-3 | PLAT | 1.50225 | 1.51992 | 0.00019137 | 0.000549999 | 29.9751 | 0.0450302 | 0.019362 | 70 | 276.6
PLAT | STEEL/E36-3 | 5741.5 | 17233.5 | 20888.4 | +5.603 | +5.880 | 221 | N49 | 2 | 2006 | GRENAILLE-PEINT | E36-3 | PLAT | 1.50225 | 1.51992 | 0.00019137 | 0.000549999 | 29.9751 | 0.0450302 | 0.019362 | 70 | 276.6
PLAT | STEEL/E36-3 | 5741.5 | 17233.5 | 20811.6 | +5.603 | +5.880 | 221 | N49 | 2 | 2006 | GRENAILLE-PEINT | E36-3 | PLAT | 1.50225 | 1.51992 | 0.00019137 | 0.000549999 | 29.9751 | 0.0450302 | 0.019362 | 70 | 276.6
PLAT | STEEL/E36-3 | 5741.5 | 16946.5 | 20888.4 | +5.603 | +5.880 | 221 | N49 | 2 | 2006 | GRENAILLE-PEINT | E36-3 | PLAT | 1.50225 | 1.51992 | 0.00019137 | 0.000549999 | 29.9751 | 0.0450302 | 0.019362 | 70 | 276.6
PLAT | STEEL/E36-3 | 5741.5 | 16946.5 | 20811.6 | +5.603 | +5.880 | 221 | N49 | 2 | 2006 | GRENAILLE-PEINT | E36-3 | PLAT | 1.50225 | 1.51992 | 0.00019137 | 0.000549999 | 29.9751 | 0.0450302 | 0.019362 | 70 | 276.6
PLAT | STEEL/E36-3 | 5741.5 | 17090 | 20811.1 | +5.603 | +5.880 | 222 | N49 | 2 | 2006 | GRENAILLE-PEINT | E36-3 | PLAT | 2.01837 | 2.08889 | 0.000257117 | 0 | 29.7642 | 0.0600752 | 0.0266101 | 70 | 380.144
PLAT | STEEL/E36-3 | 5741.5 | 17090 | 20888.9 | +5.603 | +5.880 | 222 | N49 | 2 | 2006 | GRENAILLE-PEINT | E36-3 | PLAT | 2.01837 | 2.08889 | 0.000257117 | 0 | 29.7642 | 0.0600752 | 0.0266101 | 70 | 380.144
PLAT | STEEL/E36-3 | 4088.5 | 17233.5 | 20811.6 | +3.950 | +4.227 | 221 | N49 | 2 | 2006 | GRENAILLE-PEINT | E36-3 | PLAT | 1.50225 | 1.51992 | 0.00019137 | 0.000549999 | 29.9751 | 0.0450302 | 0.019362 | 70 | 276.6
PLAT | STEEL/E36-3 | 4088.5 | 17233.5 | 20888.4 | +3.950 | +4.227 | 221 | N49 | 2 | 2006 | GRENAILLE-PEINT | E36-3 | PLAT | 1.50225 | 1.51992 | 0.00019137 | 0.000549999 | 29.9751 | 0.0450302 | 0.019362 | 70 | 276.6
PLAT | STEEL/E36-3 | 4088.5 | 16946.5 | 20811.6 | +3.950 | +4.227 | 221 | N49 | 2 | 2006 | GRENAILLE-PEINT | E36-3 | PLAT | 1.50225 | 1.51992 | 0.00019137 | 0.000549999 | 29.9751 | 0.0450302 | 0.019362 | 70 | 276.6
PLAT | STEEL/E36-3 | 4088.5 | 16946.5 | 20888.4 | +3.950 | +4.227 | 221 | N49 | 2 | 2006 | GRENAILLE-PEINT | E36-3 | PLAT | 1.50225 | 1.51992 | 0.00019137 | 0.000549999 | 29.9751 | 0.0450302 | 0.019362 | 70 | 276.6
PLAT | STEEL/E36-3 | 4088.5 | 17090 | 20888.9 | +3.950 | +4.227 | 222 | N49 | 2 | 2006 | GRENAILLE-PEINT | E36-3 | PLAT | 2.01837 | 2.08889 | 0.000257117 | 0 | 29.7642 | 0.0600752 | 0.0266101 | 70 | 380.144
PLAT | STEEL/E36-3 | 4088.5 | 17090 | 20811.1 | +3.950 | +4.227 | 222 | N49 | 2 | 2006 | GRENAILLE-PEINT | E36-3 | PLAT | 2.01837 | 2.08889 | 0.000257117 | 0 | 29.7642 | 0.0600752 | 0.0266101 | 70 | 380.144
PLAT | STEEL/E36-3 | 5741.5 | 35193.5 | 20888.4 | +5.603 | +5.880 | 221 | N44 | 2 | 2006 | GRENAILLE-PEINT | E36-3 | PLAT | 1.50225 | 1.51992 | 0.00019137 | 0.000549999 | 29.9751 | 0.0450302 | 0.019362 | 70 | 276.6
PLAT | STEEL/E36-3 | 5741.5 | 35193.5 | 20811.6 | +5.603 | +5.880 | 221 | N44 | 2 | 2006 | GRENAILLE-PEINT | E36-3 | PLAT | 1.50225 | 1.51992 | 0.00019137 | 0.000549999 | 29.9751 | 0.0450302 | 0.019362 | 70 | 276.6
PLAT | STEEL/E36-3 | 5741.5 | 34906.5 | 20888.4 | +5.603 | +5.880 | 221 | N44 | 2 | 2006 | GRENAILLE-PEINT | E36-3 | PLAT | 1.50225 | 1.51992 | 0.00019137 | 0.000549999 | 29.9751 | 0.0450302 | 0.019362 | 70 | 276.6
PLAT | STEEL/E36-3 | 5741.5 | 34906.5 | 20811.6 | +5.603 | +5.880 | 221 | N44 | 2 | 2006 | GRENAILLE-PEINT | E36-3 | PLAT | 1.50225 | 1.51992 | 0.00019137 | 0.000549999 | 29.9751 | 0.0450302 | 0.019362 | 70 | 276.6
PLAT | STEEL/E36-3 | 5741.5 | 35050 | 20811.1 | +5.603 | +5.880 | 222 | N44 | 2 | 2006 | GRENAILLE-PEINT | E36-3 | PLAT | 2.01837 | 2.08889 | 0.000257117 | 0 | 29.7642 | 0.0600752 | 0.0266101 | 70 | 380.144
PLAT | STEEL/E36-3 | 5741.5 | 35050 | 20888.9 | +5.603 | +5.880 | 222 | N44 | 2 | 2006 | GRENAILLE-PEINT | E36-3 | PLAT | 2.01837 | 2.08889 | 0.000257117 | 0 | 29.7642 | 0.0600752 | 0.0266101 | 70 | 380.144
PLAT | STEEL/E36-3 | 4088.5 | 35193.5 | 20811.6 | +3.950 | +4.227 | 221 | N44 | 2 | 2006 | GRENAILLE-PEINT | E36-3 | PLAT | 1.50225 | 1.51992 | 0.00019137 | 0.000549999 | 29.9751 | 0.0450302 | 0.019362 | 70 | 276.6
PLAT | STEEL/E36-3 | 4088.5 | 35193.5 | 20888.4 | +3.950 | +4.227 | 221 | N44 | 2 | 2006 | GRENAILLE-PEINT | E36-3 | PLAT | 1.50225 | 1.51992 | 0.00019137 | 0.000549999 | 29.9751 | 0.0450302 | 0.019362 | 70 | 276.6
PLAT | STEEL/E36-3 | 4088.5 | 34906.5 | 20811.6 | +3.950 | +4.227 | 221 | N44 | 2 | 2006 | GRENAILLE-PEINT | E36-3 | PLAT | 1.50225 | 1.51992 | 0.00019137 | 0.000549999 | 29.9751 | 0.0450302 | 0.019362 | 70 | 276.6
PLAT | STEEL/E36-3 | 4088.5 | 34906.5 | 20888.4 | +3.950 | +4.227 | 221 | N44 | 2 | 2006 | GRENAILLE-PEINT | E36-3 | PLAT | 1.50225 | 1.51992 | 0.00019137 | 0.000549999 | 29.9751 | 0.0450302 | 0.019362 | 70 | 276.6
PLAT | STEEL/E36-3 | 4088.5 | 35050 | 20888.9 | +3.950 | +4.227 | 222 | N44 | 2 | 2006 | GRENAILLE-PEINT | E36-3 | PLAT | 2.01837 | 2.08889 | 0.000257117 | 0 | 29.7642 | 0.0600752 | 0.0266101 | 70 | 380.144
PLAT | STEEL/E36-3 | 4088.5 | 35050 | 20811.1 | +3.950 | +4.227 | 222 | N44 | 2 | 2006 | GRENAILLE-PEINT | E36-3 | PLAT | 2.01837 | 2.08889 | 0.000257117 | 0 | 29.7642 | 0.0600752 | 0.0266101 | 70 | 380.144
PLAT | STEEL/E36-3 | 4088.5 | 32306.5 | 20888.4 | +3.950 | +4.227 | 221 | N44 | 2 | 2006 | GRENAILLE-PEINT | E36-3 | PLAT | 1.50225 | 1.51992 | 0.00019137 | 0.000549999 | 29.9751 | 0.0450302 | 0.019362 | 70 | 276.6
PLAT | STEEL/E36-3 | 4088.5 | 32306.5 | 20811.6 | +3.950 | +4.227 | 221 | N44 | 2 | 2006 | GRENAILLE-PEINT | E36-3 | PLAT | 1.50225 | 1.51992 | 0.00019137 | 0.000549999 | 29.9751 | 0.0450302 | 0.019362 | 70 | 276.6
PLAT | STEEL/E36-3 | 4088.5 | 32593.5 | 20888.4 | +3.950 | +4.227 | 221 | N44 | 2 | 2006 | GRENAILLE-PEINT | E36-3 | PLAT | 1.50225 | 1.51992 | 0.00019137 | 0.000549999 | 29.9751 | 0.0450302 | 0.019362 | 70 | 276.6
PLAT | STEEL/E36-3 | 4088.5 | 32593.5 | 20811.6 | +3.950 | +4.227 | 221 | N44 | 2 | 2006 | GRENAILLE-PEINT | E36-3 | PLAT | 1.50225 | 1.51992 | 0.00019137 | 0.000549999 | 29.9751 | 0.0450302 | 0.019362 | 70 | 276.6
PLAT | STEEL/E36-3 | 5741.5 | 32306.5 | 20811.6 | +5.603 | +5.880 | 221 | N44 | 2 | 2006 | GRENAILLE-PEINT | E36-3 | PLAT | 1.50225 | 1.51992 | 0.00019137 | 0.000549999 | 29.9751 | 0.0450302 | 0.019362 | 70 | 276.6
PLAT | STEEL/E36-3 | 5741.5 | 32306.5 | 20888.4 | +5.603 | +5.880 | 221 | N44 | 2 | 2006 | GRENAILLE-PEINT | E36-3 | PLAT | 1.50225 | 1.51992 | 0.00019137 | 0.000549999 | 29.9751 | 0.0450302 | 0.019362 | 70 | 276.6
PLAT | STEEL/E36-3 | 5741.5 | 32593.5 | 20811.6 | +5.603 | +5.880 | 221 | N44 | 2 | 2006 | GRENAILLE-PEINT | E36-3 | PLAT | 1.50225 | 1.51992 | 0.00019137 | 0.000549999 | 29.9751 | 0.0450302 | 0.019362 | 70 | 276.6
PLAT | STEEL/E36-3 | 5741.5 | 32593.5 | 20888.4 | +5.603 | +5.880 | 221 | N44 | 2 | 2006 | GRENAILLE-PEINT | E36-3 | PLAT | 1.50225 | 1.51992 | 0.00019137 | 0.000549999 | 29.9751 | 0.0450302 | 0.019362 | 70 | 276.6
PLAT | STEEL/E36-3 | 4088.5 | 29706.5 | 20888.4 | +3.950 | +4.227 | 221 | N44 | 2 | 2006 | GRENAILLE-PEINT | E36-3 | PLAT | 1.50225 | 1.51992 | 0.00019137 | 0.000549999 | 29.9751 | 0.0450302 | 0.019362 | 70 | 276.6
PLAT | STEEL/E36-3 | 4088.5 | 29706.5 | 20811.6 | +3.950 | +4.227 | 221 | N44 | 2 | 2006 | GRENAILLE-PEINT | E36-3 | PLAT | 1.50225 | 1.51992 | 0.00019137 | 0.000549999 | 29.9751 | 0.0450302 | 0.019362 | 70 | 276.6
PLAT | STEEL/E36-3 | 4088.5 | 29993.5 | 20888.4 | +3.950 | +4.227 | 221 | N44 | 2 | 2006 | GRENAILLE-PEINT | E36-3 | PLAT | 1.50225 | 1.51992 | 0.00019137 | 0.000549999 | 29.9751 | 0.0450302 | 0.019362 | 70 | 276.6
PLAT | STEEL/E36-3 | 4088.5 | 29993.5 | 20811.6 | +3.950 | +4.227 | 221 | N44 | 2 | 2006 | GRENAILLE-PEINT | E36-3 | PLAT | 1.50225 | 1.51992 | 0.00019137 | 0.000549999 | 29.9751 | 0.0450302 | 0.019362 | 70 | 276.6
PLAT | STEEL/E36-3 | 5741.5 | 29706.5 | 20811.6 | +5.603 | +5.880 | 221 | N44 | 2 | 2006 | GRENAILLE-PEINT | E36-3 | PLAT | 1.50225 | 1.51992 | 0.00019137 | 0.000549999 | 29.9751 | 0.0450302 | 0.019362 | 70 | 276.6
PLAT | STEEL/E36-3 | 5741.5 | 29706.5 | 20888.4 | +5.603 | +5.880 | 221 | N44 | 2 | 2006 | GRENAILLE-PEINT | E36-3 | PLAT | 1.50225 | 1.51992 | 0.00019137 | 0.000549999 | 29.9751 | 0.0450302 | 0.019362 | 70 | 276.6
PLAT | STEEL/E36-3 | 5741.5 | 29993.5 | 20811.6 | +5.603 | +5.880 | 221 | N44 | 2 | 2006 | GRENAILLE-PEINT | E36-3 | PLAT | 1.50225 | 1.51992 | 0.00019137 | 0.000549999 | 29.9751 | 0.0450302 | 0.019362 | 70 | 276.6
PLAT | STEEL/E36-3 | 5741.5 | 29993.5 | 20888.4 | +5.603 | +5.880 | 221 | N44 | 2 | 2006 | GRENAILLE-PEINT | E36-3 | PLAT | 1.50225 | 1.51992 | 0.00019137 | 0.000549999 | 29.9751 | 0.0450302 | 0.019362 | 70 | 276.6
PLAT | STEEL/E36-3 | 4088.5 | 27106.5 | 20888.4 | +3.950 | +4.227 | 221 | N45 | 2 | 2006 | GRENAILLE-PEINT | E36-3 | PLAT | 1.50225 | 1.51992 | 0.00019137 | 0.000549999 | 29.9751 | 0.0450302 | 0.019362 | 70 | 276.6
PLAT | STEEL/E36-3 | 4088.5 | 27106.5 | 20811.6 | +3.950 | +4.227 | 221 | N45 | 2 | 2006 | GRENAILLE-PEINT | E36-3 | PLAT | 1.50225 | 1.51992 | 0.00019137 | 0.000549999 | 29.9751 | 0.0450302 | 0.019362 | 70 | 276.6
PLAT | STEEL/E36-3 | 4088.5 | 27393.5 | 20888.4 | +3.950 | +4.227 | 221 | N45 | 2 | 2006 | GRENAILLE-PEINT | E36-3 | PLAT | 1.50225 | 1.51992 | 0.00019137 | 0.000549999 | 29.9751 | 0.0450302 | 0.019362 | 70 | 276.6
PLAT | STEEL/E36-3 | 4088.5 | 27393.5 | 20811.6 | +3.950 | +4.227 | 221 | N45 | 2 | 2006 | GRENAILLE-PEINT | E36-3 | PLAT | 1.50225 | 1.51992 | 0.00019137 | 0.000549999 | 29.9751 | 0.0450302 | 0.019362 | 70 | 276.6
PLAT | STEEL/E36-3 | 5741.5 | 27106.5 | 20811.6 | +5.603 | +5.880 | 221 | N45 | 2 | 2006 | GRENAILLE-PEINT | E36-3 | PLAT | 1.50225 | 1.51992 | 0.00019137 | 0.000549999 | 29.9751 | 0.0450302 | 0.019362 | 70 | 276.6
PLAT | STEEL/E36-3 | 5741.5 | 27106.5 | 20888.4 | +5.603 | +5.880 | 221 | N45 | 2 | 2006 | GRENAILLE-PEINT | E36-3 | PLAT | 1.50225 | 1.51992 | 0.00019137 | 0.000549999 | 29.9751 | 0.0450302 | 0.019362 | 70 | 276.6
PLAT | STEEL/E36-3 | 5741.5 | 27393.5 | 20811.6 | +5.603 | +5.880 | 221 | N45 | 2 | 2006 | GRENAILLE-PEINT | E36-3 | PLAT | 1.50225 | 1.51992 | 0.00019137 | 0.000549999 | 29.9751 | 0.0450302 | 0.019362 | 70 | 276.6
PLAT | STEEL/E36-3 | 5741.5 | 27393.5 | 20888.4 | +5.603 | +5.880 | 221 | N45 | 2 | 2006 | GRENAILLE-PEINT | E36-3 | PLAT | 1.50225 | 1.51992 | 0.00019137 | 0.000549999 | 29.9751 | 0.0450302 | 0.019362 | 70 | 276.6
PLAT | STEEL/E36-3 | 4088.5 | 14586.5 | 20888.4 | +3.950 | +4.227 | 221 | N49 | 2 | 2006 | GRENAILLE-PEINT | E36-3 | PLAT | 1.50225 | 1.51992 | 0.00019137 | 0.000549999 | 29.9751 | 0.0450302 | 0.019362 | 70 | 276.6
PLAT | STEEL/E36-3 | 4088.5 | 14586.5 | 20811.6 | +3.950 | +4.227 | 221 | N49 | 2 | 2006 | GRENAILLE-PEINT | E36-3 | PLAT | 1.50225 | 1.51992 | 0.00019137 | 0.000549999 | 29.9751 | 0.0450302 | 0.019362 | 70 | 276.6
PLAT | STEEL/E36-3 | 4088.5 | 14873.5 | 20888.4 | +3.950 | +4.227 | 221 | N49 | 2 | 2006 | GRENAILLE-PEINT | E36-3 | PLAT | 1.50225 | 1.51992 | 0.00019137 | 0.000549999 | 29.9751 | 0.0450302 | 0.019362 | 70 | 276.6
PLAT | STEEL/E36-3 | 4088.5 | 14873.5 | 20811.6 | +3.950 | +4.227 | 221 | N49 | 2 | 2006 | GRENAILLE-PEINT | E36-3 | PLAT | 1.50225 | 1.51992 | 0.00019137 | 0.000549999 | 29.9751 | 0.0450302 | 0.019362 | 70 | 276.6
PLAT | STEEL/E36-3 | 5741.5 | 14586.5 | 20811.6 | +5.603 | +5.880 | 221 | N49 | 2 | 2006 | GRENAILLE-PEINT | E36-3 | PLAT | 1.50225 | 1.51992 | 0.00019137 | 0.000549999 | 29.9751 | 0.0450302 | 0.019362 | 70 | 276.6
PLAT | STEEL/E36-3 | 5741.5 | 14586.5 | 20888.4 | +5.603 | +5.880 | 221 | N49 | 2 | 2006 | GRENAILLE-PEINT | E36-3 | PLAT | 1.50225 | 1.51992 | 0.00019137 | 0.000549999 | 29.9751 | 0.0450302 | 0.019362 | 70 | 276.6
PLAT | STEEL/E36-3 | 5741.5 | 14873.5 | 20811.6 | +5.603 | +5.880 | 221 | N49 | 2 | 2006 | GRENAILLE-PEINT | E36-3 | PLAT | 1.50225 | 1.51992 | 0.00019137 | 0.000549999 | 29.9751 | 0.0450302 | 0.019362 | 70 | 276.6
PLAT | STEEL/E36-3 | 5741.5 | 14873.5 | 20888.4 | +5.603 | +5.880 | 221 | N49 | 2 | 2006 | GRENAILLE-PEINT | E36-3 | PLAT | 1.50225 | 1.51992 | 0.00019137 | 0.000549999 | 29.9751 | 0.0450302 | 0.019362 | 70 | 276.6
PLAT | STEEL/E36-3 | 4088.5 | 12226.5 | 20888.4 | +3.950 | +4.227 | 221 | N49 | 2 | 2006 | GRENAILLE-PEINT | E36-3 | PLAT | 1.50225 | 1.51992 | 0.00019137 | 0.000549999 | 29.9751 | 0.0450302 | 0.019362 | 70 | 276.6
PLAT | STEEL/E36-3 | 4088.5 | 12226.5 | 20811.6 | +3.950 | +4.227 | 221 | N49 | 2 | 2006 | GRENAILLE-PEINT | E36-3 | PLAT | 1.50225 | 1.51992 | 0.00019137 | 0.000549999 | 29.9751 | 0.0450302 | 0.019362 | 70 | 276.6
PLAT | STEEL/E36-3 | 4088.5 | 12513.5 | 20888.4 | +3.950 | +4.227 | 221 | N49 | 2 | 2006 | GRENAILLE-PEINT | E36-3 | PLAT | 1.50225 | 1.51992 | 0.00019137 | 0.000549999 | 29.9751 | 0.0450302 | 0.019362 | 70 | 276.6
PLAT | STEEL/E36-3 | 4088.5 | 12513.5 | 20811.6 | +3.950 | +4.227 | 221 | N49 | 2 | 2006 | GRENAILLE-PEINT | E36-3 | PLAT | 1.50225 | 1.51992 | 0.00019137 | 0.000549999 | 29.9751 | 0.0450302 | 0.019362 | 70 | 276.6
PLAT | STEEL/E36-3 | 5741.5 | 12226.5 | 20811.6 | +5.603 | +5.880 | 221 | N49 | 2 | 2006 | GRENAILLE-PEINT | E36-3 | PLAT | 1.50225 | 1.51992 | 0.00019137 | 0.000549999 | 29.9751 | 0.0450302 | 0.019362 | 70 | 276.6
PLAT | STEEL/E36-3 | 5741.5 | 12226.5 | 20888.4 | +5.603 | +5.880 | 221 | N49 | 2 | 2006 | GRENAILLE-PEINT | E36-3 | PLAT | 1.50225 | 1.51992 | 0.00019137 | 0.000549999 | 29.9751 | 0.0450302 | 0.019362 | 70 | 276.6
PLAT | STEEL/E36-3 | 5741.5 | 12513.5 | 20811.6 | +5.603 | +5.880 | 221 | N49 | 2 | 2006 | GRENAILLE-PEINT | E36-3 | PLAT | 1.50225 | 1.51992 | 0.00019137 | 0.000549999 | 29.9751 | 0.0450302 | 0.019362 | 70 | 276.6
PLAT | STEEL/E36-3 | 5741.5 | 12513.5 | 20888.4 | +5.603 | +5.880 | 221 | N49 | 2 | 2006 | GRENAILLE-PEINT | E36-3 | PLAT | 1.50225 | 1.51992 | 0.00019137 | 0.000549999 | 29.9751 | 0.0450302 | 0.019362 | 70 | 276.6
PLAT | STEEL/E36-3 | 4088.5 | 9866.5 | 20888.4 | +3.950 | +4.227 | 221 | N49 | 2 | 2006 | GRENAILLE-PEINT | E36-3 | PLAT | 1.50225 | 1.51992 | 0.00019137 | 0.000549999 | 29.9751 | 0.0450302 | 0.019362 | 70 | 276.6
PLAT | STEEL/E36-3 | 4088.5 | 9866.5 | 20811.6 | +3.950 | +4.227 | 221 | N49 | 2 | 2006 | GRENAILLE-PEINT | E36-3 | PLAT | 1.50225 | 1.51992 | 0.00019137 | 0.000549999 | 29.9751 | 0.0450302 | 0.019362 | 70 | 276.6
PLAT | STEEL/E36-3 | 4088.5 | 10153.5 | 20888.4 | +3.950 | +4.227 | 221 | N49 | 2 | 2006 | GRENAILLE-PEINT | E36-3 | PLAT | 1.50225 | 1.51992 | 0.00019137 | 0.000549999 | 29.9751 | 0.0450302 | 0.019362 | 70 | 276.6
PLAT | STEEL/E36-3 | 4088.5 | 10153.5 | 20811.6 | +3.950 | +4.227 | 221 | N49 | 2 | 2006 | GRENAILLE-PEINT | E36-3 | PLAT | 1.50225 | 1.51992 | 0.00019137 | 0.000549999 | 29.9751 | 0.0450302 | 0.019362 | 70 | 276.6
PLAT | STEEL/E36-3 | 5741.5 | 9866.5 | 20811.6 | +5.603 | +5.880 | 221 | N49 | 2 | 2006 | GRENAILLE-PEINT | E36-3 | PLAT | 1.50225 | 1.51992 | 0.00019137 | 0.000549999 | 29.9751 | 0.0450302 | 0.019362 | 70 | 276.6
PLAT | STEEL/E36-3 | 5741.5 | 9866.5 | 20888.4 | +5.603 | +5.880 | 221 | N49 | 2 | 2006 | GRENAILLE-PEINT | E36-3 | PLAT | 1.50225 | 1.51992 | 0.00019137 | 0.000549999 | 29.9751 | 0.0450302 | 0.019362 | 70 | 276.6
PLAT | STEEL/E36-3 | 5741.5 | 10153.5 | 20811.6 | +5.603 | +5.880 | 221 | N49 | 2 | 2006 | GRENAILLE-PEINT | E36-3 | PLAT | 1.50225 | 1.51992 | 0.00019137 | 0.000549999 | 29.9751 | 0.0450302 | 0.019362 | 70 | 276.6
PLAT | STEEL/E36-3 | 5741.5 | 10153.5 | 20888.4 | +5.603 | +5.880 | 221 | N49 | 2 | 2006 | GRENAILLE-PEINT | E36-3 | PLAT | 1.50225 | 1.51992 | 0.00019137 | 0.000549999 | 29.9751 | 0.0450302 | 0.019362 | 70 | 276.6
PLAT | STEEL/E36-3 | 4088.5 | 42850 | 67511.1 | +3.950 | +4.227 | 222 | N6 | 1 | 1006 | GRENAILLE-PEINT | E36-3 | PLAT | 2.01837 | 2.08889 | 0.000257117 | 0 | 29.7642 | 0.0600752 | 0.0266101 | 70 | 380.144
PLAT | STEEL/E36-3 | 4088.5 | 42706.5 | 67511.6 | +3.950 | +4.227 | 221 | N6 | 1 | 1006 | GRENAILLE-PEINT | E36-3 | PLAT | 1.50225 | 1.51992 | 0.00019137 | 0.000549999 | 29.9751 | 0.0450302 | 0.019362 | 70 | 276.6
PLAT | STEEL/E36-3 | 4088.5 | 42706.5 | 67588.4 | +3.950 | +4.227 | 221 | N6 | 1 | 1006 | GRENAILLE-PEINT | E36-3 | PLAT | 1.50225 | 1.51992 | 0.00019137 | 0.000549999 | 29.9751 | 0.0450302 | 0.019362 | 70 | 276.6
PLAT | STEEL/E36-3 | 5741.5 | 42706.5 | 67511.6 | +5.603 | +5.880 | 221 | N6 | 1 | 1006 | GRENAILLE-PEINT | E36-3 | PLAT | 1.50225 | 1.51992 | 0.00019137 | 0.000549999 | 29.9751 | 0.0450302 | 0.019362 | 70 | 276.6
PLAT | STEEL/E36-3 | 5741.5 | 42706.5 | 67588.4 | +5.603 | +5.880 | 221 | N6 | 1 | 1006 | GRENAILLE-PEINT | E36-3 | PLAT | 1.50225 | 1.51992 | 0.00019137 | 0.000549999 | 29.9751 | 0.0450302 | 0.019362 | 70 | 276.6
PLAT | STEEL/E36-3 | 5741.5 | 42850 | 67511.1 | +5.603 | +5.880 | 222 | N6 | 1 | 1006 | GRENAILLE-PEINT | E36-3 | PLAT | 2.01837 | 2.08889 | 0.000257117 | 0 | 29.7642 | 0.0600752 | 0.0266101 | 70 | 380.144
PLAT | STEEL/E36-3 | 5741.5 | 42993.5 | 67588.4 | +5.603 | +5.880 | 221 | N6 | 1 | 1006 | GRENAILLE-PEINT | E36-3 | PLAT | 1.50225 | 1.51992 | 0.00019137 | 0.000549999 | 29.9751 | 0.0450302 | 0.019362 | 70 | 276.6
PLAT | STEEL/E36-3 | 5741.5 | 42850 | 67588.9 | +5.603 | +5.880 | 222 | N6 | 1 | 1006 | GRENAILLE-PEINT | E36-3 | PLAT | 2.01837 | 2.08889 | 0.000257117 | 0 | 29.7642 | 0.0600752 | 0.0266101 | 70 | 380.144
PLAT | STEEL/E36-3 | 4088.5 | 42850 | 67588.9 | +3.950 | +4.227 | 222 | N6 | 1 | 1006 | GRENAILLE-PEINT | E36-3 | PLAT | 2.01837 | 2.08889 | 0.000257117 | 0 | 29.7642 | 0.0600752 | 0.0266101 | 70 | 380.144
PLAT | STEEL/E36-3 | 5741.5 | 21906.5 | 67588.4 | +5.603 | +5.880 | 221 | N11 | 1 | 1006 | GRENAILLE-PEINT | E36-3 | PLAT | 1.50225 | 1.51992 | 0.00019137 | 0.000549999 | 29.9751 | 0.0450302 | 0.019362 | 70 | 276.6
PLAT | STEEL/E36-3 | 5741.5 | 21906.5 | 67511.6 | +5.603 | +5.880 | 221 | N11 | 1 | 1006 | GRENAILLE-PEINT | E36-3 | PLAT | 1.50225 | 1.51992 | 0.00019137 | 0.000549999 | 29.9751 | 0.0450302 | 0.019362 | 70 | 276.6
PLAT | STEEL/E36-3 | 5741.5 | 22050 | 67588.9 | +5.603 | +5.880 | 222 | N11 | 1 | 1006 | GRENAILLE-PEINT | E36-3 | PLAT | 2.01837 | 2.08889 | 0.000257117 | 0 | 29.7642 | 0.0600752 | 0.0266101 | 70 | 380.144
PLAT | STEEL/E36-3 | 5741.5 | 22050 | 67511.1 | +5.603 | +5.880 | 222 | N11 | 1 | 1006 | GRENAILLE-PEINT | E36-3 | PLAT | 2.01837 | 2.08889 | 0.000257117 | 0 | 29.7642 | 0.0600752 | 0.0266101 | 70 | 380.144
PLAT | STEEL/E36-3 | 5741.5 | 22193.5 | 67588.4 | +5.603 | +5.880 | 221 | N11 | 1 | 1006 | GRENAILLE-PEINT | E36-3 | PLAT | 1.50225 | 1.51992 | 0.00019137 | 0.000549999 | 29.9751 | 0.0450302 | 0.019362 | 70 | 276.6
PLAT | STEEL/E36-3 | 5741.5 | 22193.5 | 67511.6 | +5.603 | +5.880 | 221 | N11 | 1 | 1006 | GRENAILLE-PEINT | E36-3 | PLAT | 1.50225 | 1.51992 | 0.00019137 | 0.000549999 | 29.9751 | 0.0450302 | 0.019362 | 70 | 276.6
PLAT | STEEL/E36-3 | 4088.5 | 22193.5 | 67511.6 | +3.950 | +4.227 | 221 | N11 | 1 | 1006 | GRENAILLE-PEINT | E36-3 | PLAT | 1.50225 | 1.51992 | 0.00019137 | 0.000549999 | 29.9751 | 0.0450302 | 0.019362 | 70 | 276.6
PLAT | STEEL/E36-3 | 4088.5 | 22193.5 | 67588.4 | +3.950 | +4.227 | 221 | N11 | 1 | 1006 | GRENAILLE-PEINT | E36-3 | PLAT | 1.50225 | 1.51992 | 0.00019137 | 0.000549999 | 29.9751 | 0.0450302 | 0.019362 | 70 | 276.6
PLAT | STEEL/E36-3 | 4088.5 | 22050 | 67511.1 | +3.950 | +4.227 | 222 | N11 | 1 | 1006 | GRENAILLE-PEINT | E36-3 | PLAT | 2.01837 | 2.08889 | 0.000257117 | 0 | 29.7642 | 0.0600752 | 0.0266101 | 70 | 380.144
PLAT | STEEL/E36-3 | 4088.5 | 21906.5 | 67511.6 | +3.950 | +4.227 | 221 | N11 | 1 | 1006 | GRENAILLE-PEINT | E36-3 | PLAT | 1.50225 | 1.51992 | 0.00019137 | 0.000549999 | 29.9751 | 0.0450302 | 0.019362 | 70 | 276.6
PLAT | STEEL/E36-3 | 4088.5 | 21906.5 | 67588.4 | +3.950 | +4.227 | 221 | N11 | 1 | 1006 | GRENAILLE-PEINT | E36-3 | PLAT | 1.50225 | 1.51992 | 0.00019137 | 0.000549999 | 29.9751 | 0.0450302 | 0.019362 | 70 | 276.6
PLAT | STEEL/E36-3 | 4088.5 | 22050 | 67588.9 | +3.950 | +4.227 | 222 | N11 | 1 | 1006 | GRENAILLE-PEINT | E36-3 | PLAT | 2.01837 | 2.08889 | 0.000257117 | 0 | 29.7642 | 0.0600752 | 0.0266101 | 70 | 380.144
PLAT | STEEL/E36-3 | 4088.5 | 24650 | 67588.9 | +3.950 | +4.227 | 222 | N11 | 1 | 1006 | GRENAILLE-PEINT | E36-3 | PLAT | 2.01837 | 2.08889 | 0.000257117 | 0 | 29.7642 | 0.0600752 | 0.0266101 | 70 | 380.144
PLAT | STEEL/E36-3 | 4088.5 | 24506.5 | 67588.4 | +3.950 | +4.227 | 221 | N11 | 1 | 1006 | GRENAILLE-PEINT | E36-3 | PLAT | 1.50225 | 1.51992 | 0.00019137 | 0.000549999 | 29.9751 | 0.0450302 | 0.019362 | 70 | 276.6
PLAT | STEEL/E36-3 | 4088.5 | 24506.5 | 67511.6 | +3.950 | +4.227 | 221 | N11 | 1 | 1006 | GRENAILLE-PEINT | E36-3 | PLAT | 1.50225 | 1.51992 | 0.00019137 | 0.000549999 | 29.9751 | 0.0450302 | 0.019362 | 70 | 276.6
PLAT | STEEL/E36-3 | 4088.5 | 24650 | 67511.1 | +3.950 | +4.227 | 222 | N11 | 1 | 1006 | GRENAILLE-PEINT | E36-3 | PLAT | 2.01837 | 2.08889 | 0.000257117 | 0 | 29.7642 | 0.0600752 | 0.0266101 | 70 | 380.144
PLAT | STEEL/E36-3 | 4088.5 | 24793.5 | 67588.4 | +3.950 | +4.227 | 221 | N11 | 1 | 1006 | GRENAILLE-PEINT | E36-3 | PLAT | 1.50225 | 1.51992 | 0.00019137 | 0.000549999 | 29.9751 | 0.0450302 | 0.019362 | 70 | 276.6
PLAT | STEEL/E36-3 | 4088.5 | 24793.5 | 67511.6 | +3.950 | +4.227 | 221 | N11 | 1 | 1006 | GRENAILLE-PEINT | E36-3 | PLAT | 1.50225 | 1.51992 | 0.00019137 | 0.000549999 | 29.9751 | 0.0450302 | 0.019362 | 70 | 276.6
PLAT | STEEL/E36-3 | 5741.5 | 24793.5 | 67511.6 | +5.603 | +5.880 | 221 | N11 | 1 | 1006 | GRENAILLE-PEINT | E36-3 | PLAT | 1.50225 | 1.51992 | 0.00019137 | 0.000549999 | 29.9751 | 0.0450302 | 0.019362 | 70 | 276.6
PLAT | STEEL/E36-3 | 5741.5 | 24793.5 | 67588.4 | +5.603 | +5.880 | 221 | N11 | 1 | 1006 | GRENAILLE-PEINT | E36-3 | PLAT | 1.50225 | 1.51992 | 0.00019137 | 0.000549999 | 29.9751 | 0.0450302 | 0.019362 | 70 | 276.6
PLAT | STEEL/E36-3 | 5741.5 | 24650 | 67511.1 | +5.603 | +5.880 | 222 | N11 | 1 | 1006 | GRENAILLE-PEINT | E36-3 | PLAT | 2.01837 | 2.08889 | 0.000257117 | 0 | 29.7642 | 0.0600752 | 0.0266101 | 70 | 380.144
PLAT | STEEL/E36-3 | 5741.5 | 24650 | 67588.9 | +5.603 | +5.880 | 222 | N11 | 1 | 1006 | GRENAILLE-PEINT | E36-3 | PLAT | 2.01837 | 2.08889 | 0.000257117 | 0 | 29.7642 | 0.0600752 | 0.0266101 | 70 | 380.144
PLAT | STEEL/E36-3 | 5741.5 | 24506.5 | 67511.6 | +5.603 | +5.880 | 221 | N11 | 1 | 1006 | GRENAILLE-PEINT | E36-3 | PLAT | 1.50225 | 1.51992 | 0.00019137 | 0.000549999 | 29.9751 | 0.0450302 | 0.019362 | 70 | 276.6
PLAT | STEEL/E36-3 | 5741.5 | 24506.5 | 67588.4 | +5.603 | +5.880 | 221 | N11 | 1 | 1006 | GRENAILLE-PEINT | E36-3 | PLAT | 1.50225 | 1.51992 | 0.00019137 | 0.000549999 | 29.9751 | 0.0450302 | 0.019362 | 70 | 276.6
PLAT | STEEL/E36-3 | 4088.5 | 37650 | 67511.1 | +3.950 | +4.227 | 222 | N7 | 1 | 1006 | GRENAILLE-PEINT | E36-3 | PLAT | 2.01837 | 2.08889 | 0.000257117 | 0 | 29.7642 | 0.0600752 | 0.0266101 | 70 | 380.144
PLAT | STEEL/E36-3 | 4088.5 | 37650 | 67588.9 | +3.950 | +4.227 | 222 | N7 | 1 | 1006 | GRENAILLE-PEINT | E36-3 | PLAT | 2.01837 | 2.08889 | 0.000257117 | 0 | 29.7642 | 0.0600752 | 0.0266101 | 70 | 380.144
PLAT | STEEL/E36-3 | 5741.5 | 37650 | 67588.9 | +5.603 | +5.880 | 222 | N7 | 1 | 1006 | GRENAILLE-PEINT | E36-3 | PLAT | 2.01837 | 2.08889 | 0.000257117 | 0 | 29.7642 | 0.0600752 | 0.0266101 | 70 | 380.144
PLAT | STEEL/E36-3 | 5741.5 | 37650 | 67511.1 | +5.603 | +5.880 | 222 | N7 | 1 | 1006 | GRENAILLE-PEINT | E36-3 | PLAT | 2.01837 | 2.08889 | 0.000257117 | 0 | 29.7642 | 0.0600752 | 0.0266101 | 70 | 380.144
PLAT | STEEL/E36-3 | 5741.5 | 37506.5 | 67511.6 | +5.603 | +5.880 | 221 | N7 | 1 | 1006 | GRENAILLE-PEINT | E36-3 | PLAT | 1.50225 | 1.51992 | 0.00019137 | 0.000549999 | 29.9751 | 0.0450302 | 0.019362 | 70 | 276.6
PLAT | STEEL/E36-3 | 5741.5 | 37506.5 | 67588.4 | +5.603 | +5.880 | 221 | N7 | 1 | 1006 | GRENAILLE-PEINT | E36-3 | PLAT | 1.50225 | 1.51992 | 0.00019137 | 0.000549999 | 29.9751 | 0.0450302 | 0.019362 | 70 | 276.6
PLAT | STEEL/E36-3 | 5741.5 | 37793.5 | 67511.6 | +5.603 | +5.880 | 221 | N7 | 1 | 1006 | GRENAILLE-PEINT | E36-3 | PLAT | 1.50225 | 1.51992 | 0.00019137 | 0.000549999 | 29.9751 | 0.0450302 | 0.019362 | 70 | 276.6
PLAT | STEEL/E36-3 | 5741.5 | 37793.5 | 67588.4 | +5.603 | +5.880 | 221 | N7 | 1 | 1006 | GRENAILLE-PEINT | E36-3 | PLAT | 1.50225 | 1.51992 | 0.00019137 | 0.000549999 | 29.9751 | 0.0450302 | 0.019362 | 70 | 276.6
PLAT | STEEL/E36-3 | 4088.5 | 37506.5 | 67588.4 | +3.950 | +4.227 | 221 | N7 | 1 | 1006 | GRENAILLE-PEINT | E36-3 | PLAT | 1.50225 | 1.51992 | 0.00019137 | 0.000549999 | 29.9751 | 0.0450302 | 0.019362 | 70 | 276.6
PLAT | STEEL/E36-3 | 4088.5 | 37506.5 | 67511.6 | +3.950 | +4.227 | 221 | N7 | 1 | 1006 | GRENAILLE-PEINT | E36-3 | PLAT | 1.50225 | 1.51992 | 0.00019137 | 0.000549999 | 29.9751 | 0.0450302 | 0.019362 | 70 | 276.6
PLAT | STEEL/E36-3 | 4088.5 | 37793.5 | 67588.4 | +3.950 | +4.227 | 221 | N7 | 1 | 1006 | GRENAILLE-PEINT | E36-3 | PLAT | 1.50225 | 1.51992 | 0.00019137 | 0.000549999 | 29.9751 | 0.0450302 | 0.019362 | 70 | 276.6
PLAT | STEEL/E36-3 | 4088.5 | 37793.5 | 67511.6 | +3.950 | +4.227 | 221 | N7 | 1 | 1006 | GRENAILLE-PEINT | E36-3 | PLAT | 1.50225 | 1.51992 | 0.00019137 | 0.000549999 | 29.9751 | 0.0450302 | 0.019362 | 70 | 276.6
PLAT | STEEL/E36-3 | 5741.5 | 17233.5 | 67588.4 | +5.603 | +5.880 | 221 | N12 | 1 | 1006 | GRENAILLE-PEINT | E36-3 | PLAT | 1.50225 | 1.51992 | 0.00019137 | 0.000549999 | 29.9751 | 0.0450302 | 0.019362 | 70 | 276.6
PLAT | STEEL/E36-3 | 5741.5 | 17233.5 | 67511.6 | +5.603 | +5.880 | 221 | N12 | 1 | 1006 | GRENAILLE-PEINT | E36-3 | PLAT | 1.50225 | 1.51992 | 0.00019137 | 0.000549999 | 29.9751 | 0.0450302 | 0.019362 | 70 | 276.6
PLAT | STEEL/E36-3 | 5741.5 | 16946.5 | 67588.4 | +5.603 | +5.880 | 221 | N12 | 1 | 1006 | GRENAILLE-PEINT | E36-3 | PLAT | 1.50225 | 1.51992 | 0.00019137 | 0.000549999 | 29.9751 | 0.0450302 | 0.019362 | 70 | 276.6
PLAT | STEEL/E36-3 | 5741.5 | 16946.5 | 67511.6 | +5.603 | +5.880 | 221 | N12 | 1 | 1006 | GRENAILLE-PEINT | E36-3 | PLAT | 1.50225 | 1.51992 | 0.00019137 | 0.000549999 | 29.9751 | 0.0450302 | 0.019362 | 70 | 276.6
PLAT | STEEL/E36-3 | 5741.5 | 17090 | 67511.1 | +5.603 | +5.880 | 222 | N12 | 1 | 1006 | GRENAILLE-PEINT | E36-3 | PLAT | 2.01837 | 2.08889 | 0.000257117 | 0 | 29.7642 | 0.0600752 | 0.0266101 | 70 | 380.144
PLAT | STEEL/E36-3 | 5741.5 | 17090 | 67588.9 | +5.603 | +5.880 | 222 | N12 | 1 | 1006 | GRENAILLE-PEINT | E36-3 | PLAT | 2.01837 | 2.08889 | 0.000257117 | 0 | 29.7642 | 0.0600752 | 0.0266101 | 70 | 380.144
PLAT | STEEL/E36-3 | 4088.5 | 17233.5 | 67511.6 | +3.950 | +4.227 | 221 | N12 | 1 | 1006 | GRENAILLE-PEINT | E36-3 | PLAT | 1.50225 | 1.51992 | 0.00019137 | 0.000549999 | 29.9751 | 0.0450302 | 0.019362 | 70 | 276.6
PLAT | STEEL/E36-3 | 4088.5 | 17233.5 | 67588.4 | +3.950 | +4.227 | 221 | N12 | 1 | 1006 | GRENAILLE-PEINT | E36-3 | PLAT | 1.50225 | 1.51992 | 0.00019137 | 0.000549999 | 29.9751 | 0.0450302 | 0.019362 | 70 | 276.6
PLAT | STEEL/E36-3 | 4088.5 | 16946.5 | 67511.6 | +3.950 | +4.227 | 221 | N12 | 1 | 1006 | GRENAILLE-PEINT | E36-3 | PLAT | 1.50225 | 1.51992 | 0.00019137 | 0.000549999 | 29.9751 | 0.0450302 | 0.019362 | 70 | 276.6
PLAT | STEEL/E36-3 | 4088.5 | 16946.5 | 67588.4 | +3.950 | +4.227 | 221 | N12 | 1 | 1006 | GRENAILLE-PEINT | E36-3 | PLAT | 1.50225 | 1.51992 | 0.00019137 | 0.000549999 | 29.9751 | 0.0450302 | 0.019362 | 70 | 276.6
PLAT | STEEL/E36-3 | 4088.5 | 17090 | 67588.9 | +3.950 | +4.227 | 222 | N12 | 1 | 1006 | GRENAILLE-PEINT | E36-3 | PLAT | 2.01837 | 2.08889 | 0.000257117 | 0 | 29.7642 | 0.0600752 | 0.0266101 | 70 | 380.144
PLAT | STEEL/E36-3 | 4088.5 | 17090 | 67511.1 | +3.950 | +4.227 | 222 | N12 | 1 | 1006 | GRENAILLE-PEINT | E36-3 | PLAT | 2.01837 | 2.08889 | 0.000257117 | 0 | 29.7642 | 0.0600752 | 0.0266101 | 70 | 380.144
PLAT | STEEL/E36-3 | 5741.5 | 35193.5 | 67588.4 | +5.603 | +5.880 | 221 | N7 | 1 | 1006 | GRENAILLE-PEINT | E36-3 | PLAT | 1.50225 | 1.51992 | 0.00019137 | 0.000549999 | 29.9751 | 0.0450302 | 0.019362 | 70 | 276.6
PLAT | STEEL/E36-3 | 5741.5 | 35193.5 | 67511.6 | +5.603 | +5.880 | 221 | N7 | 1 | 1006 | GRENAILLE-PEINT | E36-3 | PLAT | 1.50225 | 1.51992 | 0.00019137 | 0.000549999 | 29.9751 | 0.0450302 | 0.019362 | 70 | 276.6
PLAT | STEEL/E36-3 | 5741.5 | 34906.5 | 67588.4 | +5.603 | +5.880 | 221 | N7 | 1 | 1006 | GRENAILLE-PEINT | E36-3 | PLAT | 1.50225 | 1.51992 | 0.00019137 | 0.000549999 | 29.9751 | 0.0450302 | 0.019362 | 70 | 276.6
PLAT | STEEL/E36-3 | 5741.5 | 34906.5 | 67511.6 | +5.603 | +5.880 | 221 | N7 | 1 | 1006 | GRENAILLE-PEINT | E36-3 | PLAT | 1.50225 | 1.51992 | 0.00019137 | 0.000549999 | 29.9751 | 0.0450302 | 0.019362 | 70 | 276.6
PLAT | STEEL/E36-3 | 5741.5 | 35050 | 67511.1 | +5.603 | +5.880 | 222 | N7 | 1 | 1006 | GRENAILLE-PEINT | E36-3 | PLAT | 2.01837 | 2.08889 | 0.000257117 | 0 | 29.7642 | 0.0600752 | 0.0266101 | 70 | 380.144
PLAT | STEEL/E36-3 | 5741.5 | 35050 | 67588.9 | +5.603 | +5.880 | 222 | N7 | 1 | 1006 | GRENAILLE-PEINT | E36-3 | PLAT | 2.01837 | 2.08889 | 0.000257117 | 0 | 29.7642 | 0.0600752 | 0.0266101 | 70 | 380.144
PLAT | STEEL/E36-3 | 4088.5 | 35193.5 | 67511.6 | +3.950 | +4.227 | 221 | N7 | 1 | 1006 | GRENAILLE-PEINT | E36-3 | PLAT | 1.50225 | 1.51992 | 0.00019137 | 0.000549999 | 29.9751 | 0.0450302 | 0.019362 | 70 | 276.6
PLAT | STEEL/E36-3 | 4088.5 | 35193.5 | 67588.4 | +3.950 | +4.227 | 221 | N7 | 1 | 1006 | GRENAILLE-PEINT | E36-3 | PLAT | 1.50225 | 1.51992 | 0.00019137 | 0.000549999 | 29.9751 | 0.0450302 | 0.019362 | 70 | 276.6
PLAT | STEEL/E36-3 | 4088.5 | 34906.5 | 67511.6 | +3.950 | +4.227 | 221 | N7 | 1 | 1006 | GRENAILLE-PEINT | E36-3 | PLAT | 1.50225 | 1.51992 | 0.00019137 | 0.000549999 | 29.9751 | 0.0450302 | 0.019362 | 70 | 276.6
PLAT | STEEL/E36-3 | 4088.5 | 34906.5 | 67588.4 | +3.950 | +4.227 | 221 | N7 | 1 | 1006 | GRENAILLE-PEINT | E36-3 | PLAT | 1.50225 | 1.51992 | 0.00019137 | 0.000549999 | 29.9751 | 0.0450302 | 0.019362 | 70 | 276.6
PLAT | STEEL/E36-3 | 4088.5 | 35050 | 67588.9 | +3.950 | +4.227 | 222 | N7 | 1 | 1006 | GRENAILLE-PEINT | E36-3 | PLAT | 2.01837 | 2.08889 | 0.000257117 | 0 | 29.7642 | 0.0600752 | 0.0266101 | 70 | 380.144
PLAT | STEEL/E36-3 | 4088.5 | 35050 | 67511.1 | +3.950 | +4.227 | 222 | N7 | 1 | 1006 | GRENAILLE-PEINT | E36-3 | PLAT | 2.01837 | 2.08889 | 0.000257117 | 0 | 29.7642 | 0.0600752 | 0.0266101 | 70 | 380.144
PLAT | STEEL/E36-3 | 5741.5 | 42993.5 | 67511.6 | +5.603 | +5.880 | 221 | N6 | 1 | 1006 | GRENAILLE-PEINT | E36-3 | PLAT | 1.50225 | 1.51992 | 0.00019137 | 0.000549999 | 29.9751 | 0.0450302 | 0.019362 | 70 | 276.6
PLAT | STEEL/E36-3 | 4088.5 | 42993.5 | 67588.4 | +3.950 | +4.227 | 221 | N6 | 1 | 1006 | GRENAILLE-PEINT | E36-3 | PLAT | 1.50225 | 1.51992 | 0.00019137 | 0.000549999 | 29.9751 | 0.0450302 | 0.019362 | 70 | 276.6
PLAT | STEEL/E36-3 | 4088.5 | 42993.5 | 67511.6 | +3.950 | +4.227 | 221 | N6 | 1 | 1006 | GRENAILLE-PEINT | E36-3 | PLAT | 1.50225 | 1.51992 | 0.00019137 | 0.000549999 | 29.9751 | 0.0450302 | 0.019362 | 70 | 276.6
PLAT | STEEL/E36-3 | 4088.5 | 45593.5 | 67511.6 | +3.950 | +4.227 | 221 | N6 | 1 | 1006 | GRENAILLE-PEINT | E36-3 | PLAT | 1.50225 | 1.51992 | 0.00019137 | 0.000549999 | 29.9751 | 0.0450302 | 0.019362 | 70 | 276.6
PLAT | STEEL/E36-3 | 4088.5 | 45593.5 | 67588.4 | +3.950 | +4.227 | 221 | N6 | 1 | 1006 | GRENAILLE-PEINT | E36-3 | PLAT | 1.50225 | 1.51992 | 0.00019137 | 0.000549999 | 29.9751 | 0.0450302 | 0.019362 | 70 | 276.6
PLAT | STEEL/E36-3 | 4088.5 | 45450 | 67511.1 | +3.950 | +4.227 | 222 | N6 | 1 | 1006 | GRENAILLE-PEINT | E36-3 | PLAT | 2.01837 | 2.08889 | 0.000257117 | 0 | 29.7642 | 0.0600752 | 0.0266101 | 70 | 380.144
PLAT | STEEL/E36-3 | 4088.5 | 45306.5 | 67511.6 | +3.950 | +4.227 | 221 | N6 | 1 | 1006 | GRENAILLE-PEINT | E36-3 | PLAT | 1.50225 | 1.51992 | 0.00019137 | 0.000549999 | 29.9751 | 0.0450302 | 0.019362 | 70 | 276.6
PLAT | STEEL/E36-3 | 4088.5 | 45306.5 | 67588.4 | +3.950 | +4.227 | 221 | N6 | 1 | 1006 | GRENAILLE-PEINT | E36-3 | PLAT | 1.50225 | 1.51992 | 0.00019137 | 0.000549999 | 29.9751 | 0.0450302 | 0.019362 | 70 | 276.6
PLAT | STEEL/E36-3 | 4088.5 | 45450 | 67588.9 | +3.950 | +4.227 | 222 | N6 | 1 | 1006 | GRENAILLE-PEINT | E36-3 | PLAT | 2.01837 | 2.08889 | 0.000257117 | 0 | 29.7642 | 0.0600752 | 0.0266101 | 70 | 380.144
PLAT | STEEL/E36-3 | 5741.5 | 45306.5 | 67588.4 | +5.603 | +5.880 | 221 | N6 | 1 | 1006 | GRENAILLE-PEINT | E36-3 | PLAT | 1.50225 | 1.51992 | 0.00019137 | 0.000549999 | 29.9751 | 0.0450302 | 0.019362 | 70 | 276.6
PLAT | STEEL/E36-3 | 5741.5 | 45306.5 | 67511.6 | +5.603 | +5.880 | 221 | N6 | 1 | 1006 | GRENAILLE-PEINT | E36-3 | PLAT | 1.50225 | 1.51992 | 0.00019137 | 0.000549999 | 29.9751 | 0.0450302 | 0.019362 | 70 | 276.6
PLAT | STEEL/E36-3 | 5741.5 | 45450 | 67588.9 | +5.603 | +5.880 | 222 | N6 | 1 | 1006 | GRENAILLE-PEINT | E36-3 | PLAT | 2.01837 | 2.08889 | 0.000257117 | 0 | 29.7642 | 0.0600752 | 0.0266101 | 70 | 380.144
PLAT | STEEL/E36-3 | 5741.5 | 45450 | 67511.1 | +5.603 | +5.880 | 222 | N6 | 1 | 1006 | GRENAILLE-PEINT | E36-3 | PLAT | 2.01837 | 2.08889 | 0.000257117 | 0 | 29.7642 | 0.0600752 | 0.0266101 | 70 | 380.144
PLAT | STEEL/E36-3 | 5741.5 | 45593.5 | 67588.4 | +5.603 | +5.880 | 221 | N6 | 1 | 1006 | GRENAILLE-PEINT | E36-3 | PLAT | 1.50225 | 1.51992 | 0.00019137 | 0.000549999 | 29.9751 | 0.0450302 | 0.019362 | 70 | 276.6
PLAT | STEEL/E36-3 | 5741.5 | 45593.5 | 67511.6 | +5.603 | +5.880 | 221 | N6 | 1 | 1006 | GRENAILLE-PEINT | E36-3 | PLAT | 1.50225 | 1.51992 | 0.00019137 | 0.000549999 | 29.9751 | 0.0450302 | 0.019362 | 70 | 276.6
PLAT | STEEL/E36-3 | 4088.5 | 58593.5 | 67511.6 | +3.950 | +4.227 | 221 | N13 | 1 | 1006 | GRENAILLE-PEINT | E36-3 | PLAT | 1.50225 | 1.51992 | 0.00019137 | 0.000549999 | 29.9751 | 0.0450302 | 0.019362 | 70 | 276.6
PLAT | STEEL/E36-3 | 4088.5 | 58593.5 | 67588.4 | +3.950 | +4.227 | 221 | N13 | 1 | 1006 | GRENAILLE-PEINT | E36-3 | PLAT | 1.50225 | 1.51992 | 0.00019137 | 0.000549999 | 29.9751 | 0.0450302 | 0.019362 | 70 | 276.6
PLAT | STEEL/E36-3 | 4088.5 | 58306.5 | 67511.6 | +3.950 | +4.227 | 221 | N13 | 1 | 1006 | GRENAILLE-PEINT | E36-3 | PLAT | 1.50225 | 1.51992 | 0.00019137 | 0.000549999 | 29.9751 | 0.0450302 | 0.019362 | 70 | 276.6
PLAT | STEEL/E36-3 | 4088.5 | 58306.5 | 67588.4 | +3.950 | +4.227 | 221 | N13 | 1 | 1006 | GRENAILLE-PEINT | E36-3 | PLAT | 1.50225 | 1.51992 | 0.00019137 | 0.000549999 | 29.9751 | 0.0450302 | 0.019362 | 70 | 276.6
PLAT | STEEL/E36-3 | 4088.5 | 58450 | 67588.9 | +3.950 | +4.227 | 222 | N13 | 1 | 1006 | GRENAILLE-PEINT | E36-3 | PLAT | 2.01837 | 2.08889 | 0.000257117 | 0 | 29.7642 | 0.0600752 | 0.0266101 | 70 | 380.144
PLAT | STEEL/E36-3 | 4088.5 | 58450 | 67511.1 | +3.950 | +4.227 | 222 | N13 | 1 | 1006 | GRENAILLE-PEINT | E36-3 | PLAT | 2.01837 | 2.08889 | 0.000257117 | 0 | 29.7642 | 0.0600752 | 0.0266101 | 70 | 380.144
PLAT | STEEL/E36-3 | 5741.5 | 58593.5 | 67588.4 | +5.603 | +5.880 | 221 | N13 | 1 | 1006 | GRENAILLE-PEINT | E36-3 | PLAT | 1.50225 | 1.51992 | 0.00019137 | 0.000549999 | 29.9751 | 0.0450302 | 0.019362 | 70 | 276.6
PLAT | STEEL/E36-3 | 5741.5 | 58593.5 | 67511.6 | +5.603 | +5.880 | 221 | N13 | 1 | 1006 | GRENAILLE-PEINT | E36-3 | PLAT | 1.50225 | 1.51992 | 0.00019137 | 0.000549999 | 29.9751 | 0.0450302 | 0.019362 | 70 | 276.6
PLAT | STEEL/E36-3 | 5741.5 | 58306.5 | 67588.4 | +5.603 | +5.880 | 221 | N13 | 1 | 1006 | GRENAILLE-PEINT | E36-3 | PLAT | 1.50225 | 1.51992 | 0.00019137 | 0.000549999 | 29.9751 | 0.0450302 | 0.019362 | 70 | 276.6
PLAT | STEEL/E36-3 | 5741.5 | 58306.5 | 67511.6 | +5.603 | +5.880 | 221 | N13 | 1 | 1006 | GRENAILLE-PEINT | E36-3 | PLAT | 1.50225 | 1.51992 | 0.00019137 | 0.000549999 | 29.9751 | 0.0450302 | 0.019362 | 70 | 276.6
PLAT | STEEL/E36-3 | 5741.5 | 58450 | 67511.1 | +5.603 | +5.880 | 222 | N13 | 1 | 1006 | GRENAILLE-PEINT | E36-3 | PLAT | 2.01837 | 2.08889 | 0.000257117 | 0 | 29.7642 | 0.0600752 | 0.0266101 | 70 | 380.144
PLAT | STEEL/E36-3 | 5741.5 | 58450 | 67588.9 | +5.603 | +5.880 | 222 | N13 | 1 | 1006 | GRENAILLE-PEINT | E36-3 | PLAT | 2.01837 | 2.08889 | 0.000257117 | 0 | 29.7642 | 0.0600752 | 0.0266101 | 70 | 380.144
PLAT | STEEL/E36-3 | 4088.5 | 55850 | 67511.1 | +3.950 | +4.227 | 222 | N13 | 1 | 1006 | GRENAILLE-PEINT | E36-3 | PLAT | 2.01837 | 2.08889 | 0.000257117 | 0 | 29.7642 | 0.0600752 | 0.0266101 | 70 | 380.144
PLAT | STEEL/E36-3 | 4088.5 | 55850 | 67588.9 | +3.950 | +4.227 | 222 | N13 | 1 | 1006 | GRENAILLE-PEINT | E36-3 | PLAT | 2.01837 | 2.08889 | 0.000257117 | 0 | 29.7642 | 0.0600752 | 0.0266101 | 70 | 380.144
PLAT | STEEL/E36-3 | 4088.5 | 55706.5 | 67588.4 | +3.950 | +4.227 | 221 | N13 | 1 | 1006 | GRENAILLE-PEINT | E36-3 | PLAT | 1.50225 | 1.51992 | 0.00019137 | 0.000549999 | 29.9751 | 0.0450302 | 0.019362 | 70 | 276.6
PLAT | STEEL/E36-3 | 4088.5 | 55706.5 | 67511.6 | +3.950 | +4.227 | 221 | N13 | 1 | 1006 | GRENAILLE-PEINT | E36-3 | PLAT | 1.50225 | 1.51992 | 0.00019137 | 0.000549999 | 29.9751 | 0.0450302 | 0.019362 | 70 | 276.6
PLAT | STEEL/E36-3 | 4088.5 | 55993.5 | 67588.4 | +3.950 | +4.227 | 221 | N13 | 1 | 1006 | GRENAILLE-PEINT | E36-3 | PLAT | 1.50225 | 1.51992 | 0.00019137 | 0.000549999 | 29.9751 | 0.0450302 | 0.019362 | 70 | 276.6
PLAT | STEEL/E36-3 | 4088.5 | 55993.5 | 67511.6 | +3.950 | +4.227 | 221 | N13 | 1 | 1006 | GRENAILLE-PEINT | E36-3 | PLAT | 1.50225 | 1.51992 | 0.00019137 | 0.000549999 | 29.9751 | 0.0450302 | 0.019362 | 70 | 276.6
PLAT | STEEL/E36-3 | 5741.5 | 55850 | 67588.9 | +5.603 | +5.880 | 222 | N13 | 1 | 1006 | GRENAILLE-PEINT | E36-3 | PLAT | 2.01837 | 2.08889 | 0.000257117 | 0 | 29.7642 | 0.0600752 | 0.0266101 | 70 | 380.144
PLAT | STEEL/E36-3 | 5741.5 | 55850 | 67511.1 | +5.603 | +5.880 | 222 | N13 | 1 | 1006 | GRENAILLE-PEINT | E36-3 | PLAT | 2.01837 | 2.08889 | 0.000257117 | 0 | 29.7642 | 0.0600752 | 0.0266101 | 70 | 380.144
PLAT | STEEL/E36-3 | 5741.5 | 55706.5 | 67511.6 | +5.603 | +5.880 | 221 | N13 | 1 | 1006 | GRENAILLE-PEINT | E36-3 | PLAT | 1.50225 | 1.51992 | 0.00019137 | 0.000549999 | 29.9751 | 0.0450302 | 0.019362 | 70 | 276.6
PLAT | STEEL/E36-3 | 5741.5 | 55706.5 | 67588.4 | +5.603 | +5.880 | 221 | N13 | 1 | 1006 | GRENAILLE-PEINT | E36-3 | PLAT | 1.50225 | 1.51992 | 0.00019137 | 0.000549999 | 29.9751 | 0.0450302 | 0.019362 | 70 | 276.6
PLAT | STEEL/E36-3 | 5741.5 | 55993.5 | 67511.6 | +5.603 | +5.880 | 221 | N13 | 1 | 1006 | GRENAILLE-PEINT | E36-3 | PLAT | 1.50225 | 1.51992 | 0.00019137 | 0.000549999 | 29.9751 | 0.0450302 | 0.019362 | 70 | 276.6
PLAT | STEEL/E36-3 | 5741.5 | 55993.5 | 67588.4 | +5.603 | +5.880 | 221 | N13 | 1 | 1006 | GRENAILLE-PEINT | E36-3 | PLAT | 1.50225 | 1.51992 | 0.00019137 | 0.000549999 | 29.9751 | 0.0450302 | 0.019362 | 70 | 276.6
PLAT | STEEL/E36-3 | 4088.5 | 63606.5 | 67588.4 | +3.950 | +4.227 | 221 | N17 | 1 | 1006 | GRENAILLE-PEINT | E36-3 | PLAT | 1.50225 | 1.51992 | 0.00019137 | 0.000549999 | 29.9751 | 0.0450302 | 0.019362 | 70 | 276.6
PLAT | STEEL/E36-3 | 4088.5 | 63606.5 | 67511.6 | +3.950 | +4.227 | 221 | N17 | 1 | 1006 | GRENAILLE-PEINT | E36-3 | PLAT | 1.50225 | 1.51992 | 0.00019137 | 0.000549999 | 29.9751 | 0.0450302 | 0.019362 | 70 | 276.6
PLAT | STEEL/E36-3 | 4088.5 | 63893.5 | 67588.4 | +3.950 | +4.227 | 221 | N17 | 1 | 1006 | GRENAILLE-PEINT | E36-3 | PLAT | 1.50225 | 1.51992 | 0.00019137 | 0.000549999 | 29.9751 | 0.0450302 | 0.019362 | 70 | 276.6
PLAT | STEEL/E36-3 | 4088.5 | 63893.5 | 67511.6 | +3.950 | +4.227 | 221 | N17 | 1 | 1006 | GRENAILLE-PEINT | E36-3 | PLAT | 1.50225 | 1.51992 | 0.00019137 | 0.000549999 | 29.9751 | 0.0450302 | 0.019362 | 70 | 276.6
PLAT | STEEL/E36-3 | 5741.5 | 63606.5 | 67511.6 | +5.603 | +5.880 | 221 | N17 | 1 | 1006 | GRENAILLE-PEINT | E36-3 | PLAT | 1.50225 | 1.51992 | 0.00019137 | 0.000549999 | 29.9751 | 0.0450302 | 0.019362 | 70 | 276.6
PLAT | STEEL/E36-3 | 5741.5 | 63606.5 | 67588.4 | +5.603 | +5.880 | 221 | N17 | 1 | 1006 | GRENAILLE-PEINT | E36-3 | PLAT | 1.50225 | 1.51992 | 0.00019137 | 0.000549999 | 29.9751 | 0.0450302 | 0.019362 | 70 | 276.6
PLAT | STEEL/E36-3 | 5741.5 | 63893.5 | 67511.6 | +5.603 | +5.880 | 221 | N17 | 1 | 1006 | GRENAILLE-PEINT | E36-3 | PLAT | 1.50225 | 1.51992 | 0.00019137 | 0.000549999 | 29.9751 | 0.0450302 | 0.019362 | 70 | 276.6
PLAT | STEEL/E36-3 | 5741.5 | 63893.5 | 67588.4 | +5.603 | +5.880 | 221 | N17 | 1 | 1006 | GRENAILLE-PEINT | E36-3 | PLAT | 1.50225 | 1.51992 | 0.00019137 | 0.000549999 | 29.9751 | 0.0450302 | 0.019362 | 70 | 276.6
PLAT | STEEL/E36-3 | 4088.5 | 66306.5 | 67588.4 | +3.950 | +4.227 | 221 | N17 | 1 | 1006 | GRENAILLE-PEINT | E36-3 | PLAT | 1.50225 | 1.51992 | 0.00019137 | 0.000549999 | 29.9751 | 0.0450302 | 0.019362 | 70 | 276.6
PLAT | STEEL/E36-3 | 4088.5 | 66306.5 | 67511.6 | +3.950 | +4.227 | 221 | N17 | 1 | 1006 | GRENAILLE-PEINT | E36-3 | PLAT | 1.50225 | 1.51992 | 0.00019137 | 0.000549999 | 29.9751 | 0.0450302 | 0.019362 | 70 | 276.6
PLAT | STEEL/E36-3 | 4088.5 | 66593.5 | 67588.4 | +3.950 | +4.227 | 221 | N17 | 1 | 1006 | GRENAILLE-PEINT | E36-3 | PLAT | 1.50225 | 1.51992 | 0.00019137 | 0.000549999 | 29.9751 | 0.0450302 | 0.019362 | 70 | 276.6
PLAT | STEEL/E36-3 | 4088.5 | 66593.5 | 67511.6 | +3.950 | +4.227 | 221 | N17 | 1 | 1006 | GRENAILLE-PEINT | E36-3 | PLAT | 1.50225 | 1.51992 | 0.00019137 | 0.000549999 | 29.9751 | 0.0450302 | 0.019362 | 70 | 276.6
PLAT | STEEL/E36-3 | 5741.5 | 66306.5 | 67511.6 | +5.603 | +5.880 | 221 | N17 | 1 | 1006 | GRENAILLE-PEINT | E36-3 | PLAT | 1.50225 | 1.51992 | 0.00019137 | 0.000549999 | 29.9751 | 0.0450302 | 0.019362 | 70 | 276.6
PLAT | STEEL/E36-3 | 5741.5 | 66306.5 | 67588.4 | +5.603 | +5.880 | 221 | N17 | 1 | 1006 | GRENAILLE-PEINT | E36-3 | PLAT | 1.50225 | 1.51992 | 0.00019137 | 0.000549999 | 29.9751 | 0.0450302 | 0.019362 | 70 | 276.6
PLAT | STEEL/E36-3 | 5741.5 | 66593.5 | 67511.6 | +5.603 | +5.880 | 221 | N17 | 1 | 1006 | GRENAILLE-PEINT | E36-3 | PLAT | 1.50225 | 1.51992 | 0.00019137 | 0.000549999 | 29.9751 | 0.0450302 | 0.019362 | 70 | 276.6
PLAT | STEEL/E36-3 | 5741.5 | 66593.5 | 67588.4 | +5.603 | +5.880 | 221 | N17 | 1 | 1006 | GRENAILLE-PEINT | E36-3 | PLAT | 1.50225 | 1.51992 | 0.00019137 | 0.000549999 | 29.9751 | 0.0450302 | 0.019362 | 70 | 276.6
PLAT | STEEL/E36-3 | 4088.5 | 53106.5 | 67588.4 | +3.950 | +4.227 | 221 | N13 | 1 | 1006 | GRENAILLE-PEINT | E36-3 | PLAT | 1.50225 | 1.51992 | 0.00019137 | 0.000549999 | 29.9751 | 0.0450302 | 0.019362 | 70 | 276.6
PLAT | STEEL/E36-3 | 4088.5 | 53106.5 | 67511.6 | +3.950 | +4.227 | 221 | N13 | 1 | 1006 | GRENAILLE-PEINT | E36-3 | PLAT | 1.50225 | 1.51992 | 0.00019137 | 0.000549999 | 29.9751 | 0.0450302 | 0.019362 | 70 | 276.6
PLAT | STEEL/E36-3 | 4088.5 | 53393.5 | 67588.4 | +3.950 | +4.227 | 221 | N13 | 1 | 1006 | GRENAILLE-PEINT | E36-3 | PLAT | 1.50225 | 1.51992 | 0.00019137 | 0.000549999 | 29.9751 | 0.0450302 | 0.019362 | 70 | 276.6
PLAT | STEEL/E36-3 | 4088.5 | 53393.5 | 67511.6 | +3.950 | +4.227 | 221 | N13 | 1 | 1006 | GRENAILLE-PEINT | E36-3 | PLAT | 1.50225 | 1.51992 | 0.00019137 | 0.000549999 | 29.9751 | 0.0450302 | 0.019362 | 70 | 276.6
PLAT | STEEL/E36-3 | 5741.5 | 53106.5 | 67511.6 | +5.603 | +5.880 | 221 | N13 | 1 | 1006 | GRENAILLE-PEINT | E36-3 | PLAT | 1.50225 | 1.51992 | 0.00019137 | 0.000549999 | 29.9751 | 0.0450302 | 0.019362 | 70 | 276.6
PLAT | STEEL/E36-3 | 5741.5 | 53106.5 | 67588.4 | +5.603 | +5.880 | 221 | N13 | 1 | 1006 | GRENAILLE-PEINT | E36-3 | PLAT | 1.50225 | 1.51992 | 0.00019137 | 0.000549999 | 29.9751 | 0.0450302 | 0.019362 | 70 | 276.6
PLAT | STEEL/E36-3 | 5741.5 | 53393.5 | 67511.6 | +5.603 | +5.880 | 221 | N13 | 1 | 1006 | GRENAILLE-PEINT | E36-3 | PLAT | 1.50225 | 1.51992 | 0.00019137 | 0.000549999 | 29.9751 | 0.0450302 | 0.019362 | 70 | 276.6
PLAT | STEEL/E36-3 | 5741.5 | 53393.5 | 67588.4 | +5.603 | +5.880 | 221 | N13 | 1 | 1006 | GRENAILLE-PEINT | E36-3 | PLAT | 1.50225 | 1.51992 | 0.00019137 | 0.000549999 | 29.9751 | 0.0450302 | 0.019362 | 70 | 276.6
PLAT | STEEL/E36-3 | 4088.5 | 50506.5 | 67588.4 | +3.950 | +4.227 | 221 | N6 | 1 | 1006 | GRENAILLE-PEINT | E36-3 | PLAT | 1.50225 | 1.51992 | 0.00019137 | 0.000549999 | 29.9751 | 0.0450302 | 0.019362 | 70 | 276.6
PLAT | STEEL/E36-3 | 4088.5 | 50506.5 | 67511.6 | +3.950 | +4.227 | 221 | N6 | 1 | 1006 | GRENAILLE-PEINT | E36-3 | PLAT | 1.50225 | 1.51992 | 0.00019137 | 0.000549999 | 29.9751 | 0.0450302 | 0.019362 | 70 | 276.6
PLAT | STEEL/E36-3 | 4088.5 | 50793.5 | 67588.4 | +3.950 | +4.227 | 221 | N6 | 1 | 1006 | GRENAILLE-PEINT | E36-3 | PLAT | 1.50225 | 1.51992 | 0.00019137 | 0.000549999 | 29.9751 | 0.0450302 | 0.019362 | 70 | 276.6
PLAT | STEEL/E36-3 | 4088.5 | 50793.5 | 67511.6 | +3.950 | +4.227 | 221 | N6 | 1 | 1006 | GRENAILLE-PEINT | E36-3 | PLAT | 1.50225 | 1.51992 | 0.00019137 | 0.000549999 | 29.9751 | 0.0450302 | 0.019362 | 70 | 276.6
PLAT | STEEL/E36-3 | 5741.5 | 50506.5 | 67511.6 | +5.603 | +5.880 | 221 | N6 | 1 | 1006 | GRENAILLE-PEINT | E36-3 | PLAT | 1.50225 | 1.51992 | 0.00019137 | 0.000549999 | 29.9751 | 0.0450302 | 0.019362 | 70 | 276.6
PLAT | STEEL/E36-3 | 5741.5 | 50506.5 | 67588.4 | +5.603 | +5.880 | 221 | N6 | 1 | 1006 | GRENAILLE-PEINT | E36-3 | PLAT | 1.50225 | 1.51992 | 0.00019137 | 0.000549999 | 29.9751 | 0.0450302 | 0.019362 | 70 | 276.6
PLAT | STEEL/E36-3 | 5741.5 | 50793.5 | 67511.6 | +5.603 | +5.880 | 221 | N6 | 1 | 1006 | GRENAILLE-PEINT | E36-3 | PLAT | 1.50225 | 1.51992 | 0.00019137 | 0.000549999 | 29.9751 | 0.0450302 | 0.019362 | 70 | 276.6
PLAT | STEEL/E36-3 | 5741.5 | 50793.5 | 67588.4 | +5.603 | +5.880 | 221 | N6 | 1 | 1006 | GRENAILLE-PEINT | E36-3 | PLAT | 1.50225 | 1.51992 | 0.00019137 | 0.000549999 | 29.9751 | 0.0450302 | 0.019362 | 70 | 276.6
PLAT | STEEL/E36-3 | 4088.5 | 47906.5 | 67588.4 | +3.950 | +4.227 | 221 | N6 | 1 | 1006 | GRENAILLE-PEINT | E36-3 | PLAT | 1.50225 | 1.51992 | 0.00019137 | 0.000549999 | 29.9751 | 0.0450302 | 0.019362 | 70 | 276.6
PLAT | STEEL/E36-3 | 4088.5 | 47906.5 | 67511.6 | +3.950 | +4.227 | 221 | N6 | 1 | 1006 | GRENAILLE-PEINT | E36-3 | PLAT | 1.50225 | 1.51992 | 0.00019137 | 0.000549999 | 29.9751 | 0.0450302 | 0.019362 | 70 | 276.6
PLAT | STEEL/E36-3 | 4088.5 | 48193.5 | 67588.4 | +3.950 | +4.227 | 221 | N6 | 1 | 1006 | GRENAILLE-PEINT | E36-3 | PLAT | 1.50225 | 1.51992 | 0.00019137 | 0.000549999 | 29.9751 | 0.0450302 | 0.019362 | 70 | 276.6
PLAT | STEEL/E36-3 | 4088.5 | 48193.5 | 67511.6 | +3.950 | +4.227 | 221 | N6 | 1 | 1006 | GRENAILLE-PEINT | E36-3 | PLAT | 1.50225 | 1.51992 | 0.00019137 | 0.000549999 | 29.9751 | 0.0450302 | 0.019362 | 70 | 276.6
PLAT | STEEL/E36-3 | 5741.5 | 47906.5 | 67511.6 | +5.603 | +5.880 | 221 | N6 | 1 | 1006 | GRENAILLE-PEINT | E36-3 | PLAT | 1.50225 | 1.51992 | 0.00019137 | 0.000549999 | 29.9751 | 0.0450302 | 0.019362 | 70 | 276.6
PLAT | STEEL/E36-3 | 5741.5 | 47906.5 | 67588.4 | +5.603 | +5.880 | 221 | N6 | 1 | 1006 | GRENAILLE-PEINT | E36-3 | PLAT | 1.50225 | 1.51992 | 0.00019137 | 0.000549999 | 29.9751 | 0.0450302 | 0.019362 | 70 | 276.6
PLAT | STEEL/E36-3 | 5741.5 | 48193.5 | 67511.6 | +5.603 | +5.880 | 221 | N6 | 1 | 1006 | GRENAILLE-PEINT | E36-3 | PLAT | 1.50225 | 1.51992 | 0.00019137 | 0.000549999 | 29.9751 | 0.0450302 | 0.019362 | 70 | 276.6
PLAT | STEEL/E36-3 | 5741.5 | 48193.5 | 67588.4 | +5.603 | +5.880 | 221 | N6 | 1 | 1006 | GRENAILLE-PEINT | E36-3 | PLAT | 1.50225 | 1.51992 | 0.00019137 | 0.000549999 | 29.9751 | 0.0450302 | 0.019362 | 70 | 276.6
PLAT | STEEL/E36-3 | 4088.5 | 32306.5 | 67588.4 | +3.950 | +4.227 | 221 | N7 | 1 | 1006 | GRENAILLE-PEINT | E36-3 | PLAT | 1.50225 | 1.51992 | 0.00019137 | 0.000549999 | 29.9751 | 0.0450302 | 0.019362 | 70 | 276.6
PLAT | STEEL/E36-3 | 4088.5 | 32306.5 | 67511.6 | +3.950 | +4.227 | 221 | N7 | 1 | 1006 | GRENAILLE-PEINT | E36-3 | PLAT | 1.50225 | 1.51992 | 0.00019137 | 0.000549999 | 29.9751 | 0.0450302 | 0.019362 | 70 | 276.6
PLAT | STEEL/E36-3 | 4088.5 | 32593.5 | 67588.4 | +3.950 | +4.227 | 221 | N7 | 1 | 1006 | GRENAILLE-PEINT | E36-3 | PLAT | 1.50225 | 1.51992 | 0.00019137 | 0.000549999 | 29.9751 | 0.0450302 | 0.019362 | 70 | 276.6
PLAT | STEEL/E36-3 | 4088.5 | 32593.5 | 67511.6 | +3.950 | +4.227 | 221 | N7 | 1 | 1006 | GRENAILLE-PEINT | E36-3 | PLAT | 1.50225 | 1.51992 | 0.00019137 | 0.000549999 | 29.9751 | 0.0450302 | 0.019362 | 70 | 276.6
PLAT | STEEL/E36-3 | 5741.5 | 32306.5 | 67511.6 | +5.603 | +5.880 | 221 | N7 | 1 | 1006 | GRENAILLE-PEINT | E36-3 | PLAT | 1.50225 | 1.51992 | 0.00019137 | 0.000549999 | 29.9751 | 0.0450302 | 0.019362 | 70 | 276.6
PLAT | STEEL/E36-3 | 5741.5 | 32306.5 | 67588.4 | +5.603 | +5.880 | 221 | N7 | 1 | 1006 | GRENAILLE-PEINT | E36-3 | PLAT | 1.50225 | 1.51992 | 0.00019137 | 0.000549999 | 29.9751 | 0.0450302 | 0.019362 | 70 | 276.6
PLAT | STEEL/E36-3 | 5741.5 | 32593.5 | 67511.6 | +5.603 | +5.880 | 221 | N7 | 1 | 1006 | GRENAILLE-PEINT | E36-3 | PLAT | 1.50225 | 1.51992 | 0.00019137 | 0.000549999 | 29.9751 | 0.0450302 | 0.019362 | 70 | 276.6
PLAT | STEEL/E36-3 | 5741.5 | 32593.5 | 67588.4 | +5.603 | +5.880 | 221 | N7 | 1 | 1006 | GRENAILLE-PEINT | E36-3 | PLAT | 1.50225 | 1.51992 | 0.00019137 | 0.000549999 | 29.9751 | 0.0450302 | 0.019362 | 70 | 276.6
PLAT | STEEL/E36-3 | 4088.5 | 29706.5 | 67588.4 | +3.950 | +4.227 | 221 | N7 | 1 | 1006 | GRENAILLE-PEINT | E36-3 | PLAT | 1.50225 | 1.51992 | 0.00019137 | 0.000549999 | 29.9751 | 0.0450302 | 0.019362 | 70 | 276.6
PLAT | STEEL/E36-3 | 4088.5 | 29706.5 | 67511.6 | +3.950 | +4.227 | 221 | N7 | 1 | 1006 | GRENAILLE-PEINT | E36-3 | PLAT | 1.50225 | 1.51992 | 0.00019137 | 0.000549999 | 29.9751 | 0.0450302 | 0.019362 | 70 | 276.6
PLAT | STEEL/E36-3 | 4088.5 | 29993.5 | 67588.4 | +3.950 | +4.227 | 221 | N7 | 1 | 1006 | GRENAILLE-PEINT | E36-3 | PLAT | 1.50225 | 1.51992 | 0.00019137 | 0.000549999 | 29.9751 | 0.0450302 | 0.019362 | 70 | 276.6
PLAT | STEEL/E36-3 | 4088.5 | 29993.5 | 67511.6 | +3.950 | +4.227 | 221 | N7 | 1 | 1006 | GRENAILLE-PEINT | E36-3 | PLAT | 1.50225 | 1.51992 | 0.00019137 | 0.000549999 | 29.9751 | 0.0450302 | 0.019362 | 70 | 276.6
PLAT | STEEL/E36-3 | 5741.5 | 29706.5 | 67511.6 | +5.603 | +5.880 | 221 | N7 | 1 | 1006 | GRENAILLE-PEINT | E36-3 | PLAT | 1.50225 | 1.51992 | 0.00019137 | 0.000549999 | 29.9751 | 0.0450302 | 0.019362 | 70 | 276.6
PLAT | STEEL/E36-3 | 5741.5 | 29706.5 | 67588.4 | +5.603 | +5.880 | 221 | N7 | 1 | 1006 | GRENAILLE-PEINT | E36-3 | PLAT | 1.50225 | 1.51992 | 0.00019137 | 0.000549999 | 29.9751 | 0.0450302 | 0.019362 | 70 | 276.6
PLAT | STEEL/E36-3 | 5741.5 | 29993.5 | 67511.6 | +5.603 | +5.880 | 221 | N7 | 1 | 1006 | GRENAILLE-PEINT | E36-3 | PLAT | 1.50225 | 1.51992 | 0.00019137 | 0.000549999 | 29.9751 | 0.0450302 | 0.019362 | 70 | 276.6
PLAT | STEEL/E36-3 | 5741.5 | 29993.5 | 67588.4 | +5.603 | +5.880 | 221 | N7 | 1 | 1006 | GRENAILLE-PEINT | E36-3 | PLAT | 1.50225 | 1.51992 | 0.00019137 | 0.000549999 | 29.9751 | 0.0450302 | 0.019362 | 70 | 276.6
PLAT | STEEL/E36-3 | 4088.5 | 27106.5 | 67588.4 | +3.950 | +4.227 | 221 | N11 | 1 | 1006 | GRENAILLE-PEINT | E36-3 | PLAT | 1.50225 | 1.51992 | 0.00019137 | 0.000549999 | 29.9751 | 0.0450302 | 0.019362 | 70 | 276.6
PLAT | STEEL/E36-3 | 4088.5 | 27106.5 | 67511.6 | +3.950 | +4.227 | 221 | N11 | 1 | 1006 | GRENAILLE-PEINT | E36-3 | PLAT | 1.50225 | 1.51992 | 0.00019137 | 0.000549999 | 29.9751 | 0.0450302 | 0.019362 | 70 | 276.6
PLAT | STEEL/E36-3 | 4088.5 | 27393.5 | 67588.4 | +3.950 | +4.227 | 221 | N11 | 1 | 1006 | GRENAILLE-PEINT | E36-3 | PLAT | 1.50225 | 1.51992 | 0.00019137 | 0.000549999 | 29.9751 | 0.0450302 | 0.019362 | 70 | 276.6
PLAT | STEEL/E36-3 | 4088.5 | 27393.5 | 67511.6 | +3.950 | +4.227 | 221 | N11 | 1 | 1006 | GRENAILLE-PEINT | E36-3 | PLAT | 1.50225 | 1.51992 | 0.00019137 | 0.000549999 | 29.9751 | 0.0450302 | 0.019362 | 70 | 276.6
PLAT | STEEL/E36-3 | 5741.5 | 27106.5 | 67511.6 | +5.603 | +5.880 | 221 | N11 | 1 | 1006 | GRENAILLE-PEINT | E36-3 | PLAT | 1.50225 | 1.51992 | 0.00019137 | 0.000549999 | 29.9751 | 0.0450302 | 0.019362 | 70 | 276.6
PLAT | STEEL/E36-3 | 5741.5 | 27106.5 | 67588.4 | +5.603 | +5.880 | 221 | N11 | 1 | 1006 | GRENAILLE-PEINT | E36-3 | PLAT | 1.50225 | 1.51992 | 0.00019137 | 0.000549999 | 29.9751 | 0.0450302 | 0.019362 | 70 | 276.6
PLAT | STEEL/E36-3 | 5741.5 | 27393.5 | 67511.6 | +5.603 | +5.880 | 221 | N11 | 1 | 1006 | GRENAILLE-PEINT | E36-3 | PLAT | 1.50225 | 1.51992 | 0.00019137 | 0.000549999 | 29.9751 | 0.0450302 | 0.019362 | 70 | 276.6
PLAT | STEEL/E36-3 | 5741.5 | 27393.5 | 67588.4 | +5.603 | +5.880 | 221 | N11 | 1 | 1006 | GRENAILLE-PEINT | E36-3 | PLAT | 1.50225 | 1.51992 | 0.00019137 | 0.000549999 | 29.9751 | 0.0450302 | 0.019362 | 70 | 276.6
PLAT | STEEL/E36-3 | 4088.5 | 14586.5 | 67588.4 | +3.950 | +4.227 | 221 | N12 | 1 | 1006 | GRENAILLE-PEINT | E36-3 | PLAT | 1.50225 | 1.51992 | 0.00019137 | 0.000549999 | 29.9751 | 0.0450302 | 0.019362 | 70 | 276.6
PLAT | STEEL/E36-3 | 4088.5 | 14586.5 | 67511.6 | +3.950 | +4.227 | 221 | N12 | 1 | 1006 | GRENAILLE-PEINT | E36-3 | PLAT | 1.50225 | 1.51992 | 0.00019137 | 0.000549999 | 29.9751 | 0.0450302 | 0.019362 | 70 | 276.6
PLAT | STEEL/E36-3 | 4088.5 | 14873.5 | 67588.4 | +3.950 | +4.227 | 221 | N12 | 1 | 1006 | GRENAILLE-PEINT | E36-3 | PLAT | 1.50225 | 1.51992 | 0.00019137 | 0.000549999 | 29.9751 | 0.0450302 | 0.019362 | 70 | 276.6
PLAT | STEEL/E36-3 | 4088.5 | 14873.5 | 67511.6 | +3.950 | +4.227 | 221 | N12 | 1 | 1006 | GRENAILLE-PEINT | E36-3 | PLAT | 1.50225 | 1.51992 | 0.00019137 | 0.000549999 | 29.9751 | 0.0450302 | 0.019362 | 70 | 276.6
PLAT | STEEL/E36-3 | 5741.5 | 14586.5 | 67511.6 | +5.603 | +5.880 | 221 | N12 | 1 | 1006 | GRENAILLE-PEINT | E36-3 | PLAT | 1.50225 | 1.51992 | 0.00019137 | 0.000549999 | 29.9751 | 0.0450302 | 0.019362 | 70 | 276.6
