Properties of the parts of a building model (IFC2X3), part 22 of 32

# IfcElementAssembly (4665)
Name | Assembly/Cast unit weight (kg) | Assembly/Cast unit bottom elevation | Assembly/Cast unit top elevation | Assembly/Cast unit name | Assembly/Cast unit position code | Assembly/Cast unit Mark
PL2*340 | 1.44126 | +5.110 | +5.123 | PL2*340 | 7'-/7'-D1 | Y6
5 x TUBE-C-100*100*3 | 7.80298 | +10.303 | +10.865 | TUBE-C-100*100*3 | >/B'> | P65
HEA100 | 0 | +10.207 | +10.306 | HEA100 | >/B'> | N60
PL2*340 | 1.44126 | +5.187 | +5.199 | PL2*340 | 7-8/E-D | Y6
PL2*340 | 1.44126 | +5.263 | +5.276 | PL2*340 | 7-8/E-D | Y6
PL2*340 | 1.44126 | +5.340 | +5.353 | PL2*340 | <7'/7'-D1 | Y6
4 x PL2*340 | 1.44126 | +5.417 | +5.429 | PL2*340 | 7-8/E-D | Y6
PL2*340 | 1.44126 | +5.340 | +5.353 | PL2*340 | 7-8/E-D | Y6
PL2*340 | 1.44126 | +5.110 | +5.123 | PL2*340 | 7-8/E | Y6
PL2*340 | 1.44126 | +5.110 | +5.123 | PL2*340 | 7-8/E-D | Y6
2 x FPL6*50 | 0.393167 | +10.144 | +10.196 | FPL6*50 | >/B'> | H47
5 x PL2*340 | 1.44126 | +10.300 | +10.312 | PL2*340 | >/B'> | Y6
L60*6 | 0 | +5.850 | +5.910 | L60*6 | <7'/7'-D1 | H24
3 x L40*4 | 0 | +5.910 | +5.950 | L40*4 | 7-8/E-D | H55
2 x UPF-100*50*4 | 0 | +5.850 | +5.950 | UPF-100*50*4 | 7-8/E-D | S15
TUBE-C-100*100*3 | 7.80298 | +5.344 | +5.850 | TUBE-C-100*100*3 | <7'/7'-D1 | P71
5 x UPF-100*50*4 | 0 | +10.865 | +10.965 | UPF-100*50*4 | ->/B'> | S46
UPF-100*50*4 | 0 | +5.750 | +5.850 | UPF-100*50*4 | <7'/<-D1 | S23
5 x PL2*340 | 1.44126 | +10.387 | +10.400 | PL2*340 | >/B'> | Y6
UPF-100*50*4 | 0 | +5.750 | +5.850 | UPF-100*50*4 | 7'-/<-D1 | S12
5 x L40*4 | 0 | +5.910 | +5.950 | L40*4 | 7-8/F-E | H55
TUBE-C-100*100*3 | 6.71458 | +5.192 | +5.750 | TUBE-C-100*100*3 | 7-8/F-E | P89
TUBE-C-100*100*3 | 6.71458 | +5.269 | +5.750 | TUBE-C-100*100*3 | 7-8/F-E | P88
3 x L60*6 | 0 | +5.750 | +5.810 | L60*6 | 7'-/7'-D1 | H24
12 x L60*6 | 0 | +5.754 | +5.946 | L60*6 | 7-8/F-E | H25
3 x UPF-100*50*4 | 0 | +5.850 | +5.950 | UPF-100*50*4 | 7-8/F-E | S15
2 x UPF-100*50*4 | 0 | +5.750 | +5.850 | UPF-100*50*4 | 7'-/<-D1 | S13
L60*6 | 0 | +5.850 | +5.910 | L60*6 | 7'-/7'-D1 | H32
TUBE-C-100*100*3 | 5.52766 | +5.422 | +5.810 | TUBE-C-100*100*3 | 7-8/F-E | P102
TUBE-C-100*100*3 | 7.18432 | +5.191 | +5.750 | TUBE-C-100*100*3 | 7'-/7'-D1 | P81
3 x L60*6 | 0 | +5.754 | +5.946 | L60*6 | 7-8/F-E | H21
TUBE-C-100*100*3 | 6.71458 | +5.346 | +5.750 | TUBE-C-100*100*3 | 7-8/F-E | P87
UPF-100*50*4 | 0 | +5.850 | +5.950 | UPF-100*50*4 | <7'-/7'-D1 | S21
5 x PL2*340 | 1.44126 | +10.475 | +10.487 | PL2*340 | >/B'> | Y6
5 x UPF-100*50*4 | 0 | +10.865 | +10.965 | UPF-100*50*4 | >/B'> | S79
L60*6 | 0 | +5.754 | +5.946 | L60*6 | 7-8/F | H21
4 x L60*6 | 0 | +5.754 | +5.946 | L60*6 | 7-8/F | H25
3 x L60*6 | 0 | +5.854 | +5.946 | L60*6 | 7-8/F-E | H26
L40*4 | 0 | +5.910 | +5.950 | L40*4 | 7'-/D1 | H55
5 x PL2*340 | 1.44126 | +10.212 | +10.224 | PL2*340 | >/B'> | Y6
UPF-100*50*4 | 0 | +5.850 | +5.950 | UPF-100*50*4 | 7'-/7'-D1 | S31
L40*4 | 0 | +5.910 | +5.950 | L40*4 | 7'-/7'-D1 | H55
2 x PL2*340 | 1.44126 | +5.417 | +5.429 | PL2*340 | 7-8/F-E | Y6
2 x PL2*340 | 1.44126 | +5.110 | +5.123 | PL2*340 | 7-8/F-E | Y6
2 x PL2*340 | 1.44126 | +5.187 | +5.199 | PL2*340 | 7-8/F-E | Y6
2 x PL2*340 | 1.44126 | +5.340 | +5.353 | PL2*340 | 7-8/F-E | Y6
PL2*340 | 1.44126 | +5.263 | +5.276 | PL2*340 | 7-8/E | Y6
PL2*340 | 1.44126 | +5.187 | +5.199 | PL2*340 | 7-8/E | Y6
2 x PL2*340 | 1.44126 | +5.263 | +5.276 | PL2*340 | 7-8/F-E | Y6
PL2*340 | 1.44126 | +5.340 | +5.353 | PL2*340 | 7-8/E | Y6
PL2*340 | 1.44126 | +5.417 | +5.429 | PL2*340 | 7-8/E | Y6
5 x TUBE-C-100*100*3 | 5.9974 | +10.567 | +10.925 | TUBE-C-100*100*3 | -/B'> | P95
5 x PL2*340 | 1.44126 | +10.563 | +10.575 | PL2*340 | -/B'> | Y6
16 x UPF-100*50*4 | 0 | +10.765 | +10.865 | UPF-100*50*4 | >/B'> | S80
3 x UPF-100*50*4 | 0 | +10.765 | +10.865 | UPF-100*50*4 | >/B'> | S47
HEA100 | 0 | +10.383 | +10.482 | HEA100 | >/B'> | N58
UPF-100*50*4 | 0 | +10.865 | +10.965 | UPF-100*50*4 | ->/B'> | S83
2 x FPL6*50 | 0.393167 | +10.405 | +10.457 | FPL6*50 | >/B'> | H47
2 x PL2*340 | 1.25977 | +10.301 | +10.310 | PL2*340 | >/B'> | Y7
2 x FPL6*50 | 0.393167 | +10.407 | +10.459 | FPL6*50 | >/B'> | H47
2 x PL2*340 | 1.25977 | +10.389 | +10.398 | PL2*340 | >/B'> | Y7
UPF-100*50*4 | 0 | +10.765 | +10.865 | UPF-100*50*4 | >/B'> | S59
UPF-100*50*4 | 0 | +4.365 | +4.465 | UPF-100*50*4 | 1-3/C | S75
10 x L60*6 | 0 | +10.769 | +10.961 | L60*6 | /B'> | H25
TUBE-C-100*100*3 | 6.71458 | +10.217 | +10.765 | TUBE-C-100*100*3 | >/B'> | P86
HEA100 | 0 | +10.383 | +10.482 | HEA100 | >/B'> | N59
2 x FPL6*50 | 0.393167 | +10.318 | +10.370 | FPL6*50 | >/B'> | H47
2 x PL2*340 | 1.25977 | +10.477 | +10.486 | PL2*340 | >/B'> | Y7
HEA100 | 0 | +10.295 | +10.394 | HEA100 | >/B'> | N56
2 x PL2*340 | 1.25977 | +10.564 | +10.574 | PL2*340 | -/B'> | Y7
HEA100 | 0 | +10.470 | +10.570 | HEA100 | -/B'> | N56
2 x FPL6*50 | 0.393167 | +10.495 | +10.547 | FPL6*50 | -/B'> | H47
TUBE-C-100*100*3 | 6.71458 | +10.393 | +10.765 | TUBE-C-100*100*3 | >/B'> | P84
TUBE-C-100*100*3 | 6.71458 | +10.305 | +10.765 | TUBE-C-100*100*3 | >/B'> | P85
TUBE-C-100*100*3 | 5.52766 | +10.480 | +10.825 | TUBE-C-100*100*3 | >/B'> | P100
TUBE-C-100*100*3 | 5.52766 | +10.568 | +10.925 | TUBE-C-100*100*3 | -/B'> | P101
L60*6 | 0 | +4.269 | +4.461 | L60*6 | 1-2/C-B | H22
UPF-100*50*4 | 0 | +4.365 | +4.465 | UPF-100*50*4 | 1-2/C-B | S41
2 x FPL6*50 | 0.393167 | +3.312 | +3.364 | FPL6*50 | 2-3/E-D | H47
TUBE-C-100*100*3 | 6.71458 | +3.387 | +4.265 | TUBE-C-100*100*3 | 2-3/C-B | P83
HEA100 | 0 | +3.290 | +3.389 | HEA100 | 2-3/C-B | N61
8 x UPF-100*50*4 | 0 | +4.365 | +4.465 | UPF-100*50*4 | 1-2/D-C | S54
8 x UPF-100*50*4 | 0 | +4.365 | +4.465 | UPF-100*50*4 | 1-3/D-C | S81
11 x L60*6 | 0 | +4.269 | +4.461 | L60*6 | 1-2/D-C | H21
8 x L60*6 | 0 | +4.369 | +4.461 | L60*6 | 1-2/D-C | H26
6 x UPF-100*50*4 | 0 | +4.365 | +4.465 | UPF-100*50*4 | 1-2/E-D | S54
5 x UPF-100*50*4 | 0 | +4.365 | +4.465 | UPF-100*50*4 | 1-3/E-D | S81
7 x L60*6 | 0 | +4.269 | +4.461 | L60*6 | 1-2/E-D | H21
6 x L60*6 | 0 | +4.369 | +4.461 | L60*6 | 1-2/E-D | H26
PL2*340 | 1.44126 | +4.014 | +4.027 | PL2*340 | 1-2/C-B | Y6
3 x PL2*340 | 1.44126 | +3.742 | +3.756 | PL2*340 | 1-2/C-B | Y6
TUBE-C-100*100*3 | 7.18432 | +3.746 | +4.265 | TUBE-C-100*100*3 | 1-2/C-B | P79
2 x PL2*340 | 1.44126 | +4.020 | +4.034 | PL2*340 | 1-2/C-B | Y6
2 x TUBE-C-100*100*3 | 5.9974 | +4.024 | +4.425 | TUBE-C-100*100*3 | 1/C-B | P96
UPF-100*50*4 | 0 | +4.365 | +4.465 | UPF-100*50*4 | 1-2/C-B | S53
TUBE-C-100*100*3 | 7.18432 | +3.839 | +4.265 | TUBE-C-100*100*3 | 1-2/C-B | P78
3 x PL2*340 | 1.44126 | +3.835 | +3.849 | PL2*340 | 1-2/C-B | Y6
2 x TUBE-C-100*100*3 | 7.80298 | +3.746 | +4.365 | TUBE-C-100*100*3 | 1-2/C-B | P67
3 x UPF-100*50*4 | 0 | +4.265 | +4.365 | UPF-100*50*4 | 1-2/C-B | S58
UPF-100*50*4 | 0 | +4.265 | +4.365 | UPF-100*50*4 | 1-2/C-B | S57
UPF-100*50*4 | 0 | +4.365 | +4.465 | UPF-100*50*4 | 1-2/C-B | S52
2 x UPF-100*50*4 | 0 | +4.365 | +4.465 | UPF-100*50*4 | 1-3/C-B | S75
4 x L60*6 | 0 | +4.365 | +4.425 | L60*6 | 1-2/C-B | H24
2 x L60*6 | 0 | +4.365 | +4.425 | L60*6 | 1-2/C-B | H20
2 x TUBE-C-100*100*3 | 7.80298 | +3.839 | +4.365 | TUBE-C-100*100*3 | 1-2/C-B | P66
UPF-100*50*4 | 0 | +4.265 | +4.365 | UPF-100*50*4 | 1-2/C-B | S56
UPN100 | 11.9116 | +2.930 | +4.340 | UPN100 | 1-3/E-D | L52
UPN100 | 1.14453 | +4.284 | +4.340 | UPN100 | 1/E-D | L51
UPN100 | 1.14453 | +2.930 | +2.986 | UPN100 | 1/E-D | L51
UPN100 | 1.35648 | +2.930 | +2.986 | UPN100 | 1/E-C | L50
4 x HEA100 | 5.64007 | +2.986 | +4.284 | HEA100 | 1/D-C | L118
4 x HEA100 | 5.64007 | +2.986 | +4.284 | HEA100 | 1/E-D | L118
HEA100 | 5.64007 | +2.986 | +4.284 | HEA100 | 1/D | L118
UPN100 | 1.61082 | +2.930 | +2.986 | UPN100 | 1/D-C | L49
UPN100 | 1.35648 | +4.284 | +4.340 | UPN100 | 1/E-C | L50
UPN100 | 1.61082 | +4.284 | +4.340 | UPN100 | 1/D-C | L49
L50*5 | 0 | +3.160 | +3.380 | L50*5 | 2-3/C-B | C81
L50*5 | 0 | +3.217 | +3.438 | L50*5 | 2-3/C-B | C81
2 x L50*5 | 0 | +3.158 | +3.292 | L50*5 | 2-3/C-B | C74
2 x L50*5 | 0 | +3.215 | +3.350 | L50*5 | 2-3/C-B | C74
L50*5 | 0 | +3.244 | +3.381 | L50*5 | 2-3/C-B | C75
L50*5 | 0 | +3.301 | +3.439 | L50*5 | 2-3/C-B | C75
2 x L50*5 | 0 | +3.424 | +3.559 | L50*5 | 2-3/D-C | C73
2 x L50*5 | 0 | +3.481 | +3.617 | L50*5 | 2-3/D-C | C73
2 x L50*5 | 0 | +3.158 | +3.292 | L50*5 | 2-3/D-C | C76
2 x L50*5 | 0 | +3.215 | +3.350 | L50*5 | 2-3/D-C | C76
2 x L50*5 | 0 | +3.244 | +3.381 | L50*5 | 2-3/D-C | C72
2 x L50*5 | 0 | +3.301 | +3.439 | L50*5 | 2-3/D-C | C72
2 x L50*5 | 0 | +3.335 | +3.471 | L50*5 | 2-3/D-C | C72
2 x L50*5 | 0 | +3.392 | +3.529 | L50*5 | 2-3/D-C | C72
2 x L50*5 | 0 | +3.215 | +3.350 | L50*5 | 2-3/D-C | C52
2 x L50*5 | 0 | +3.302 | +3.439 | L50*5 | 2-3/D-C | C53
2 x L50*5 | 0 | +3.158 | +3.292 | L50*5 | 2-3/D-C | C77
2 x L50*5 | 0 | +3.215 | +3.350 | L50*5 | 2-3/D-C | C77
2 x L50*5 | 0 | +3.244 | +3.381 | L50*5 | 2-3/D-C | C78
2 x L50*5 | 0 | +3.302 | +3.439 | L50*5 | 2-3/D-C | C78
3 x L50*5 | 0 | +3.158 | +3.292 | L50*5 | 2-3/E-D | C79
3 x L50*5 | 0 | +3.215 | +3.350 | L50*5 | 2-3/E-D | C79
3 x L50*5 | 0 | +3.245 | +3.381 | L50*5 | 2-3/E-D | C80
3 x L50*5 | 0 | +3.302 | +3.439 | L50*5 | 2-3/E-D | C80
2 x L70*7 | 0 | +3.389 | +3.462 | L70*7 | 2-3/C-B | C133
4 x L70*7 | 0 | +3.313 | +3.384 | L70*7 | 2-3/D-C | C111
4 x L70*7 | 0 | +3.389 | +3.462 | L70*7 | 2-3/D-C | C111
4 x L70*7 | 0 | +3.313 | +3.384 | L70*7 | 2-3/D-C | C112
4 x L70*7 | 0 | +3.389 | +3.462 | L70*7 | 2-3/D-C | C112
L50*5 | 0 | +3.215 | +3.349 | L50*5 | 2-3/E-D | C79
3 x L70*7 | 0 | +3.389 | +3.462 | L70*7 | 2-3/E-D | C134
L50*5 | 0 | +3.157 | +3.292 | L50*5 | 2-3/E-D | C79
2 x L70*7 | 0 | +5.411 | +5.496 | L70*7 | 4/C | H39
2 x TUBE-C-90*90*3 | 2.93904 | +10.164 | +10.291 | TUBE-C-90*90*3 | >/B'> | B6
4 x TUBE-C-90*90*3 | 5.83547 | +10.164 | +10.291 | TUBE-C-90*90*3 | >/B'> | B9
L60*6 | 0 | +10.263 | +10.417 | L60*6 | ->/B'> | C2
2 x PL8 | 3.5599 | +10.214 | +10.233 | PL8 | >/B'> | G30
PL8 | 1.45892 | +10.415 | +10.428 | PL8 | -/B'> | G29
4 x L60*6 | 0 | +10.264 | +10.420 | L60*6 | ->/B'> | C3
TUBE-C-60*60*3 | 1.60768 | +10.281 | +10.363 | TUBE-C-60*60*3 | >/B'> | B11
IPE220 | 0 | +7.145 | +7.365 | IPE220 | 2-4/B-A | S97
IPE220 | 0 | +7.145 | +7.365 | IPE220 | 3-4/B-A | S98
2 x IPE220 | 0 | +7.145 | +7.365 | IPE220 | 3-4/B-A | S95
UPN160 | 2.4179 | +10.248 | +10.584 | UPN160 | ->/B'> | K105
UPN160 | 3.62685 | +10.025 | +10.407 | UPN160 | >/B'> | K104
UPN160 | 6.04475 | +10.025 | +10.584 | UPN160 | ->/B'> | K103
IPE330 | 26.6396 | +9.855 | +10.704 | IPE330 | ->/B'> | K36
IPE330 | 26.6396 | +9.855 | +10.704 | IPE330 | ->/B'> | K35
2 x IPE330 | 20.8003 | +9.855 | +10.704 | IPE330 | ->/B'> | K33
IPE330 | 26.6396 | +9.855 | +10.704 | IPE330 | ->/B'> | K34
IPEA300 | 0 | +4.104 | +5.809 | IPEA300 | 3-4/C-B | K17
PL800*400 | 13204.4 | +5.160 | +5.960 | PL800*400 | 4/C-A | Z79 | PredefinedType: REINFORCEMENT_UNIT; Tekla Assembly - Cast unit vertical position code: +0-+3940; Cast unit rebar weight: 0 kg
PL860*200 | 576.114 | +6.140 | +7.000 | PL860*200 | 3/C-B | Z23 | PredefinedType: REINFORCEMENT_UNIT; Tekla Assembly - Cast unit vertical position code: +3940>; Cast unit rebar weight: 0 kg
PL860*200 | 576.114 | +6.140 | +7.000 | PL860*200 | 3-4/C-B | Z23 | PredefinedType: REINFORCEMENT_UNIT; Tekla Assembly - Cast unit vertical position code: +3940>; Cast unit rebar weight: 0 kg
PL1620*200 | 1928.93 | +6.140 | +7.760 | PL1620*200 | 4/B-A | Z24 | PredefinedType: REINFORCEMENT_UNIT; Tekla Assembly - Cast unit vertical position code: +3940>; Cast unit rebar weight: 0 kg
PL200 | 4893.65 | +5.940 | +6.140 | PL200 | 3-4/C-B | Z25 | PredefinedType: REINFORCEMENT_UNIT; Tekla Assembly - Cast unit vertical position code: +3940; Cast unit rebar weight: 0 kg
PL2600*200 | 1381.38 | +6.140 | +8.740 | PL2600*200 | 3-4/B-A | Z26 | PredefinedType: REINFORCEMENT_UNIT; Tekla Assembly - Cast unit vertical position code: +3940>; Cast unit rebar weight: 0 kg
PL2600*200 | 1310.4 | +6.140 | +8.740 | PL2600*200 | 3-4/B-A | Z27 | PredefinedType: REINFORCEMENT_UNIT; Tekla Assembly - Cast unit vertical position code: +3940>; Cast unit rebar weight: 0 kg
PL2600*200 | 1796.34 | +6.140 | +8.740 | PL2600*200 | 3-4/B-A | Z28 | PredefinedType: REINFORCEMENT_UNIT; Tekla Assembly - Cast unit vertical position code: +3940>; Cast unit rebar weight: 0 kg
PL2600*200 | 2140.32 | +6.140 | +8.740 | PL2600*200 | 3-4/B-A | Z29 | PredefinedType: REINFORCEMENT_UNIT; Tekla Assembly - Cast unit vertical position code: +3940>; Cast unit rebar weight: 0 kg
2 x PL2600*200 | 3718.26 | +6.140 | +8.740 | PL2600*200 | 3-4/B-A | Z22 | PredefinedType: REINFORCEMENT_UNIT; Tekla Assembly - Cast unit vertical position code: +3940>; Cast unit rebar weight: 0 kg
PL2600*150 | 4884.24 | +6.140 | +8.740 | PL2600*150 | 3-4/B | Z72 | PredefinedType: REINFORCEMENT_UNIT; Tekla Assembly - Cast unit vertical position code: +3940>; Cast unit rebar weight: 0 kg
PL2600*150 | 1721.57 | +6.140 | +8.740 | PL2600*150 | 3-4/B-A | Z73 | PredefinedType: REINFORCEMENT_UNIT; Tekla Assembly - Cast unit vertical position code: +3940>; Cast unit rebar weight: 0 kg
PL2600*150 | 3054.87 | +6.140 | +8.740 | PL2600*150 | 3-4/B-A | Z74 | PredefinedType: REINFORCEMENT_UNIT; Tekla Assembly - Cast unit vertical position code: +3940>; Cast unit rebar weight: 0 kg
PL2600*150 | 397.215 | +6.140 | +8.740 | PL2600*150 | 3-4/B-A | Z75 | PredefinedType: REINFORCEMENT_UNIT; Tekla Assembly - Cast unit vertical position code: +3940>; Cast unit rebar weight: 0 kg
PL2600*150 | 1122.03 | +6.140 | +8.740 | PL2600*150 | 3-4/B-A | Z76 | PredefinedType: REINFORCEMENT_UNIT; Tekla Assembly - Cast unit vertical position code: +3940>; Cast unit rebar weight: 0 kg
PL180 | 38088 | +5.960 | +6.140 | PL180 | 3-4/C-A | Z4 | PredefinedType: REINFORCEMENT_UNIT; Tekla Assembly - Cast unit vertical position code: +3940; Cast unit rebar weight: 0 kg
PL1620*200 | 7768.28 | +6.140 | +7.760 | PL1620*200 | 2-4/A | Z44 | PredefinedType: REINFORCEMENT_UNIT; Tekla Assembly - Cast unit vertical position code: +3940>; Cast unit rebar weight: 0 kg
PL2270*200 | 2702.89 | +6.140 | +8.410 | PL2270*200 | 2-3/B-A | Z30 | PredefinedType: REINFORCEMENT_UNIT; Tekla Assembly - Cast unit vertical position code: +3940>; Cast unit rebar weight: 0 kg
PL2780*200 | 2784.73 | +3.140 | +5.920 | PL2780*200 | 3-4/B-A | Z31 | PredefinedType: REINFORCEMENT_UNIT; Tekla Assembly - Cast unit vertical position code: A-+3940; Cast unit rebar weight: 0 kg
PL2780*200 | 2055.09 | +3.140 | +5.920 | PL2780*200 | 3-4/B-A | Z32 | PredefinedType: REINFORCEMENT_UNIT; Tekla Assembly - Cast unit vertical position code: A-+3940; Cast unit rebar weight: 0 kg
PL2780*200 | 4933.11 | +3.140 | +5.920 | PL2780*200 | 3-4/B-A | Z33 | PredefinedType: REINFORCEMENT_UNIT; Tekla Assembly - Cast unit vertical position code: A-+3940; Cast unit rebar weight: 0 kg
PL6140*200 | 2063.04 | +0.000 | +6.140 | PL6140*200 | 3-4/B-A | Z35 | PredefinedType: REINFORCEMENT_UNIT; Tekla Assembly - Cast unit vertical position code: A-+3940; Cast unit rebar weight: 0 kg
2 x PL6140*200 | 2063.04 | +0.000 | +6.140 | PL6140*200 | 3-4/C-B | Z35 | PredefinedType: REINFORCEMENT_UNIT; Tekla Assembly - Cast unit vertical position code: A-+3940; Cast unit rebar weight: 0 kg
PL6140 | 3842.41 | -0.000 | +6.140 | PL6140 | 3/C-B | Z66 | PredefinedType: REINFORCEMENT_UNIT; Tekla Assembly - Cast unit vertical position code: A-+3940; Cast unit rebar weight: 0 kg
PL6140*200 | 4492.53 | +0.000 | +6.140 | PL6140*200 | 3-4/A | Z36 | PredefinedType: REINFORCEMENT_UNIT; Tekla Assembly - Cast unit vertical position code: A-+3940; Cast unit rebar weight: 0 kg
HEA220 | 10.183 | -0.400 | +3.500 | HEA220 | 7'/C1 | P118
2 x L50*5 | 0 | -0.354 | +2.078 | L50*5 | /<-D1 | V2
PL50*8 | 0.157 | +0.989 | +1.060 | PL50*8 | /7' | Y3
2 x PL50*8 | 0.157 | +1.314 | +1.385 | PL50*8 | 8/E-D | Y3
2 x PL50*8 | 0.157 | +1.640 | +1.710 | PL50*8 | 8/E-D | Y3
PL50*8 | 0.157 | +0.339 | +0.409 | PL50*8 | /7'-D1 | Y3
PL50*8 | 0.157 | +0.013 | +0.084 | PL50*8 | /7'-D1 | Y3
PL50*8 | 0.157 | +3.539 | +3.609 | PL50*8 | /7'-D1 | Y3
PL50*8 | 0.157 | +3.864 | +3.935 | PL50*8 | /7'-D1 | Y3
PL50*8 | 0.157 | +4.189 | +4.260 | PL50*8 | /7'-D1 | Y3
PL50*8 | 0.157 | +3.214 | +3.284 | PL50*8 | /7' | Y3
PL50*8 | 0.157 | +2.888 | +2.959 | PL50*8 | /-7' | Y3
2 x PL50*8 | 0.157 | +2.563 | +2.634 | PL50*8 | 8/E-D | Y3
PL50*8 | 0.157 | +2.888 | +2.959 | PL50*8 | 8/E-D | Y3
PL50*8 | 0.157 | +3.214 | +3.284 | PL50*8 | 8/E-D | Y3
PL50*8 | 0.157 | +4.189 | +4.260 | PL50*8 | 8/E-D | Y3
PL50*8 | 0.157 | +3.864 | +3.935 | PL50*8 | 8/E-D | Y3
PL50*8 | 0.157 | +3.539 | +3.609 | PL50*8 | 8/E-D | Y3
PL50*8 | 0.157 | +0.664 | +0.734 | PL50*8 | /7'-D1 | Y3
PL50*8 | 0.157 | +0.339 | +0.409 | PL50*8 | 8/E-D | Y3
PL50*8 | 0.157 | +0.013 | +0.084 | PL50*8 | 8/E-D | Y3
PL50*8 | 0.157 | +5.048 | +5.065 | PL50*8 | <7'/C1> | Y3
PL50*8 | 0.157 | +5.081 | +5.097 | PL50*8 | <7'/C1 | Y3
PL60*8 | 0.22608 | +3.616 | +3.626 | PL60*8 | 7'-/D1-C1 | Y2
PL60*8 | 0.22608 | +3.597 | +3.607 | PL60*8 | 7'-/D1-C1 | Y2
PL60*8 | 0.22608 | +3.540 | +3.550 | PL60*8 | 7'-/D1-C1 | Y2
PL60*8 | 0.22608 | +3.559 | +3.569 | PL60*8 | 7'-/D1-C1 | Y2
PL60*8 | 0.22608 | +3.578 | +3.588 | PL60*8 | 7'-/D1-C1 | Y2
PL8 | 2.63972 | +3.526 | +3.540 | PL8 | /D1-C1 | G62
L90*9 | 0 | +3.685 | +3.955 | L90*9 | 7'/D1 | H75
L90*9 | 0 | +3.685 | +3.955 | L90*9 | 7'/D1 | H74
PL60*8 | 0.22608 | +4.866 | +4.876 | PL60*8 | 7-8/F-E | Y2
PL60*8 | 0.22608 | +4.847 | +4.857 | PL60*8 | 7-8/F-E | Y2
PL60*8 | 0.22608 | +4.791 | +4.801 | PL60*8 | 7-8/F-E | Y2
PL60*8 | 0.22608 | +4.809 | +4.820 | PL60*8 | 7-8/F-E | Y2
PL60*8 | 0.22608 | +4.828 | +4.838 | PL60*8 | 7-8/F-E | Y2
2 x PL50*8 | 0.157 | +4.794 | +4.804 | PL50*8 | 7-8/F-E | Y3
2 x PL50*8 | 0.157 | +4.806 | +4.817 | PL50*8 | 7-8/F-E | Y3
2 x PL50*8 | 0.157 | +4.819 | +4.829 | PL50*8 | 7-8/F-E | Y3
2 x PL50*8 | 0.157 | +4.831 | +4.841 | PL50*8 | 7-8/F-E | Y3
2 x PL50*8 | 0.157 | +4.843 | +4.853 | PL50*8 | 7-8/F-E | Y3
2 x PL50*8 | 0.157 | +4.855 | +4.865 | PL50*8 | 7-8/F-E | Y3
2 x PL50*8 | 0.157 | +4.867 | +4.877 | PL50*8 | 7-8/F-E | Y3
PL8 | 2.359 | +4.776 | +4.791 | PL8 | 8/F-E | G61
UPN180 | 0.96084 | +2.400 | +2.476 | UPN180 | 8/B-A | L28
PL140*10 | 4.47264 | +4.871 | +5.041 | PL140*10 | 7-8/A | H6
UPN180 | 1.04091 | +2.400 | +2.476 | UPN180 | 8/C-B | L27
UPN180 | 0 | +3.512 | +3.582 | UPN180 | 7-8/A | L31
UPN180 | 3.56311 | +0.000 | +3.512 | UPN180 | 7-8/A | P42
UPN180 | 3.56311 | +0.000 | +3.512 | UPN180 | 7-8/A | P43
TUBE-C-90*90*3 | 0.348352 | +5.890 | +5.980 | TUBE-C-90*90*3 | 7-8/A | L96
UPN180 | 1.12098 | +2.400 | +2.470 | UPN180 | 7-8/A | L25
TUBE-C-90*90*3 | 1.30429 | +4.767 | +5.890 | TUBE-C-90*90*3 | 7-8/A | L23
UPN180 | 1.04091 | +2.400 | +2.476 | UPN180 | 8/B-A | L26
L80*8 | 0 | +5.720 | +5.800 | L80*8 | 8/A | H70
UPN180 | 3.00263 | +0.000 | +4.010 | UPN180 | 8/B-A | P41
UPN180 | 0.785 | -0.200 | +4.979 | UPN180 | 8/D-C | P49
UPN180 | 3.56311 | +0.000 | +2.400 | UPN180 | 8/B-A | P50
UPN180 | 3.00263 | +0.000 | +4.010 | UPN180 | 8/C-B | P40
UPN180 | 0.785 | -0.200 | +4.979 | UPN180 | 8/D-C | P48
UPN180 | 1.62809 | +0.000 | +2.400 | UPN180 | 8/B-A | P51
UPN140 | 0.989307 | +5.078 | +5.570 | UPN140 | <7'/C1> | K100
HEA120 | 5.06335 | +4.000 | +5.529 | HEA120 | 7'/C1> | M13
HEA120 | 5.11234 | +4.000 | +5.894 | HEA120 | 7'/C1 | M14
2 x TUBE-C-100*100*3 | 9.1374 | +3.938 | +4.475 | TUBE-C-100*100*3 | 7'-/D1-C1 | P54
2 x TUBE-C-100*100*3 | 9.1374 | +3.876 | +4.475 | TUBE-C-100*100*3 | 7'-/D1-C1 | P55
12 x PL5*200 | 1.57 | +4.475 | +4.480 | PL5*200 | 7'-/D1-C1 | Y5
TUBE-C-100*100*3 | 9.3101 | +3.936 | +4.475 | TUBE-C-100*100*3 | 7'-/D1-C1 | P59
2 x PL2*240 | 1.28112 | +3.934 | +3.943 | PL2*240 | 7'-/D1-C1 | Y8
2 x PL2*250 | 1.3345 | +3.932 | +3.945 | PL2*250 | 7'-/D1-C1 | Y9
TUBE-C-100*100*3 | 9.3101 | +3.936 | +4.475 | TUBE-C-100*100*3 | 7'-/D1-C1 | P58
2 x PL2*250 | 1.3345 | +3.870 | +3.883 | PL2*250 | 7'-/D1-C1 | Y9
2 x PL2*240 | 1.28112 | +3.872 | +3.881 | PL2*240 | 7'-/D1-C1 | Y8
TUBE-C-100*100*3 | 9.3101 | +3.874 | +4.475 | TUBE-C-100*100*3 | 7'-/D1-C1 | P60
2 x PL2*240 | 1.28112 | +3.806 | +3.816 | PL2*240 | 7'-/D1-C1 | Y8
2 x PL2*240 | 1.28112 | +3.835 | +3.845 | PL2*240 | 7'-/D1-C1 | Y8
TUBE-C-100*100*3 | 9.3101 | +3.874 | +4.475 | TUBE-C-100*100*3 | 7'-/D1-C1 | P61
2 x TUBE-C-100*100*3 | 9.1374 | +3.839 | +4.475 | TUBE-C-100*100*3 | 7'-/D1-C1 | P56
2 x TUBE-C-100*100*3 | 9.1374 | +3.810 | +4.475 | TUBE-C-100*100*3 | 7'-/D1-C1 | P57
5 x L60*6 | 0 | +5.720 | +5.946 | L60*6 | 7'/D1-C1 | H29
2 x UPF-100*50*4 | 0 | +5.850 | +5.950 | UPF-100*50*4 | 7-8/E-D | S24
TUBE-C-100*100*3 | 6.71458 | +5.115 | +5.750 | TUBE-C-100*100*3 | 7-8/F-E | P90
8 x UPF-100*50*4 | 0 | +5.750 | +5.850 | UPF-100*50*4 | 7-8/E-D | S23
2 x TUBE-C-100*100*3 | 7.8018 | +5.421 | +5.850 | TUBE-C-100*100*3 | 7-8/F-E | P73
8 x L60*6 | 0 | +5.850 | +5.910 | L60*6 | 7-8/F-E | H24
2 x TUBE-C-100*100*3 | 7.80298 | +5.344 | +5.850 | TUBE-C-100*100*3 | 7-8/F-E | P71
2 x L60*6 | 0 | +5.850 | +5.910 | L60*6 | 7-8/F-E | H20
2 x TUBE-C-100*100*3 | 7.80298 | +5.267 | +5.850 | TUBE-C-100*100*3 | 7-8/F-E | P70
2 x TUBE-C-100*100*3 | 7.80298 | +5.191 | +5.850 | TUBE-C-100*100*3 | 7-8/F-E | P69
2 x TUBE-C-100*100*3 | 7.80298 | +5.114 | +5.850 | TUBE-C-100*100*3 | 7-8/F-E | P68
5 x UPF-100*50*4 | 0 | +5.750 | +5.850 | UPF-100*50*4 | 7-8/F-E | S17
10 x UPF-100*50*4 | 0 | +5.750 | +5.850 | UPF-100*50*4 | 7-8/F-E | S22
3 x PL60*8 | 0.22608 | +5.238 | +5.253 | PL60*8 | 7-8/D-C | Y2
PL50*8 | 0.157 | +5.182 | +5.198 | PL50*8 | 7-8/D-C | Y3
PL50*8 | 0.157 | +5.134 | +5.150 | PL50*8 | 7-8/D-C | Y3
PL50*8 | 0.157 | +5.086 | +5.102 | PL50*8 | 7-8/D-C | Y3
PL50*8 | 0.157 | +4.966 | +4.982 | PL50*8 | 7-8/D-C | Y3
PL50*8 | 0.157 | +4.918 | +4.934 | PL50*8 | 7-8/D-C | Y3
2 x PL50*8 | 0.157 | +4.870 | +4.886 | PL50*8 | 7-8/D-C | Y3
PL50*8 | 0.157 | +5.082 | +5.098 | PL50*8 | 7-8/D-C | Y3
PL50*8 | 0.157 | +5.131 | +5.147 | PL50*8 | 7-8/D-C | Y3
PL50*8 | 0.157 | +5.180 | +5.196 | PL50*8 | 7-8/D-C | Y3
PL50*8 | 0.157 | +4.920 | +4.936 | PL50*8 | 7-8/D-C | Y3
PL50*8 | 0.157 | +4.969 | +4.985 | PL50*8 | 7-8/D-C | Y3
PL50*8 | 0.157 | +5.307 | +5.323 | PL50*8 | 7-8/D-C | Y3
PL50*8 | 0.157 | +5.342 | +5.358 | PL50*8 | 7-8/D-C | Y3
PL50*8 | 0.157 | +5.462 | +5.478 | PL50*8 | 7/D-C | Y3
PL50*8 | 0.157 | +5.426 | +5.443 | PL50*8 | 7-8/D-C | Y3
PL50*8 | 0.157 | +5.339 | +5.356 | PL50*8 | 7-8/D-C | Y3
3 x PL50*8 | 0.157 | +5.306 | +5.323 | PL50*8 | 7-8/D-C | Y3
PL50*8 | 0.157 | +5.424 | +5.440 | PL50*8 | 7-8/D-C | Y3
2 x PL50*8 | 0.157 | +5.461 | +5.477 | PL50*8 | 7/D-C | Y3
PL50*8 | 0.157 | +5.340 | +5.357 | PL50*8 | 7-8/D-C | Y3
PL50*8 | 0.157 | +5.425 | +5.442 | PL50*8 | 7-8/D-C | Y3
PL50*8 | 0.157 | +5.334 | +5.351 | PL50*8 | 7-8/D-C | Y3
PL50*8 | 0.157 | +5.299 | +5.315 | PL50*8 | 7-8/D-C | Y3
PL50*8 | 0.157 | +5.422 | +5.439 | PL50*8 | 7-8/D-C | Y3
PL50*8 | 0.157 | +5.460 | +5.476 | PL50*8 | 7/D-C | Y3
2 x PL50*8 | 0.157 | +5.459 | +5.476 | PL50*8 | 7/D-C | Y3
PL50*8 | 0.157 | +5.422 | +5.438 | PL50*8 | 7-8/D-C | Y3
PL50*8 | 0.157 | +5.298 | +5.315 | PL50*8 | 7-8/D-C | Y3
PL50*8 | 0.157 | +5.334 | +5.350 | PL50*8 | 7-8/D-C | Y3
PL50*8 | 0.157 | +5.291 | +5.307 | PL50*8 | 7-8/D-C | Y3
PL50*8 | 0.157 | +5.328 | +5.344 | PL50*8 | 7-8/D-C | Y3
PL50*8 | 0.157 | +5.419 | +5.436 | PL50*8 | 7-8/D-C | Y3
PL50*8 | 0.157 | +5.458 | +5.474 | PL50*8 | 7/D-C | Y3
PL50*8 | 0.157 | +5.291 | +5.308 | PL50*8 | 7-8/D-C | Y3
PL50*8 | 0.157 | +5.329 | +5.345 | PL50*8 | 7-8/D-C | Y3
2 x PL50*8 | 0.157 | +5.457 | +5.474 | PL50*8 | 7/D-C | Y3
PL50*8 | 0.157 | +5.418 | +5.434 | PL50*8 | 7-8/D-C | Y3
2 x PL50*8 | 0.157 | +5.421 | +5.438 | PL50*8 | 7-8/D-C | Y3
PL50*8 | 0.157 | +5.326 | +5.343 | PL50*8 | 7-8/D-C | Y3
PL50*8 | 0.157 | +5.290 | +5.306 | PL50*8 | 7-8/D-C | Y3
PL50*8 | 0.157 | +5.157 | +5.173 | PL50*8 | <7'/D1-C1 | Y3
PL50*8 | 0.157 | +5.190 | +5.206 | PL50*8 | <7'/D1-C1 | Y3
PL50*8 | 0.157 | +5.159 | +5.176 | PL50*8 | <7'/C1 | Y3
PL50*8 | 0.157 | +5.191 | +5.207 | PL50*8 | <7'/C1> | Y3
PL50*8 | 0.157 | +5.078 | +5.095 | PL50*8 | <7'/D1-C1 | Y3
PL50*8 | 0.157 | +5.047 | +5.063 | PL50*8 | <7'/D1-C1 | Y3
3 x PL60*8 | 0.22608 | +5.257 | +5.272 | PL60*8 | 7-8/D-C | Y2
L50*5 | 0 | +5.257 | +5.563 | L50*5 | 7-8/D-C | C68
L50*5 | 0 | +5.200 | +5.509 | L50*5 | 7-8/D-C | C67
L50*5 | 0 | +5.019 | +5.288 | L50*5 | <7'/D1-C1> | C69
L50*5 | 0 | +4.962 | +5.234 | L50*5 | <7'/D1-C1> | C69
L50*5 | 0 | +5.389 | +5.567 | L50*5 | 7-8/D-C | C92
L50*5 | 0 | +4.823 | +5.297 | L50*5 | 7-8/D-C | C83
L50*5 | 0 | +4.766 | +5.242 | L50*5 | 7-8/D-C | C82
L50*5 | 0 | +5.276 | +5.563 | L50*5 | 7-8/D-C | C62
L50*5 | 0 | +5.218 | +5.509 | L50*5 | 7-8/D-C | C61
L50*5 | 0 | +5.276 | +5.563 | L50*5 | 7-8/D-C | C64
L50*5 | 0 | +5.219 | +5.509 | L50*5 | 7-8/D-C | C63
L50*5 | 0 | +5.267 | +5.563 | L50*5 | 7-8/D-C | C66
L50*5 | 0 | +5.209 | +5.509 | L50*5 | 7-8/D-C | C65
PL8 | 5.49955 | +5.223 | +5.269 | PL8 | <7'/C1> | G56
L50*5 | 0 | +5.393 | +5.567 | L50*5 | 7-8/D-C | C87
L50*5 | 0 | +5.395 | +5.567 | L50*5 | 7-8/D-C | C85
L50*5 | 0 | +5.342 | +5.510 | L50*5 | 7-8/D-C | C85
L50*5 | 0 | +5.041 | +5.302 | L50*5 | 7-8/D-C | C94
L50*5 | 0 | +4.986 | +5.244 | L50*5 | 7-8/D-C | C94
UPN300 | 11.8294 | +4.814 | +5.114 | UPN300 | 8/D-C | N37
2 x PL1520 | 97382.3 | +4.480 | +6.000 | PL1520 | 7'-/D1-C1 | Z63
L60*6 | 0 | +5.018 | +5.078 | L60*6 | 8/F | H33
L60*6 | 0 | +5.750 | +5.810 | L60*6 | <7'/D1-C1 | H24
4 x UPF-100*50*4 | 6.83783 | +5.844 | +5.950 | UPF-100*50*4 | <7'/D1-C1 | S38
2 x UPF-100*50*4 | 0 | +5.850 | +5.950 | UPF-100*50*4 | <7'/D1-C1 | S33
UPF-100*50*4 | 0 | +5.850 | +5.950 | UPF-100*50*4 | 7'-/D1 | S16
2 x UPF-100*50*4 | 0 | +5.850 | +5.950 | UPF-100*50*4 | <7'/D1-C1 | S34
2 x L60*6 | 0 | +5.754 | +5.946 | L60*6 | 7'-/D1 | H27
L60*6 | 0 | +5.754 | +5.946 | L60*6 | 7'-/D1 | H22
UPF-100*50*4 | 0 | +5.850 | +5.950 | UPF-100*50*4 | 7-8/F | S24
4 x TUBE-C-100*100*3 | 7.8018 | +5.421 | +5.850 | TUBE-C-100*100*3 | 7-8/E-D | P73
7 x L60*6 | 0 | +5.850 | +5.910 | L60*6 | 7-8/E-D | H24
UPF-100*50*4 | 0 | +5.850 | +5.950 | UPF-100*50*4 | <7'/D1 | S33
4 x L60*6 | 0 | +5.850 | +5.910 | L60*6 | 7-8/E | H24
L60*6 | 0 | +5.850 | +5.910 | L60*6 | 7-8/E-D | H20
3 x UPF-100*50*4 | 0 | +5.850 | +5.950 | UPF-100*50*4 | 7-8/F-E | S24
TUBE-C-100*100*3 | 7.80298 | +5.114 | +5.850 | TUBE-C-100*100*3 | 7-8/E | P68
L40*4 | 0 | +5.910 | +5.950 | L40*4 | 7-8/E | H55
L60*6 | 0 | +5.854 | +5.946 | L60*6 | 7-8/F | H26
L40*4 | 0 | +5.910 | +5.950 | L40*4 | 7-8/F | H55
FPL255*8 | 3.20284 | +4.787 | +4.917 | FPL255*8 | 7-8/F | H54
FPL255*8 | 2.88256 | +4.699 | +4.811 | FPL255*8 | 7-8/F | H53
FPL255*8 | 3.37354 | +4.796 | +4.937 | FPL255*8 | 7-8/F | H51
FPL255*8 | 3.20284 | +4.819 | +4.952 | FPL255*8 | 7-8/F | H52
TUBE-C-100*100*3 | 0 | +4.034 | +4.878 | TUBE-C-100*100*3 | 7-8/A | B16
UPN180 | 1.34549 | -0.200 | +2.400 | UPN180 | 6-7/F | P45
PL20*110 | 3.6267 | +2.161 | +2.371 | PL20*110 | 5-6/A | Y1
PL60*8 | 0.22608 | +3.558 | +3.633 | PL60*8 | 5-6/A | Y2
PL60*8 | 0.22608 | +3.349 | +3.424 | PL60*8 | 5-6/A | Y2
PL60*8 | 0.22608 | +3.140 | +3.216 | PL60*8 | 5-6/A | Y2
PL60*8 | 0.22608 | +2.932 | +3.007 | PL60*8 | 5-6/A | Y2
2 x L70*7 | 0 | -0.362 | +2.244 | L70*7 | 5-6/A | V15
2 x L70*7 | 0 | +2.264 | +4.083 | L70*7 | 5-6/A | V12
PL60*8 | 0.22608 | +2.514 | +2.590 | PL60*8 | 5-6/A | Y2
PL60*8 | 0.22608 | +2.723 | +2.798 | PL60*8 | 5-6/A | Y2
4 x L50*5 | 0 | +4.761 | +5.143 | L50*5 | 7-8/C-B | C58
3 x PL8 | 6.37364 | +4.795 | +4.833 | PL8 | 7-8/C-B | G48
4 x PL8 | 9.12418 | +5.131 | +5.188 | PL8 | 7-8/C-B | G42
2 x L50*5 | 0 | +5.122 | +5.506 | L50*5 | 7-8/C-B | C57
L50*5 | 0 | +5.277 | +5.443 | L50*5 | 7-8/D-C | C84
L50*5 | 0 | +5.224 | +5.385 | L50*5 | 7-8/D-C | C84
L60*6 | 0 | +5.740 | +5.800 | L60*6 | 8/F | H11
TUBE-C-90*90*3 | 0.348352 | +5.890 | +5.980 | TUBE-C-90*90*3 | 5-6/F | L97
TUBE-C-90*90*3 | 0.348352 | +5.890 | +5.980 | TUBE-C-90*90*3 | 6-7/F | L97
TUBE-C-90*90*3 | 1.30429 | +4.757 | +5.890 | TUBE-C-90*90*3 | 5-6/F | L21
TUBE-C-90*90*3 | 1.30429 | +4.757 | +5.890 | TUBE-C-90*90*3 | 6-7/F | L21
TUBE-C-60*60*3 | 1.45395 | +4.417 | +5.588 | TUBE-C-60*60*3 | 6/F | L42
TUBE-C-90*90*3 | 0.348352 | +5.890 | +5.980 | TUBE-C-90*90*3 | 3-4/F | L108
TUBE-C-90*90*3 | 1.30429 | +4.757 | +5.890 | TUBE-C-90*90*3 | 3-4/F | L24
PL8 | 2.57354 | +4.792 | +4.814 | PL8 | 7-8/B-A | G18
3 x L70*7 | 0 | +4.803 | +4.881 | L70*7 | 7-8/B-A | C104
3 x L70*7 | 0 | +4.733 | +4.804 | L70*7 | 7-8/B-A | C104
PL8 | 9.15352 | +5.131 | +5.187 | PL8 | 7-8/B-A | G43
PL8 | 10.1004 | +4.773 | +4.848 | PL8 | 7-8/B-A | G32
PL8 | 9.15352 | +4.418 | +4.474 | PL8 | 7-8/B-A | G43
2 x L50*5 | 0 | +4.409 | +4.787 | L50*5 | 7-8/B-A | C27
2 x L50*5 | 0 | +4.060 | +4.430 | L50*5 | 7-8/B-A | C40
9 x PL60*8 | 0.22608 | +4.795 | +4.810 | PL60*8 | 7-8/B-A | Y2
2 x L70*7 | 0 | -0.220 | +0.000 | L70*7 | 5/B | H36
L70*7 | 0 | -0.143 | +2.266 | L70*7 | 5-6/B | V8
PL8 | 2.03499 | -0.220 | +0.000 | PL8 | 5/B | G26
L70*7 | 0 | +2.208 | +4.033 | L70*7 | 5-6/B | V9
L70*7 | 0 | +2.250 | +5.377 | L70*7 | 5-6/B | V10
L70*7 | 0 | -0.128 | +2.224 | L70*7 | 5-6/B | V11
PL8 | 4.00549 | +2.108 | +2.356 | PL8 | 5-6/B | G28
2 x L70*7 | 0 | -0.220 | +0.000 | L70*7 | 6/B | H36
PL8 | 2.05316 | -0.220 | +0.000 | PL8 | 6/B | G25
2 x L70*7 | 0 | +3.880 | +4.100 | L70*7 | 6/B | H36
PL8 | 2.035 | +3.880 | +4.100 | PL8 | 6/B | G26
2 x L70*7 | 0 | +5.239 | +5.459 | L70*7 | 5/B | H36
PL8 | 2.05316 | +5.239 | +5.459 | PL8 | 5/B | G25
PL8 | 4.00549 | +2.108 | +2.356 | PL8 | 5-6/E | G28
PL8 | 2.035 | +3.880 | +4.100 | PL8 | 6/E | G26
PL8 | 2.05316 | -0.220 | -0.000 | PL8 | 6/E | G25
PL8 | 2.03499 | -0.220 | -0.000 | PL8 | 5/E | G26
PL8 | 2.05316 | +5.239 | +5.459 | PL8 | 5/E | G25
L70*7 | 0 | -0.128 | +2.224 | L70*7 | 5-6/E | V11
L70*7 | 0 | +2.250 | +5.377 | L70*7 | 5-6/E | V10
L70*7 | 0 | +2.208 | +4.033 | L70*7 | 5-6/E | V9
L70*7 | 0 | -0.143 | +2.266 | L70*7 | 5-6/E | V8
2 x L70*7 | 0 | -0.220 | -0.000 | L70*7 | 6/E | H36
2 x L70*7 | 0 | +5.239 | +5.459 | L70*7 | 5/E | H36
2 x L70*7 | 0 | +3.880 | +4.100 | L70*7 | 6/E | H36
2 x L70*7 | 0 | -0.220 | -0.000 | L70*7 | 5/E | H36
TUBE-C-90*90*3 | 0.348352 | +5.890 | +5.980 | TUBE-C-90*90*3 | 4-5/F | L107
TUBE-C-90*90*3 | 1.30429 | +4.757 | +5.890 | TUBE-C-90*90*3 | 4-5/F | L21
TUBE-C-60*60*3 | 1.45395 | +4.417 | +5.588 | TUBE-C-60*60*3 | 7/F | L42
TUBE-C-90*90*3 | 0.348352 | +5.429 | +5.683 | TUBE-C-90*90*3 | 7-8/F | L100
TUBE-C-90*90*3 | 0.522527 | +5.800 | +5.890 | TUBE-C-90*90*3 | 7-8/F | L55
6 x PL60*8 | 0.22608 | +5.001 | +5.016 | PL60*8 | 7'/D1-C1 | Y2
BLU300*80*5 | 0.785 | -0.200 | +4.779 | BLU300*80*5 | 7-8/F | P112
BLU300*80*5 | 0.785 | -0.200 | +4.867 | BLU300*80*5 | 7-8/F | P111
BLU300*80*5 | 0.785 | -0.200 | +5.000 | BLU300*80*5 | 7-8/F | P109
BLU300*80*5 | 0.785 | -0.200 | +4.899 | BLU300*80*5 | 7-8/F | P110
PL60*8 | 0.22608 | +2.720 | +2.802 | PL60*8 | 5-6/F | Y2
PL60*8 | 0.22608 | +3.049 | +3.131 | PL60*8 | 5-6/F | Y2
PL60*8 | 0.22608 | +3.378 | +3.460 | PL60*8 | 5-6/F | Y2
PL60*8 | 0.22608 | +3.707 | +3.789 | PL60*8 | 5-6/F | Y2
PL60*8 | 0.22608 | +4.036 | +4.118 | PL60*8 | 5-6/F | Y2
PL60*8 | 0.22608 | +4.365 | +4.447 | PL60*8 | 5-6/F | Y2
PL60*8 | 0.22608 | +4.694 | +4.776 | PL60*8 | 5-6/F | Y2
PL60*8 | 0.22608 | +5.023 | +5.105 | PL60*8 | 5-6/F | Y2
PL60*8 | 0.22608 | +1.544 | +1.623 | PL60*8 | 5-6/F | Y2
PL60*8 | 0.22608 | +1.272 | +1.351 | PL60*8 | 5-6/F | Y2
TUBE-C-120*120*4 | 1.08588 | +4.023 | +5.029 | TUBE-C-120*120*4 | 7-8/F | B8
2 x L70*7 | 0 | +2.350 | +5.484 | L70*7 | 5-6/F | V7
2 x L70*7 | 0 | +2.264 | +4.083 | L70*7 | 5-6/F | V4
2 x L70*7 | 0 | -0.362 | +2.244 | L70*7 | 5-6/F | V6
PL140*10 | 4.47264 | +4.871 | +5.041 | PL140*10 | 5-6/F | H6
2 x L70*7 | 0 | -0.388 | +2.206 | L70*7 | 5-6/F | V5
PL140*10 | 4.47264 | +4.963 | +5.133 | PL140*10 | 7-8/F | H6
2 x L50*5 | 0 | +4.963 | +5.251 | L50*5 | <7'/D1-C1 | C20
2 x L50*5 | 0 | +5.020 | +5.304 | L50*5 | <7'/D1-C1 | C20
L50*5 | 0 | +5.216 | +5.509 | L50*5 | 7-8/D-C | C21
L50*5 | 0 | +5.274 | +5.563 | L50*5 | 7-8/D-C | C21
L50*5 | 0 | +5.216 | +5.504 | L50*5 | 7-8/D-C | C20
L50*5 | 0 | +5.274 | +5.557 | L50*5 | 7-8/D-C | C20
2 x PL50*8 | 0.157 | +5.055 | +5.065 | PL50*8 | <7'/D1-C1 | Y3
7 x PL60*8 | 0.22608 | +5.005 | +5.015 | PL60*8 | 7'/D1-C1 | Y2
PL8 | 7.12217 | +5.240 | +5.285 | PL8 | 7-8/D-C | G46
PL60*8 | 0.22608 | +5.042 | +5.053 | PL60*8 | <7'/7'-D1 | Y2
PL60*8 | 0.22608 | +5.024 | +5.034 | PL60*8 | <7'/D1 | Y2
PL50*8 | 0.157 | +4.908 | +4.918 | PL50*8 | 7-8/F-E | Y3
PL50*8 | 0.157 | +4.920 | +4.931 | PL50*8 | 7-8/F-E | Y3
PL50*8 | 0.157 | +4.933 | +4.943 | PL50*8 | 7-8/F-E | Y3
PL50*8 | 0.157 | +4.946 | +4.956 | PL50*8 | 7-8/F-E | Y3
PL50*8 | 0.157 | +4.959 | +4.969 | PL50*8 | 7-8/F-E | Y3
PL50*8 | 0.157 | +4.972 | +4.982 | PL50*8 | 7-8/F-E | Y3
PL50*8 | 0.157 | +4.985 | +4.995 | PL50*8 | 7-8/F-E | Y3
5 x PL60*8 | 0.22608 | +5.005 | +5.015 | PL60*8 | 7-8/E-D | Y2
PL60*8 | 0.22608 | +5.005 | +5.015 | PL60*8 | 7'/7' | Y2
6 x PL60*8 | 0.22608 | +5.005 | +5.015 | PL60*8 | 7-8/F-E | Y2
L70*7 | 0 | +5.055 | +5.204 | L70*7 | 7-8/F-E | C100
L70*7 | 0 | +5.053 | +5.203 | L70*7 | 7-8/F-E | C100
PL50*8 | 0.157 | +5.159 | +5.169 | PL50*8 | 7-8/F-E | Y3
PL50*8 | 0.157 | +5.139 | +5.150 | PL50*8 | 7-8/F-E | Y3
PL8 | 7.94385 | +4.997 | +5.019 | PL8 | 7-8/F-E | G10
PL8 | 10.6169 | +5.060 | +5.083 | PL8 | <7'/7'-D1 | G65
PL8 | 4.37716 | +5.005 | +5.019 | PL8 | 7-8/E-D | G49
2 x L70*7 | 0 | +4.935 | +5.007 | L70*7 | 7'/D1-C1 | C106
2 x L70*7 | 0 | +5.013 | +5.083 | L70*7 | 7'/D1-C1 | C106
L70*7 | 0 | +4.935 | +5.007 | L70*7 | 7'/D1-C1 | C97
L70*7 | 0 | +5.013 | +5.083 | L70*7 | 7'/D1-C1 | C97
L70*7 | 0 | +4.935 | +5.007 | L70*7 | 7'/7'-D1 | C97
L70*7 | 0 | +5.013 | +5.083 | L70*7 | 7'/7'-D1 | C97
L70*7 | 0 | +4.935 | +5.007 | L70*7 | 7'/<-D1 | C106
L70*7 | 0 | +5.013 | +5.083 | L70*7 | 7'/<-D1 | C106
L70*7 | 0 | +4.935 | +5.007 | L70*7 | 7-8/E-D | C106
L70*7 | 0 | +5.013 | +5.083 | L70*7 | 7-8/E-D | C106
2 x L70*7 | 0 | +4.935 | +5.007 | L70*7 | 7-8/F-E | C103
2 x L70*7 | 0 | +5.013 | +5.083 | L70*7 | 7-8/F-E | C103
L70*7 | 0 | +5.057 | +5.130 | L70*7 | 7-8/F-E | C105
L70*7 | 0 | +5.135 | +5.206 | L70*7 | 7-8/F-E | C105
PL140*10 | 4.47264 | +4.871 | +5.041 | PL140*10 | 6-7/F | H6
IPE400 | 17.9166 | -0.400 | +5.890 | IPE400 | 6/E | P4
IPE400 | 17.9004 | -0.400 | +5.890 | IPE400 | 7/E | P38
2 x FPL6*120 | 0.793042 | +5.509 | +5.584 | FPL6*120 | 6/D | H49
PL8 | 2.02629 | +5.481 | +5.517 | PL8 | 6/D | G35
2 x L70*7 | 0 | +5.411 | +5.496 | L70*7 | 6/D | H39
PL8 | 2.02629 | +5.481 | +5.517 | PL8 | 6/D | G34
2 x PL8 | 2.02629 | +5.481 | +5.517 | PL8 | 6/C | G34
2 x FPL6*120 | 0.793042 | +5.509 | +5.584 | FPL6*120 | 6/C | H49
2 x L70*7 | 0 | +5.411 | +5.496 | L70*7 | 6/C | H39
L50*5 | 0 | +5.122 | +5.510 | L50*5 | 6-7/C-B | C37
PL3450*200 | 10461.8 | +2.500 | +5.950 | PL3450*200 | 7-8/D-C | Z20 | PredefinedType: REINFORCEMENT_UNIT; Tekla Assembly - Cast unit vertical position code: A-+3940; Cast unit rebar weight: 0 kg
PL5950*200 | 4499.12 | +0.000 | +5.574 | PL5950*200 | 7-8/D-C | Z50 | PredefinedType: REINFORCEMENT_UNIT; Tekla Assembly - Cast unit vertical position code: A-+3940; Cast unit rebar weight: 0 kg
PL200 | 16981.4 | +3.000 | +3.200 | PL200 | 7'-/C1> | Z43 | PredefinedType: REINFORCEMENT_UNIT; Tekla Assembly - Cast unit vertical position code: -; Cast unit rebar weight: 0 kg
PL3920*180 | 29287.1 | -0.000 | +3.920 | PL3920*180 | 7'-/<-C1 | Z3 | PredefinedType: REINFORCEMENT_UNIT; Tekla Assembly - Cast unit vertical position code: -; Cast unit rebar weight: 0 kg
PL8 | 9.15352 | +5.131 | +5.187 | PL8 | 6-7/B-A | G43
PL8 | 9.15352 | +4.418 | +4.474 | PL8 | 6-7/B-A | G43
2 x L70*7 | 0 | +4.733 | +4.804 | L70*7 | 6-7/B-A | C104
2 x L70*7 | 0 | +4.733 | +4.804 | L70*7 | 6-7/D-C | C118
6 x L50*5 | 0 | +4.761 | +5.143 | L50*5 | 6-7/D-C | C25
2 x PL8 | 9.76032 | +5.129 | +5.190 | PL8 | 6-7/E-D | G41
PL8 | 9.43281 | +5.129 | +5.190 | PL8 | 6-7/E | G40
IPEA300 | 5.66124 | +5.001 | +5.809 | IPEA300 | <7'/C1> | K49
IPEA300 | 1.9782 | +5.007 | +5.809 | IPEA300 | <7'/D1-C1 | K48
IPEA300 | 2.47275 | +4.106 | +5.773 | IPEA300 | 7-8/C | K39
PL220 | 67546.4 | +2.920 | +3.140 | PL220 | 3-4/C-A | Z62 | PredefinedType: REINFORCEMENT_UNIT; Tekla Assembly - Cast unit vertical position code: A-+0; Cast unit rebar weight: 0 kg
PL200 | 64365.8 | +5.940 | +6.140 | PL200 | 2-4/C-A | Z46 | PredefinedType: REINFORCEMENT_UNIT; Tekla Assembly - Cast unit vertical position code: +3940; Cast unit rebar weight: 0 kg
PL5950*200 | 8119.18 | +0.000 | +5.950 | PL5950*200 | 7-8/D-C | Z42 | PredefinedType: REINFORCEMENT_UNIT; Tekla Assembly - Cast unit vertical position code: A-+3940; Cast unit rebar weight: 0 kg
L70*7 | 0 | +4.975 | +5.154 | L70*7 | 3-4/F-E | C127
L70*7 | 0 | +5.045 | +5.232 | L70*7 | 3-4/F-E | C127
L70*7 | 0 | +4.381 | +4.560 | L70*7 | 3-4/F-E | C127
L70*7 | 0 | +4.451 | +4.638 | L70*7 | 3-4/F-E | C127
L50*5 | 0 | +5.214 | +5.383 | L50*5 | 7-8/D-C | C86
L50*5 | 0 | +5.204 | +5.378 | L50*5 | 7-8/D-C | C91
2 x L50*5 | 0 | +4.765 | +5.143 | L50*5 | 7-8/B-A | C27
2 x L50*5 | 0 | +5.122 | +5.506 | L50*5 | 7-8/B-A | C26
L70*7 | 0 | +3.459 | +3.630 | L70*7 | 7'-/D1-C1 | C101
L70*7 | 0 | +3.536 | +3.708 | L70*7 | 7'-/D1-C1 | C101
L70*7 | 0 | +4.935 | +5.064 | L70*7 | <7'/7'-D1 | C114
L70*7 | 0 | +5.012 | +5.142 | L70*7 | <7'/7'-D1 | C114
L50*5 | 0 | +4.843 | +5.001 | L50*5 | 7-8/F-E | C7
L50*5 | 0 | +4.901 | +5.058 | L50*5 | 7-8/F-E | C7
L50*5 | 0 | +4.729 | +4.885 | L50*5 | 7-8/F-E | C5
L50*5 | 0 | +4.787 | +4.942 | L50*5 | 7-8/F-E | C4
L50*5 | 0 | +4.729 | +4.885 | L50*5 | 7-8/F-E | C6
L50*5 | 0 | +4.787 | +4.942 | L50*5 | 7-8/F-E | C6
L70*7 | 0 | +4.931 | +5.009 | L70*7 | 7'/D1-C1> | C99
L70*7 | 0 | +5.008 | +5.078 | L70*7 | 7'/D1-C1> | C98
2 x L70*7 | 0 | +4.931 | +5.009 | L70*7 | 7'/D1-C1 | C107
2 x L70*7 | 0 | +5.008 | +5.078 | L70*7 | 7'/D1-C1 | C107
4 x L50*5 | 0 | +5.080 | +5.192 | L50*5 | 7-8/E-D | C11
4 x L50*5 | 0 | +5.023 | +5.134 | L50*5 | 7-8/E-D | C11
L50*5 | 0 | +5.016 | +5.126 | L50*5 | <7'/<-D1 | C13
L50*5 | 0 | +4.959 | +5.068 | L50*5 | <7'/<-D1 | C13
L50*5 | 0 | +4.959 | +5.068 | L50*5 | 7-8/F-E | C19
L50*5 | 0 | +5.015 | +5.126 | L50*5 | 7-8/F-E | C19
L50*5 | 0 | +4.958 | +5.068 | L50*5 | 7-8/F-E | C15
L50*5 | 0 | +5.015 | +5.126 | L50*5 | 7-8/F-E | C15
L50*5 | 0 | +5.079 | +5.192 | L50*5 | 7-8/F-E | C18
L50*5 | 0 | +5.136 | +5.250 | L50*5 | 7-8/F-E | C18
L50*5 | 0 | +5.023 | +5.134 | L50*5 | 7-8/F-E | C16
L50*5 | 0 | +5.080 | +5.192 | L50*5 | 7-8/F-E | C16
L50*5 | 0 | +5.023 | +5.134 | L50*5 | 7-8/F-E | C17
L50*5 | 0 | +5.080 | +5.192 | L50*5 | 7-8/F-E | C17
L50*5 | 0 | +4.959 | +5.068 | L50*5 | <7'/7'-C1 | C13
L50*5 | 0 | +5.016 | +5.126 | L50*5 | <7'/7'-C1 | C13
L50*5 | 0 | +5.023 | +5.134 | L50*5 | 7-8/F-E | C14
L50*5 | 0 | +5.080 | +5.192 | L50*5 | 7-8/F-E | C14
L50*5 | 0 | +5.016 | +5.126 | L50*5 | 7-8/E-D | C13
L50*5 | 0 | +4.959 | +5.068 | L50*5 | 7-8/E-D | C13
L50*5 | 0 | +4.959 | +5.068 | L50*5 | <7'/D1-C1 | C10
L50*5 | 0 | +5.015 | +5.126 | L50*5 | <7'/D1-C1 | C10
L50*5 | 0 | +4.959 | +5.068 | L50*5 | <7'/D1-C1 | C13
L50*5 | 0 | +5.016 | +5.126 | L50*5 | <7'/D1-C1 | C13
L50*5 | 0 | +5.023 | +5.135 | L50*5 | 7-8/E-D | C12
L50*5 | 0 | +5.080 | +5.193 | L50*5 | 7-8/E-D | C12
2 x PL8 | 9.70969 | +3.631 | +3.655 | PL8 | 7'-/D1-C1 | G21
PL8 | 2.20249 | +3.744 | +3.758 | PL8 | 7'/C1 | G14
6 x L50*5 | 0 | +3.482 | +3.635 | L50*5 | 7'-/D1-C1 | C41
6 x L50*5 | 0 | +3.595 | +3.747 | L50*5 | 7'-/D1-C1 | C41
PL8 | 6.82104 | +4.774 | +4.831 | PL8 | 7-8/A | G3
PL8 | 2.57354 | +5.004 | +5.016 | PL8 | 7'/7'-D1 | G18
PL8 | 2.57354 | +5.004 | +5.016 | PL8 | 7-8/E | G18
UPN180 | 3.56311 | -0.060 | +2.400 | UPN180 | 6-7/A | P46
L70*7 | 0 | +5.264 | +5.334 | L70*7 | 7-8/D-C | C109
L50*5 | 0 | +5.386 | +5.567 | L50*5 | 7-8/D-C | C90
L50*5 | 0 | +5.333 | +5.510 | L50*5 | 7-8/D-C | C90
3 x PL50*8 | 0.157 | +5.018 | +5.028 | PL50*8 | <7'/D1-C1 | Y3
2 x PL50*8 | 0.157 | +5.027 | +5.037 | PL50*8 | <7'/D1-C1 | Y3
L50*5 | 0 | +4.834 | +5.562 | L50*5 | 7-8/B-A | C95
PL8 | 7.51422 | +4.795 | +4.848 | PL8 | 7-8/B | G1
L50*5 | 0 | +4.776 | +5.484 | L50*5 | 7-8/B-A | C96
L50*5 | 0 | +4.967 | +5.123 | L50*5 | <7'/D1-C1 | C88
L50*5 | 0 | +5.335 | +5.510 | L50*5 | 7-8/D-C | C92
PL8 | 2.57354 | +5.001 | +5.024 | PL8 | 7'/D1-C1 | G27
PL8 | 4.37853 | +5.001 | +5.032 | PL8 | 7'/D1-C1 | G4
L50*5 | 0 | +5.132 | +5.292 | L50*5 | <7'/C1> | C88
L50*5 | 0 | +5.258 | +5.433 | L50*5 | 7-8/D-C | C89
L50*5 | 0 | +5.204 | +5.376 | L50*5 | 7-8/D-C | C89
L50*5 | 0 | +5.258 | +5.436 | L50*5 | 7-8/D-C | C91
L50*5 | 0 | +5.079 | +5.235 | L50*5 | <7'/C1> | C88
L50*5 | 0 | +4.825 | +5.085 | L50*5 | 7-8/D-C | C93
L50*5 | 0 | +4.771 | +5.027 | L50*5 | 7-8/D-C | C93
L50*5 | 0 | +5.340 | +5.510 | L50*5 | 7-8/D-C | C87
L50*5 | 0 | +5.267 | +5.441 | L50*5 | 7-8/D-C | C86
PL50*8 | 0.157 | +5.036 | +5.047 | PL50*8 | <7'/D1-C1 | Y3
2 x PL50*8 | 0.157 | +5.046 | +5.056 | PL50*8 | <7'/D1-C1 | Y3
2 x L50*5 | 0 | +3.420 | +3.545 | L50*5 | 1-2/D-C | C51
3 x L70*7 | 0 | +3.579 | +3.649 | L70*7 | 1-2/C-B | C129
2 x L70*7 | 0 | +3.579 | +3.649 | L70*7 | 1-2/D-C | C130
4 x L70*7 | 0 | +3.579 | +3.649 | L70*7 | 1-2/D-C | C131
4 x L70*7 | 0 | +3.579 | +3.649 | L70*7 | 1-2/E-D | C132
2 x L50*5 | 0 | +3.525 | +3.651 | L50*5 | 1-2/D-C | C71
2 x L50*5 | 0 | +3.583 | +3.708 | L50*5 | 1-2/D-C | C71
2 x L50*5 | 0 | +3.606 | +3.732 | L50*5 | 1-2/D-C | C71
2 x L50*5 | 0 | +3.664 | +3.789 | L50*5 | 1-2/D-C | C71
2 x L50*5 | 0 | +3.501 | +3.626 | L50*5 | 1-2/D-C | C51
L50*5 | 0 | +4.409 | +4.786 | L50*5 | 3-4/F-E | C54
L50*5 | 0 | +4.762 | +5.142 | L50*5 | 3-4/F-E | C54
PL8 | 9.43281 | +5.129 | +5.190 | PL8 | 3-4/E | G40
L50*5 | 0 | +4.463 | +4.844 | L50*5 | 3-4/F-E | C54
L50*5 | 0 | +4.761 | +5.504 | L50*5 | 3-4/C-B | C48
L50*5 | 0 | +4.767 | +5.497 | L50*5 | 3-4/C-B | C46
PL50*8 | 0.157 | +5.262 | +5.279 | PL50*8 | 3-4/F-E | Y3
PL50*8 | 0.157 | +5.217 | +5.233 | PL50*8 | 3-4/F-E | Y3
6 x PL60*8 | 0.22608 | +4.795 | +4.810 | PL60*8 | 3-4/F-E | Y2
PL50*8 | 0.157 | +4.905 | +4.922 | PL50*8 | 3-4/F-E | Y3
PL8 | 6.72677 | +4.740 | +4.799 | PL8 | 4-5/B-A | G6
2 x L70*7 | 0 | +4.733 | +4.804 | L70*7 | 3-4/F-E | C103
L50*5 | 0 | +5.176 | +5.557 | L50*5 | 3-4/F-E | C56
PL50*8 | 0.157 | +4.145 | +4.162 | PL50*8 | 3-4/F | Y3
PL50*8 | 0.157 | +4.283 | +4.299 | PL50*8 | 3-4/F-E | Y3
PL50*8 | 0.157 | +4.728 | +4.745 | PL50*8 | 3-4/F-E | Y3
PL50*8 | 0.157 | +4.504 | +4.521 | PL50*8 | 3-4/F-E | Y3
PL50*8 | 0.157 | +4.861 | +4.877 | PL50*8 | 3-4/F-E | Y3
L50*5 | 0 | +4.053 | +4.430 | L50*5 | 3-4/F-E | C70
L50*5 | 0 | +4.819 | +5.196 | L50*5 | 3-4/F-E | C54
PL8 | 8.43791 | +4.773 | +4.832 | PL8 | 3-4/F-E | G9
L50*5 | 0 | +4.046 | +4.430 | L50*5 | 3-4/F-E | C22
4 x L50*5 | 0 | +4.763 | +5.141 | L50*5 | 3-4/E-D | C30
L70*7 | 0 | +4.733 | +4.804 | L70*7 | 3-4/F-D | C113
2 x L50*5 | 0 | +4.762 | +5.142 | L50*5 | 3-4/F-E | C23
4 x L50*5 | 0 | +5.120 | +5.504 | L50*5 | 3-4/E-D | C24
2 x L70*7 | 0 | +4.803 | +4.881 | L70*7 | 3-4/F-E | C103
L50*5 | 0 | +4.409 | +4.786 | L50*5 | 3-4/F-E | C23
PL50*8 | 0.157 | +4.549 | +4.565 | PL50*8 | 3-4/F-E | Y3
PL50*8 | 0.157 | +4.639 | +4.655 | PL50*8 | 3-4/F-E | Y3
PL50*8 | 0.157 | +4.328 | +4.345 | PL50*8 | 3-4/F-E | Y3
PL50*8 | 0.157 | +4.191 | +4.208 | PL50*8 | 3-4/F-E | Y3
2 x L50*5 | 0 | +5.118 | +5.505 | L50*5 | 3-4/F-E | C22
PL50*8 | 0.157 | +5.085 | +5.101 | PL50*8 | 3-4/F-E | Y3
PL50*8 | 0.157 | +4.995 | +5.012 | PL50*8 | 3-4/F-E | Y3
PL50*8 | 0.157 | +5.308 | +5.325 | PL50*8 | 3-4/F-E | Y3
PL50*8 | 0.157 | +5.446 | +5.462 | PL50*8 | 3-4/F | Y3
PL50*8 | 0.157 | +5.400 | +5.416 | PL50*8 | 3-4/F-E | Y3
PL50*8 | 0.157 | +5.040 | +5.057 | PL50*8 | 3-4/F-E | Y3
PL50*8 | 0.157 | +4.950 | +4.967 | PL50*8 | 3-4/F-E | Y3
PL8 | 2.57354 | +4.792 | +4.814 | PL8 | 3-4/F-E | G18
L50*5 | 0 | +5.118 | +5.503 | L50*5 | 3-4/F-E | C56
PL8 | 6.82104 | +4.774 | +4.831 | PL8 | 3-4/F | G2
PL50*8 | 0.157 | +4.237 | +4.253 | PL50*8 | 3-4/F-E | Y3
PL50*8 | 0.157 | +4.374 | +4.391 | PL50*8 | 3-4/F-E | Y3
PL50*8 | 0.157 | +4.684 | +4.700 | PL50*8 | 3-4/F-E | Y3
PL50*8 | 0.157 | +4.594 | +4.610 | PL50*8 | 3-4/F-E | Y3
PL50*8 | 0.157 | +5.354 | +5.370 | PL50*8 | 3-4/F-E | Y3
L50*5 | 0 | +4.107 | +4.487 | L50*5 | 3-4/F-E | C70
2 x PL8 | 6.37364 | +4.795 | +4.833 | PL8 | 3-4/E-D | G47
L70*7 | 0 | +4.770 | +4.848 | L70*7 | 4-5/B-A | C126
L70*7 | 0 | +4.700 | +4.770 | L70*7 | 4-5/B-A | C126
L70*7 | 0 | +4.770 | +4.848 | L70*7 | 4-5/B-A | C125
L70*7 | 0 | +4.700 | +4.770 | L70*7 | 4-5/B-A | C125
2 x L70*7 | 0 | +4.733 | +4.804 | L70*7 | 4-5/F-E | C103
L70*7 | 0 | +4.733 | +4.804 | L70*7 | 4-5/F-D | C113
L50*5 | 0 | +5.176 | +5.557 | L50*5 | 4-5/F-E | C56
L50*5 | 0 | +5.118 | +5.503 | L50*5 | 4-5/F-E | C56
L70*7 | 0 | +4.692 | +4.770 | L70*7 | 4-5/B-A | C124
L70*7 | 0 | +4.692 | +4.770 | L70*7 | 4-5/C-B | C123
3 x L70*7 | 0 | +4.692 | +4.770 | L70*7 | 4-5/C-B | C122
PL50*8 | 0.157 | +4.728 | +4.745 | PL50*8 | 4-5/F-E | Y3
PL50*8 | 0.157 | +4.684 | +4.700 | PL50*8 | 4-5/F-E | Y3
PL50*8 | 0.157 | +4.995 | +5.012 | PL50*8 | 4-5/F-E | Y3
PL50*8 | 0.157 | +4.950 | +4.967 | PL50*8 | 4-5/F-E | Y3
PL50*8 | 0.157 | +4.861 | +4.877 | PL50*8 | 4-5/F-E | Y3
PL50*8 | 0.157 | +4.905 | +4.922 | PL50*8 | 4-5/F-E | Y3
6 x PL60*8 | 0.22608 | +4.795 | +4.810 | PL60*8 | 4-5/F-E | Y2
PL50*8 | 0.157 | +4.549 | +4.565 | PL50*8 | 5-6/F-E | Y3
L50*5 | 0 | +4.819 | +5.196 | L50*5 | 4-5/F-E | C54
L50*5 | 0 | +4.762 | +5.142 | L50*5 | 4-5/F-E | C54
L50*5 | 0 | +4.046 | +4.430 | L50*5 | 4-5/F-E | C55
L50*5 | 0 | +4.100 | +4.487 | L50*5 | 4-5/F-E | C55
PL50*8 | 0.157 | +4.504 | +4.521 | PL50*8 | 5-6/F-E | Y3
L50*5 | 0 | +4.409 | +4.786 | L50*5 | 4-5/F-E | C54
L50*5 | 0 | +4.463 | +4.844 | L50*5 | 4-5/F-E | C54
2 x L50*5 | 0 | +4.762 | +5.142 | L50*5 | 4-5/F-E | C23
2 x L50*5 | 0 | +5.118 | +5.505 | L50*5 | 4-5/F-E | C22
4 x L50*5 | 0 | +4.763 | +5.141 | L50*5 | 4-5/E-D | C30
4 x L50*5 | 0 | +5.120 | +5.504 | L50*5 | 4-5/E-D | C24
2 x L70*7 | 0 | +5.411 | +5.496 | L70*7 | 5/C | H39
PL50*8 | 0.157 | +4.728 | +4.745 | PL50*8 | 5-6/F-E | Y3
7 x L50*5 | 0 | +4.761 | +5.143 | L50*5 | 5-6/C-B | C25
L50*5 | 0 | +4.409 | +4.786 | L50*5 | 4-5/F-E | C23
L50*5 | 0 | +4.046 | +4.430 | L50*5 | 4-5/F-E | C22
IPEA300 | 4.9455 | +4.112 | +5.785 | IPEA300 | 4-5/E | K42
PL8 | 9.10531 | +4.418 | +4.475 | PL8 | 4-5/F-E | G39
2 x PL8 | 9.76032 | +5.129 | +5.190 | PL8 | 4-5/E-D | G41
L50*5 | 0 | +4.756 | +5.141 | L50*5 | 4-5/E-D | C24
L50*5 | 0 | +5.120 | +5.502 | L50*5 | 4-5/E-D | C35
PL8 | 9.43281 | +5.129 | +5.190 | PL8 | 4-5/E | G40
PL8 | 9.10531 | +5.131 | +5.188 | PL8 | 4-5/F-E | G39
PL50*8 | 0.157 | +4.639 | +4.655 | PL50*8 | 4-5/F-E | Y3
PL50*8 | 0.157 | +4.684 | +4.700 | PL50*8 | 5-6/F-E | Y3
PL50*8 | 0.157 | +5.085 | +5.101 | PL50*8 | 4-5/F-E | Y3
PL50*8 | 0.157 | +4.371 | +4.388 | PL50*8 | 4-5/F-E | Y3
L50*5 | 0 | +5.072 | +5.440 | L50*5 | 4-5/B-A | C42
L50*5 | 0 | +4.729 | +5.097 | L50*5 | 4-5/B-A | C43
PL8 | 2.89301 | +5.427 | +5.460 | PL8 | 4/A | G15
6 x PL60*8 | 0.22608 | +4.795 | +4.810 | PL60*8 | 5-6/F-E | Y2
L50*5 | 0 | +5.075 | +5.439 | L50*5 | 4-5/B-A | C43
L50*5 | 0 | +4.376 | +4.753 | L50*5 | 4-5/B-A | C34
L50*5 | 0 | +4.013 | +4.397 | L50*5 | 4-5/B-A | C33
L50*5 | 0 | +4.373 | +4.754 | L50*5 | 4-5/B-A | C32
L50*5 | 0 | +4.009 | +4.397 | L50*5 | 4-5/B-A | C31
PL50*8 | 0.157 | +4.325 | +4.342 | PL50*8 | 4-5/F-E | Y3
6 x PL60*8 | 0.22608 | +4.795 | +4.810 | PL60*8 | 5-6/B-A | Y2
PL50*8 | 0.157 | +4.594 | +4.610 | PL50*8 | 4-5/F-E | Y3
PL50*8 | 0.157 | +5.040 | +5.057 | PL50*8 | 4-5/F-E | Y3
L70*7 | 0 | +4.733 | +4.804 | L70*7 | 4-5/E-D | C116
2 x PL8 | 6.37364 | +4.795 | +4.833 | PL8 | 4-5/E-D | G47
2 x IPEA300 | 0 | +4.104 | +5.809 | IPEA300 | 4-5/E-D | K16
2 x IPEA300 | 0 | +4.104 | +5.809 | IPEA300 | 4-5/E-D | K14
IPEA300 | 0 | +4.113 | +5.809 | IPEA300 | 4-5/F-E | K12
IPEA300 | 0 | +4.104 | +5.809 | IPEA300 | 4-5/F-E | K11
2 x L70*7 | 0 | +4.803 | +4.881 | L70*7 | 6-7/B-A | C104
PL8 | 2.57354 | +4.792 | +4.814 | PL8 | 6-7/B-A | G18
2 x L70*7 | 0 | +4.803 | +4.881 | L70*7 | 6-7/F-E | C103
2 x PL8 | 2.02629 | +5.481 | +5.517 | PL8 | 5/C | G34
2 x L70*7 | 0 | +4.733 | +4.804 | L70*7 | 6-7/F-E | C103
6 x L50*5 | 0 | +5.122 | +5.506 | L50*5 | 5-6/C-B | C28
6 x L50*5 | 0 | +5.122 | +5.506 | L50*5 | 5-6/D-C | C28
L70*7 | 0 | +4.733 | +4.804 | L70*7 | 6-7/B-A | C121
7 x L50*5 | 0 | +4.761 | +5.143 | L50*5 | 6-7/C-B | C25
4 x PL8 | 9.12418 | +5.131 | +5.188 | PL8 | 6-7/C-B | G42
6 x L50*5 | 0 | +5.122 | +5.506 | L50*5 | 6-7/C-B | C28
L50*5 | 0 | +5.122 | +5.510 | L50*5 | 5-6/C-B | C37
L70*7 | 0 | +4.733 | +4.804 | L70*7 | 6-7/D-C | C119
L70*7 | 0 | +4.733 | +4.804 | L70*7 | 6-7/E-D | C116
L50*5 | 0 | +5.122 | +5.503 | L50*5 | 6-7/C-B | C36
2 x PL8 | 6.37364 | +4.795 | +4.833 | PL8 | 6-7/E-D | G47
PL8 | 2.02629 | +5.481 | +5.517 | PL8 | 5/D | G35
2 x L70*7 | 0 | +5.411 | +5.496 | L70*7 | 5/D | H39
PL50*8 | 0.157 | +4.639 | +4.655 | PL50*8 | 5-6/F-E | Y3
6 x L50*5 | 0 | +5.122 | +5.506 | L50*5 | 6-7/D-C | C28
L70*7 | 0 | +4.733 | +4.804 | L70*7 | 5-6/D-C | C119
3 x PL8 | 6.37364 | +4.795 | +4.833 | PL8 | 6-7/D-C | G48
PL50*8 | 0.157 | +4.950 | +4.967 | PL50*8 | 5-6/F-E | Y3
PL50*8 | 0.157 | +4.995 | +5.012 | PL50*8 | 5-6/F-E | Y3
2 x FPL6*120 | 0.793042 | +5.509 | +5.584 | FPL6*120 | 5/D | H49
PL8 | 2.02629 | +5.481 | +5.517 | PL8 | 5/D | G34
PL50*8 | 0.157 | +4.594 | +4.610 | PL50*8 | 5-6/F-E | Y3
L70*7 | 0 | +4.733 | +4.804 | L70*7 | 6-7/E-D | C115
PL8 | 8.43791 | +4.773 | +4.832 | PL8 | 6-7/F-E | G9
4 x PL8 | 9.12418 | +5.131 | +5.188 | PL8 | 5-6/C-B | G42
3 x PL8 | 6.37364 | +4.795 | +4.833 | PL8 | 5-6/C-B | G48
3 x L70*7 | 0 | +4.733 | +4.804 | L70*7 | 5-6/C-B | C118
L70*7 | 0 | +4.733 | +4.804 | L70*7 | 6-7/F-D | C113
L50*5 | 0 | +5.176 | +5.559 | L50*5 | 6-7/F-E | C55
PL50*8 | 0.157 | +4.905 | +4.922 | PL50*8 | 5-6/F-E | Y3
PL50*8 | 0.157 | +4.861 | +4.877 | PL50*8 | 5-6/F-E | Y3
L50*5 | 0 | +4.760 | +5.143 | L50*5 | 5-6/C-B | C29
L50*5 | 0 | +5.118 | +5.505 | L50*5 | 6-7/F-E | C55
L50*5 | 0 | +4.819 | +5.196 | L50*5 | 6-7/F-E | C54
L50*5 | 0 | +4.762 | +5.142 | L50*5 | 6-7/F-E | C54
2 x L70*7 | 0 | +4.733 | +4.804 | L70*7 | 5-6/B-A | C104
2 x L70*7 | 0 | +4.803 | +4.881 | L70*7 | 5-6/B-A | C104
PL8 | 2.57354 | +4.792 | +4.814 | PL8 | 5-6/B-A | G18
PL8 | 9.10531 | +4.418 | +4.475 | PL8 | 5-6/F-E | G39
L50*5 | 0 | +4.046 | +4.430 | L50*5 | 6-7/F-E | C55
L50*5 | 0 | +4.100 | +4.487 | L50*5 | 6-7/F-E | C55
PL8 | 9.15352 | +5.131 | +5.187 | PL8 | 5-6/B-A | G43
PL8 | 9.15352 | +4.418 | +4.474 | PL8 | 5-6/B-A | G43
L70*7 | 0 | +4.733 | +4.804 | L70*7 | 5-6/C-B | C117
L50*5 | 0 | +4.409 | +4.786 | L50*5 | 6-7/F-E | C54
L50*5 | 0 | +4.463 | +4.844 | L50*5 | 6-7/F-E | C54
2 x L50*5 | 0 | +4.762 | +5.142 | L50*5 | 6-7/F-E | C23
2 x L50*5 | 0 | +5.118 | +5.505 | L50*5 | 6-7/F-E | C22
2 x L50*5 | 0 | +5.122 | +5.503 | L50*5 | 5-6/D-C | C36
L50*5 | 0 | +5.122 | +5.503 | L50*5 | 5-6/C-B | C36
4 x L50*5 | 0 | +4.763 | +5.141 | L50*5 | 6-7/E-D | C30
4 x L50*5 | 0 | +5.120 | +5.504 | L50*5 | 6-7/E-D | C24
L50*5 | 0 | +4.756 | +5.143 | L50*5 | 5-6/D-C | C29
PL50*8 | 0.157 | +5.040 | +5.057 | PL50*8 | 5-6/F-E | Y3
L50*5 | 0 | +4.756 | +5.141 | L50*5 | 6-7/E-D | C24
PL50*8 | 0.157 | +5.085 | +5.101 | PL50*8 | 5-6/F-E | Y3
L50*5 | 0 | +4.760 | +5.143 | L50*5 | 6-7/D-C | C29
L50*5 | 0 | +5.120 | +5.502 | L50*5 | 6-7/E-D | C35
L50*5 | 0 | +4.409 | +4.786 | L50*5 | 6-7/F-E | C23
L50*5 | 0 | +4.046 | +4.430 | L50*5 | 6-7/F-E | C22
2 x L50*5 | 0 | +5.122 | +5.503 | L50*5 | 6-7/D-C | C36
3 x PL8 | 6.37364 | +4.795 | +4.833 | PL8 | 6-7/C-B | G48
3 x L70*7 | 0 | +4.733 | +4.804 | L70*7 | 6-7/C-B | C118
L50*5 | 0 | +4.756 | +5.143 | L50*5 | 6-7/D-C | C29
2 x L50*5 | 0 | +4.046 | +4.430 | L50*5 | 6-7/B-A | C26
2 x L50*5 | 0 | +4.409 | +4.787 | L50*5 | 6-7/B-A | C27
L50*5 | 0 | +4.834 | +5.562 | L50*5 | 6-7/B-A | C95
2 x L50*5 | 0 | +4.765 | +5.143 | L50*5 | 6-7/B-A | C27
L50*5 | 0 | +4.776 | +5.484 | L50*5 | 6-7/B-A | C96
PL8 | 6.82104 | +4.774 | +4.831 | PL8 | 5-6/F | G2
PL8 | 10.1004 | +4.773 | +4.848 | PL8 | 5-6/B-A | G32
PL8 | 7.51422 | +4.795 | +4.848 | PL8 | 5-6/B | G1
TUBE-C-150*150*4 | 1.08588 | +2.188 | +4.152 | TUBE-C-150*150*4 | 5-6/F | B5
PL140*10 | 4.47264 | +5.109 | +5.279 | PL140*10 | 3-4/F | H5
TUBE-C-120*120*4 | 1.08588 | +4.023 | +5.089 | TUBE-C-120*120*4 | 6-7/F | B7
PL140*10 | 4.47264 | +4.871 | +5.041 | PL140*10 | 4-5/F | H5
TUBE-C-120*120*4 | 1.08588 | +4.023 | +5.089 | TUBE-C-120*120*4 | 3-4/F | B7
PL140*10 | 4.47264 | +4.634 | +4.804 | PL140*10 | 3-4/F | H5
PL60*8 | 0.22608 | +0.186 | +0.265 | PL60*8 | 5-6/F | Y2
PL60*8 | 0.22608 | +1.815 | +1.895 | PL60*8 | 5-6/F | Y2
TUBE-C-120*120*4 | 1.08588 | +4.023 | +5.089 | TUBE-C-120*120*4 | 4-5/F | B7
PL60*8 | 0.22608 | +0.457 | +0.536 | PL60*8 | 5-6/F | Y2
TUBE-168.3*4.5 | 10.6823 | -0.361 | +3.061 | TUBE-168.3*4.5 | -/D' | B18
TUBE-C-100*100*3 | 0 | +4.034 | +4.878 | TUBE-C-100*100*3 | 6-7/A | B16
PL60*8 | 0.22608 | +3.767 | +3.842 | PL60*8 | 5-6/A | Y2
2 x L70*7 | 0 | -0.358 | +2.257 | L70*7 | 5-6/A | V14
2 x L50*5 | 0 | +2.176 | +4.647 | L50*5 | /<-D1 | V3
2 x L50*5 | 0 | +2.176 | +4.647 | L50*5 | 8/E-D | V3
PL50*8 | 0.157 | +0.664 | +0.734 | PL50*8 | 8/E-D | Y3
PL50*8 | 0.157 | +0.989 | +1.060 | PL50*8 | 8/E-D | Y3
2 x L50*5 | 0 | -0.354 | +2.078 | L50*5 | 8/E-D | V2
TUBE-C-80*80*3 | 14.6786 | +1.947 | +2.325 | TUBE-C-80*80*3 | /<-D1 | B4
TUBE-C-100*100*3 | 4.5216 | +3.855 | +5.104 | TUBE-C-100*100*3 | /D1-C1> | B3
PL60*8 | 0.22608 | -0.061 | +0.019 | PL60*8 | 5-6/A | Y2
TUBE-C-100*100*3 | 4.5216 | +3.855 | +4.095 | TUBE-C-100*100*3 | /D1-C1 | B2
TUBE-C-100*100*3 | 4.5216 | +3.855 | +4.774 | TUBE-C-100*100*3 | /D1-C1 | B1
2 x L70*7 | 0 | +2.275 | +5.469 | L70*7 | 5-6/A | V13
UPN260 | 0 | +3.845 | +4.105 | UPN260 | 8/B-A | N30
UPN260 | 0 | +3.845 | +4.105 | UPN260 | 8/C-B | N29
UPN260 | 0 | +3.845 | +4.105 | UPN260 | 8/C-B | N28
UPN260 | 0 | +3.845 | +4.105 | UPN260 | 8/D-C | N27
UPN260 | 0 | +4.524 | +4.784 | UPN260 | /<-D1 | N26
UPN260 | 0 | +4.524 | +4.784 | UPN260 | 8/F-E | N25
UPN260 | 0 | +3.273 | +3.533 | UPN260 | /D1-C1> | N24
IPE500 | 30.1405 | +3.490 | +5.298 | IPE500 | 7'/D1-C1> | N5
IPEA300 | 14.2098 | +5.242 | +5.539 | IPEA300 | <7'/C1> | N36
HEA120 | 3.85466 | +4.000 | +5.894 | HEA120 | 7'/D1-C1 | M3
HEA120 | 4.41986 | +4.000 | +5.894 | HEA120 | 7'/D1-C1 | M2
2 x HEA120 | 3.85466 | +4.000 | +5.894 | HEA120 | 7'/D1-C1 | M4
IPEA300 | 9.4689 | +3.059 | +3.708 | IPEA300 | 2-3/D-C | K70
HEA200 | 8.46858 | -0.400 | +3.215 | HEA200 | 2/C | P124
HEA180 | 11.9155 | -0.400 | +3.640 | HEA180 | 1/C | P126
UPN200 | 1.4836 | +4.875 | +5.311 | UPN200 | 7'-/D1 | K56
2 x UPF-100*50*4 | 0 | +5.850 | +5.950 | UPF-100*50*4 | 7-8/F-E | S21
IPE270 | 0 | +5.110 | +5.570 | IPE270 | <7'-/C1> | K97
PL5950*200 | 25773.3 | +0.000 | +5.528 | PL5950*200 | 7'/D1-C1> | Z51 | PredefinedType: REINFORCEMENT_UNIT; Tekla Assembly - Cast unit vertical position code: -; Cast unit rebar weight: 0 kg
PL3450*200 | 10751.6 | +2.500 | +5.950 | PL3450*200 | 7'-/C1 | Z18 | PredefinedType: REINFORCEMENT_UNIT; Tekla Assembly - Cast unit vertical position code: -; Cast unit rebar weight: 0 kg
IPE240 | 0 | +3.527 | +3.997 | IPE240 | 7'-/D1-C1 | K92
IPE240 | 3.53061 | +3.527 | +3.997 | IPE240 | 7'-/D1-C1 | K89
IPE240 | 0 | +3.527 | +3.997 | IPE240 | 7'-/D1-C1 | K91
IPE240 | 3.53061 | +3.527 | +3.997 | IPE240 | 7'-/D1-C1 | K88
IPE240 | 2.33045 | +3.533 | +3.999 | IPE240 | 7'-/D1 | K57
IPE240 | 2.68375 | +3.527 | +3.997 | IPE240 | 7'-/C1 | K87
IPE240 | 1.4836 | +3.527 | +3.997 | IPE240 | 7'-/D1-C1 | K58
IPEA300 | 5.57411 | +4.085 | +5.806 | IPEA300 | 7-8/A | K54
IPEA300 | 3.52889 | +4.116 | +5.806 | IPEA300 | 6-7/A | K55
4 x PL8 | 9.12418 | +5.131 | +5.188 | PL8 | 5-6/D-C | G42
IPEA300 | 0 | +4.116 | +5.792 | IPEA300 | 4-5/A | K4
IPE360 | 16.2274 | +4.042 | +5.809 | IPE360 | 7-8/D-C | K99
IPEA300 | 0 | +4.106 | +5.809 | IPEA300 | 7-8/D-C | K5
IPEA300 | 0 | +4.085 | +5.809 | IPEA300 | 7-8/D-C | K7
4 x IPEA300 | 0 | +4.085 | +5.809 | IPEA300 | 7-8/C-B | K7
3 x IPEA300 | 0 | +4.106 | +5.809 | IPEA300 | 7-8/C-B | K6
UPN200 | 0 | +5.110 | +5.437 | UPN200 | <7'/D1-C1 | K90
IPEA300 | 4.45095 | +5.007 | +5.773 | IPEA300 | <7'/D1-C1 | K43
IPEA300 | 1.9782 | +5.007 | +5.809 | IPEA300 | <7'/D1-C1 | K47
IPEA300 | 2.47275 | +4.106 | +5.785 | IPEA300 | 7-8/B | K40
IPEA300 | 2.04524 | +4.085 | +5.809 | IPEA300 | 7-8/B-A | K8
IPEA300 | 0 | +4.085 | +5.809 | IPEA300 | 7-8/B-A | K9
IPEA300 | 1.9782 | +5.013 | +5.439 | IPEA300 | <7'/D1-C1 | K46
IPEA300 | 4.45095 | +5.013 | +5.440 | IPEA300 | <7'/D1-C1 | K44
IPEA300 | 0 | +5.261 | +5.809 | IPEA300 | 7-8/D-C | K10
IPEA300 | 7.79242 | +4.778 | +5.440 | IPEA300 | <7'-/7'-D1 | K45
IPEA300 | 3.83722 | +4.778 | +5.439 | IPEA300 | 7-8/E-D | K59
IPEA300 | 19.2119 | +4.784 | +5.439 | IPEA300 | 7-8/F | K28
IPEA300 | 9.05923 | +4.778 | +5.440 | IPEA300 | 7-8/F-E | K38
IPEA300 | 1.7997 | +4.778 | +5.439 | IPEA300 | 7-8/F-E | K3
HEA180 | 6.48096 | -0.400 | +3.640 | HEA180 | 1/D-C | P125
HEA200 | 8.46858 | -0.400 | +3.215 | HEA200 | 2/D | P124
IPEA300 | 7.31449 | +3.059 | +3.708 | IPEA300 | 2-3/D-C | K65
IPEA300 | 2.47275 | +4.784 | +5.431 | IPEA300 | 7-8/E | K37
IPE450 | 142.181 | +3.767 | +5.771 | IPE450 | 3-4/D | K21
IPE500 | 50.2073 | -0.400 | +5.890 | IPE500 | 7/D | P28
IPEA300 | 101.276 | +3.864 | +5.902 | IPEA300 | 5/C-B | N42
2 x PL10*55 | 2.20193 | +5.602 | +5.612 | PL10*55 | 5/C-B | H4
PL10*150 | 6.00525 | +5.583 | +5.593 | PL10*150 | 5/C-B | H3
2 x PL10*55 | 2.20193 | +5.871 | +5.881 | PL10*55 | 5/C-B | H4
PL10*150 | 6.00525 | +5.890 | +5.900 | PL10*150 | 5/C-B | H3
2 x PL6*240 | 3.73032 | +5.622 | +5.862 | PL6*240 | 5/C-B | H8
2 x PL6*240 | 3.73032 | +3.969 | +4.209 | PL6*240 | 5/C-B | H8
PL10*150 | 6.00525 | +4.237 | +4.247 | PL10*150 | 5/C-B | H3
2 x PL10*55 | 2.20193 | +4.218 | +4.228 | PL10*55 | 5/C-B | H4
IPEA300 | 81.3191 | +3.864 | +5.902 | IPEA300 | 5/B-A | N39
IPEA300 | 143.979 | +3.869 | +5.900 | IPEA300 | 5/D-C | N8
2 x PL10*55 | 2.20193 | +3.949 | +3.959 | PL10*55 | 5/C-B | H4
PL10*150 | 6.00525 | +3.930 | +3.940 | PL10*150 | 5/C-B | H3
IPEA300 | 123.054 | +3.868 | +5.900 | IPEA300 | 5/D-C | N10
IPEA300 | 143.979 | +3.869 | +5.900 | IPEA300 | 5/C-B | N41
2 x PL6*240 | 3.73032 | +5.621 | +5.861 | PL6*240 | 5/D-C | H8
2 x PL10*55 | 2.20193 | +3.949 | +3.959 | PL10*55 | 5/D-C | H4
PL10*150 | 6.00525 | +3.930 | +3.940 | PL10*150 | 5/D-C | H3
2 x PL10*55 | 2.20193 | +4.218 | +4.228 | PL10*55 | 5/D-C | H4
PL10*150 | 6.00525 | +4.237 | +4.247 | PL10*150 | 5/D-C | H3
2 x PL6*240 | 3.73032 | +3.968 | +4.208 | PL6*240 | 5/D-C | H8
2 x PL10*55 | 2.20193 | +5.602 | +5.612 | PL10*55 | 5/D-C | H4
PL10*150 | 6.00525 | +5.890 | +5.900 | PL10*150 | 5/D-C | H3
2 x PL10*55 | 2.20193 | +5.871 | +5.881 | PL10*55 | 5/D-C | H4
PL10*150 | 6.00525 | +5.583 | +5.593 | PL10*150 | 5/D-C | H3
IPEA300 | 146.948 | +3.863 | +5.901 | IPEA300 | 5/E-D | N47
IPE450 | 142.182 | +3.767 | +5.771 | IPE450 | 4-5/D | K21
IPEA300 | 0 | +4.113 | +5.809 | IPEA300 | 6-7/F-E | K12
IPEA300 | 6.81276 | +4.116 | +5.806 | IPEA300 | 6-7/F | K26
IPEA300 | 6.63656 | +4.116 | +5.809 | IPEA300 | 3-4/F | K25
HEA220 | 17.9011 | -0.400 | +5.894 | HEA220 | 7'/D1 | P123
IPE500 | 64.253 | -0.400 | +5.890 | IPE500 | 7/F | P24
IPE500 | 72.8339 | -0.400 | +5.890 | IPE500 | 6/F | P25
IPE500 | 84.6063 | -0.600 | +5.890 | IPE500 | 5/F | P22
IPE500 | 67.2408 | -0.400 | +5.890 | IPE500 | 5/A | P26
IPE500 | 70.0427 | -0.400 | +5.890 | IPE500 | 6/A | P27
IPE500 | 66.0714 | -0.060 | +5.890 | IPE500 | 7/A | P23
IPE200 | 5.81842 | -0.400 | +5.965 | IPE200 | 4-5/A | P21
IPE200 | 5.81842 | -0.400 | +5.965 | IPE200 | 5-6/A | P20
IPE200 | 6.75982 | -0.400 | +5.965 | IPE200 | 6-7/A | P19
IPE200 | 6.75982 | +0.000 | +5.965 | IPE200 | 7-8/A | P18
IPE200 | 3.73032 | -0.060 | +5.970 | IPE200 | 8/A | P17
IPE200 | 5.61312 | -0.060 | +5.875 | IPE200 | 8/B-A | P15
IPE200 | 5.61312 | -0.060 | +5.875 | IPE200 | 8/B | P14
IPE200 | 3.73032 | -0.060 | +5.875 | IPE200 | 8/C-B | P16
2 x IPE200 | 3.73032 | -0.400 | +5.875 | IPE200 | 8/C-B | P13
IPE200 | 3.73032 | -0.400 | +5.875 | IPE200 | 8/C | P13
IPE200 | 3.73032 | -0.400 | +5.875 | IPE200 | 8/D-C | P12
IPE200 | 5.36312 | -0.400 | +5.875 | IPE200 | 8/D-C | P11
IPE200 | 3.73032 | -0.400 | +5.875 | IPE200 | /D1-C1 | P10
