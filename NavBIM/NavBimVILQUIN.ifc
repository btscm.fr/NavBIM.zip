Properties of the parts of a building model (IFC2X3), part 11 of 32

# IfcBeam: PL120*10 (25)
Name | Center of gravity Z (mm) | Center of gravity Y (mm) | Center of gravity X (mm) | Bottom elevation | Top elevation | Part mark | Assembly mark | Phase | Class | Net weight (kg) = Gross weight (kg) = Weight (kg) = NetWeight (kg) | Net volume (m3) = Gross volume (m3) = NetVolume (m3) | Gross footprint area (m2) | Area per tons (m2) | Net surface area (m2) = Gross area (m2) = OuterSurfaceArea (m2) | Tekla Quantity, Length (mm) = BaseQuantities, Length (mm) | Name
PLAT | 3840 | 21981.2 | -105 | +3.650 | +4.030 | 294 | L118 | 2 | 2003 | 3.5796 | 0.000456 | 0.0012 | 28.2713 | 0.1012 | 380 | PLAT
PLAT | 3840 | 21981.2 | -95 | +3.650 | +4.030 | 294 | N19 | 2 | 2006 | 3.5796 | 0.000456 | 0.0012 | 28.2713 | 0.1012 | 380 | PLAT
PLAT | 3840 | 29375 | -105 | +3.650 | +4.030 | 294 | L118 | 2 | 2003 | 3.5796 | 0.000456 | 0.0012 | 28.2713 | 0.1012 | 380 | PLAT
PLAT | 3840 | 29375 | -95 | +3.650 | +4.030 | 294 | N21 | 2 | 2006 | 3.5796 | 0.000456 | 0.0012 | 28.2713 | 0.1012 | 380 | PLAT
PLAT | 3840 | 24512.5 | -105 | +3.650 | +4.030 | 294 | L118 | 2 | 2003 | 3.5796 | 0.000456 | 0.0012 | 28.2713 | 0.1012 | 380 | PLAT
PLAT | 3840 | 24512.5 | -95 | +3.650 | +4.030 | 294 | N19 | 2 | 2006 | 3.5796 | 0.000456 | 0.0012 | 28.2713 | 0.1012 | 380 | PLAT
PLAT | 3840 | 27043.8 | -95 | +3.650 | +4.030 | 294 | N21 | 2 | 2006 | 3.5796 | 0.000456 | 0.0012 | 28.2713 | 0.1012 | 380 | PLAT
PLAT | 3840 | 27043.8 | -105 | +3.650 | +4.030 | 294 | L118 | 2 | 2003 | 3.5796 | 0.000456 | 0.0012 | 28.2713 | 0.1012 | 380 | PLAT
 | 5524.49 | 26545 | 71815 | +5.519 | +5.529 | 229 | M13 | 1 | 1007 | 0.97968 | 0.0001248 | 0.01248 | 30.0506 | 0.02944 | 104
PLATINE | 3974.78 | 24657.8 | 79225 | +3.855 | +4.095 | 242 | B3 | 1 | 1002 | 2.2608 | 0.000288 | 0.0012 | 28.6624 | 0.0648 | 240 | PLATINE
PLATINE | 4653.72 | 13557.8 | 79225 | +4.534 | +4.774 | 242 | B1 | 1 | 1002 | 2.2608 | 0.000288 | 0.0012 | 28.6624 | 0.0648 | 240 | PLATINE
PLATINE | 3974.78 | 19457.8 | 79225 | +3.855 | +4.095 | 242 | B2 | 1 | 1002 | 2.2608 | 0.000288 | 0.0012 | 28.6624 | 0.0648 | 240 | PLATINE

# IfcBeam: PL120*12 (22)
In: Undefined
Description: PL120*12; Material: STEEL/S235JR
Tekla Common - Phase: 4; Class: 4000; Finish: GALVANISE; Grade: S235JR; Profile: PL120*12; Name: SUPPORT; sets with these values: 2
Tekla Quantity - Height: 120 mm; Width: 12 mm; sets with these values: 2
Name | Center of gravity Z (mm) | Center of gravity Y (mm) | Center of gravity X (mm) | Bottom elevation | Top elevation | Part mark | Assembly mark | Net weight (kg) = Gross weight (kg) = Weight (kg) = NetWeight (kg) | Net volume (m3) = Gross volume (m3) = NetVolume (m3) | Gross footprint area (m2) | Area per tons (m2) | Net surface area (m2) = Gross area (m2) = OuterSurfaceArea (m2) | Tekla Quantity, Length (mm) = BaseQuantities, Length (mm)
SUPPORT | 5089.91 | 18956 | 71997 | +5.030 | +5.150 | 1261 | E1 | 5.53896 | 0.0007056 | 0.00588 | 23.8745 | 0.13224 | 490
SUPPORT | 5089.91 | 18344 | 71997 | +5.030 | +5.150 | 1261 | E1 | 5.53896 | 0.0007056 | 0.00588 | 23.8745 | 0.13224 | 490
SUPPORT | 4790 | 25444 | 55625 | +4.730 | +4.850 | 1262 | E2 | 6.2172 | 0.000792 | 0.0066 | 23.8178 | 0.14808 | 550
SUPPORT | 5440 | 25444 | 55625 | +5.380 | +5.500 | 1262 | E2 | 6.2172 | 0.000792 | 0.0066 | 23.8178 | 0.14808 | 550
SUPPORT | 5440 | 26056 | 55625 | +5.380 | +5.500 | 1262 | E2 | 6.2172 | 0.000792 | 0.0066 | 23.8178 | 0.14808 | 550
SUPPORT | 4790 | 26056 | 55625 | +4.730 | +4.850 | 1262 | E2 | 6.2172 | 0.000792 | 0.0066 | 23.8178 | 0.14808 | 550
SUPPORT | 4790 | 26056 | 43950 | +4.730 | +4.850 | 1262 | E2 | 6.2172 | 0.000792 | 0.0066 | 23.8178 | 0.14808 | 550
SUPPORT | 4790 | 25444 | 43950 | +4.730 | +4.850 | 1262 | E2 | 6.2172 | 0.000792 | 0.0066 | 23.8178 | 0.14808 | 550
SUPPORT | 5440 | 25444 | 43950 | +5.380 | +5.500 | 1262 | E2 | 6.2172 | 0.000792 | 0.0066 | 23.8178 | 0.14808 | 550
SUPPORT | 5440 | 26056 | 43950 | +5.380 | +5.500 | 1262 | E2 | 6.2172 | 0.000792 | 0.0066 | 23.8178 | 0.14808 | 550
SUPPORT | 4790 | 26056 | 32275 | +4.730 | +4.850 | 1262 | E2 | 6.2172 | 0.000792 | 0.0066 | 23.8178 | 0.14808 | 550
SUPPORT | 4790 | 25444 | 32275 | +4.730 | +4.850 | 1262 | E2 | 6.2172 | 0.000792 | 0.0066 | 23.8178 | 0.14808 | 550
SUPPORT | 5440 | 25444 | 32275 | +5.380 | +5.500 | 1262 | E2 | 6.2172 | 0.000792 | 0.0066 | 23.8178 | 0.14808 | 550
SUPPORT | 5440 | 26056 | 32275 | +5.380 | +5.500 | 1262 | E2 | 6.2172 | 0.000792 | 0.0066 | 23.8178 | 0.14808 | 550
SUPPORT | 4790 | 23156 | 67300 | +4.730 | +4.850 | 1262 | E2 | 6.2172 | 0.000792 | 0.0066 | 23.8178 | 0.14808 | 550
SUPPORT | 5440 | 23156 | 67300 | +5.380 | +5.500 | 1262 | E2 | 6.2172 | 0.000792 | 0.0066 | 23.8178 | 0.14808 | 550
SUPPORT | 5440 | 22544 | 67300 | +5.380 | +5.500 | 1262 | E2 | 6.2172 | 0.000792 | 0.0066 | 23.8178 | 0.14808 | 550
SUPPORT | 4790 | 22544 | 67300 | +4.730 | +4.850 | 1262 | E2 | 6.2172 | 0.000792 | 0.0066 | 23.8178 | 0.14808 | 550
SUPPORT | 5740 | 18956 | 71997 | +5.680 | +5.800 | 1261 | E1 | 5.53896 | 0.0007056 | 0.00588 | 23.8745 | 0.13224 | 490
SUPPORT | 4439.82 | 18956 | 71997 | +4.380 | +4.500 | 1261 | E1 | 5.53896 | 0.0007056 | 0.00588 | 23.8745 | 0.13224 | 490
SUPPORT | 4439.82 | 18344 | 71997 | +4.380 | +4.500 | 1261 | E1 | 5.53896 | 0.0007056 | 0.00588 | 23.8745 | 0.13224 | 490
SUPPORT | 5740 | 18344 | 71997 | +5.680 | +5.800 | 1261 | E1 | 5.53896 | 0.0007056 | 0.00588 | 23.8745 | 0.13224 | 490

# IfcBeam: PL120*8 (10)
In: Undefined
Description: PL120*8; Material: STEEL/E24-2
Tekla Common - Center of gravity Z: 10227.5 mm; Center of gravity X: 26177.5 mm; Bottom elevation: +10.164; Top elevation: +10.291; Part mark: 819; Phase: 2; Class: 2004; Finish: GRENAILLE-PEINT; Grade: E24-2; Profile: PL120*8; Name: PLAT; sets with these values: 2
Tekla Quantity - Net weight: 1.58256 kg; Gross weight: 1.58256 kg; Weight: 1.58256 kg; Net volume: 0.0002016 m3; Gross volume: 0.0002016 m3; Gross footprint area: 0 m2; Area per tons: 35.1835 m2; Net surface area: 0.05568 m2; Gross area: 0.05568 m2; Height: 120 mm; Width: 8 mm; Length: 210 mm; sets with these values: 2
BaseQuantities - Length: 210 mm; OuterSurfaceArea: 0.05568 m2; NetVolume: 0.0002016 m3; NetWeight: 1.58256 kg
Name | Center of gravity Y (mm) | Assembly mark
PLAT | 52697.8 | B9
PLAT | 63742.2 | B9
PLAT | 60977.2 | B9
PLAT | 60992.8 | B9
PLAT | 55447.2 | B9
PLAT | 55462.8 | B9
PLAT | 63757.8 | B6
PLAT | 58212.2 | B9
PLAT | 58227.8 | B9
PLAT | 52682.2 | B6

# IfcBeam: PL140*10 (16)
In: Undefined
Description: PL140*10
Tekla Common - Finish: GRENAILLE-PEINT; Profile: PL140*10; sets with these values: 2
Tekla Quantity - Height: 140 mm; Width: 10 mm; sets with these values: 2
Name | Material | Center of gravity Z (mm) | Center of gravity Y (mm) | Center of gravity X (mm) | Bottom elevation | Top elevation | Part mark | Assembly mark | Phase | Class | Grade | Name | Net weight (kg) = Gross weight (kg) = Weight (kg) = NetWeight (kg) | Net volume (m3) = Gross volume (m3) = NetVolume (m3) | Gross footprint area (m2) | Area per tons (m2) | Net surface area (m2) = Gross area (m2) = OuterSurfaceArea (m2) | Tekla Quantity, Length (mm) = BaseQuantities, Length (mm)
PLAT | STEEL/S235JR | 4744.57 | 69275 | 50037.5 | +4.740 | +4.750 | 212 | P20 | 1 | 1001 | S235JR | PLAT | 2.0881 | 0.000266 | 0.0266 | 28.6385 | 0.0598 | 190
PLAT | STEEL/S235JR | 4744.57 | 69275 | 61712.5 | +4.740 | +4.750 | 212 | P19 | 1 | 1001 | S235JR | PLAT | 2.0881 | 0.000266 | 0.0266 | 28.6385 | 0.0598 | 190
PLAT | STEEL/E24-2 | 4744.57 | 69275 | 38362.5 | +4.740 | +4.750 | 184 | P21 | 3 | 3001 | E24-2 | PLAT | 2.0881 | 0.000266 | 0.0266 | 28.6385 | 0.0598 | 190
ATTACHE | STEEL/S235JR | 4956.4 | -87 | 38362.5 | +4.871 | +5.041 | 202 | H5 | 3 | 3001 | S235JR | ATTACHE | 1.86827 | 0.000237996 | 0.0014 | 28.7963 | 0.0537992 | 169.997
ATTACHE | STEEL/S235JR | 4956.4 | -8.05 | 38362.5 | +4.871 | +5.041 | 202 | H5 | 3 | 3001 | S235JR | ATTACHE | 1.86827 | 0.000237996 | 0.0014 | 28.7963 | 0.0537992 | 169.997
ATTACHE | STEEL/S235JR | 4956.4 | -87 | 61712.5 | +4.871 | +5.041 | 210 | H6 | 1 | 1001 | S235JR | ATTACHE | 1.86827 | 0.000237996 | 0.0014 | 28.7963 | 0.0537992 | 169.997
ATTACHE | STEEL/S235JR | 4956.4 | -8.05 | 61712.5 | +4.871 | +5.041 | 210 | H6 | 1 | 1001 | S235JR | ATTACHE | 1.86827 | 0.000237996 | 0.0014 | 28.7963 | 0.0537992 | 169.997
ATTACHE | STEEL/S235JR | 5048.46 | -8.05 | 74420 | +4.963 | +5.133 | 210 | H6 | 1 | 1001 | S235JR | ATTACHE | 1.86827 | 0.000237996 | 0.0014 | 28.7963 | 0.0537992 | 169.997
ATTACHE | STEEL/S235JR | 5048.46 | -87 | 74420 | +4.963 | +5.133 | 210 | H6 | 1 | 1001 | S235JR | ATTACHE | 1.86827 | 0.000237996 | 0.0014 | 28.7963 | 0.0537992 | 169.997
ATTACHE | STEEL/S235JR | 4956.4 | -8.05 | 50037.5 | +4.871 | +5.041 | 210 | H6 | 1 | 1001 | S235JR | ATTACHE | 1.86827 | 0.000237996 | 0.0014 | 28.7963 | 0.0537992 | 169.997
ATTACHE | STEEL/S235JR | 4956.4 | -87 | 50037.5 | +4.871 | +5.041 | 210 | H6 | 1 | 1001 | S235JR | ATTACHE | 1.86827 | 0.000237996 | 0.0014 | 28.7963 | 0.0537992 | 169.997
ATTACHE | STEEL/S235JR | 4718.77 | -8.05 | 28633 | +4.634 | +4.804 | 202 | H5 | 3 | 3001 | S235JR | ATTACHE | 1.86827 | 0.000237996 | 0.0014 | 28.7963 | 0.0537992 | 169.997
ATTACHE | STEEL/S235JR | 4718.77 | -87 | 28633 | +4.634 | +4.804 | 202 | H5 | 3 | 3001 | S235JR | ATTACHE | 1.86827 | 0.000237996 | 0.0014 | 28.7963 | 0.0537992 | 169.997
ATTACHE | STEEL/S235JR | 5194.03 | -8.05 | 24742 | +5.109 | +5.279 | 202 | H5 | 3 | 3001 | S235JR | ATTACHE | 1.86827 | 0.000237996 | 0.0014 | 28.7963 | 0.0537992 | 169.997
ATTACHE | STEEL/S235JR | 5194.03 | -87 | 24742 | +5.109 | +5.279 | 202 | H5 | 3 | 3001 | S235JR | ATTACHE | 1.86827 | 0.000237996 | 0.0014 | 28.7963 | 0.0537992 | 169.997
PLAT | STEEL/S235JR | 4744.57 | 69275 | 73387.5 | +4.740 | +4.750 | 212 | P18 | 1 | 1001 | S235JR | PLAT | 2.0881 | 0.000266 | 0.0266 | 28.6385 | 0.0598 | 190

# IfcBeam: PL15*190 (16)
In: Undefined
Description: PL15*190; Material: STEEL/E24-2
Tekla Common - Finish: GRENAILLE-PEINT; Grade: E24-2; Profile: PL15*190; Name: POUTRE; sets with these values: 2
Tekla Quantity - Gross footprint area: 0 m2; Height: 190 mm; Width: 15 mm; sets with these values: 2
Name | Center of gravity Z (mm) | Center of gravity Y (mm) | Center of gravity X (mm) | Bottom elevation | Top elevation | Part mark | Assembly mark | Phase | Class | Net weight (kg) = Gross weight (kg) = Weight (kg) = NetWeight (kg) | Net volume (m3) = Gross volume (m3) = NetVolume (m3) | Area per tons (m2) | Net surface area (m2) = Gross area (m2) = OuterSurfaceArea (m2) | Tekla Quantity, Length (mm) = BaseQuantities, Length (mm)
POUTRE | 5034.08 | 19450 | 45577.9 | +4.991 | +5.077 | 152 | K21 | 1 | 1005 | 44.2209 | 0.00563323 | 18.455 | 0.816095 | 1976.57
POUTRE | 3934.18 | 19450 | 55469.5 | +3.850 | +4.019 | 150 | K21 | 1 | 1005 | 11.4178 | 0.0014545 | 18.8253 | 0.214944 | 510.352
POUTRE | 5034.08 | 40250 | 45577.9 | +4.991 | +5.077 | 152 | K22 | 1 | 1005 | 44.2209 | 0.00563323 | 18.455 | 0.816095 | 1976.57
POUTRE | 3934.18 | 40250 | 55469.5 | +3.850 | +4.019 | 150 | K22 | 1 | 1005 | 11.4178 | 0.0014545 | 18.8253 | 0.214944 | 510.352
POUTRE | 3934.18 | 40250 | 67144.5 | +3.850 | +4.019 | 150 | K24 | 1 | 1005 | 11.4178 | 0.0014545 | 18.8253 | 0.214944 | 510.352
POUTRE | 5034.08 | 40250 | 57252.9 | +4.991 | +5.077 | 152 | K24 | 1 | 1005 | 44.2209 | 0.00563323 | 18.455 | 0.816095 | 1976.57
POUTRE | 3934.18 | 40250 | 43794.5 | +3.850 | +4.019 | 150 | K22 | 3 | 3005 | 11.4178 | 0.0014545 | 18.8253 | 0.214944 | 510.352
POUTRE | 5034.08 | 40250 | 33902.9 | +4.991 | +5.077 | 152 | K22 | 3 | 3005 | 44.2209 | 0.00563323 | 18.455 | 0.816095 | 1976.57
POUTRE | 3934.18 | 40250 | 32119.5 | +3.850 | +4.019 | 150 | K23 | 3 | 3005 | 11.4178 | 0.0014545 | 18.8253 | 0.214944 | 510.352
POUTRE | 5034.08 | 19450 | 22227.9 | +4.991 | +5.077 | 152 | K21 | 3 | 3005 | 44.2209 | 0.00563323 | 18.455 | 0.816095 | 1976.57
POUTRE | 3934.18 | 19450 | 32119.5 | +3.850 | +4.019 | 150 | K21 | 3 | 3005 | 11.4178 | 0.0014545 | 18.8253 | 0.214944 | 510.352
POUTRE | 5034.08 | 40250 | 22227.9 | +4.991 | +5.077 | 152 | K23 | 3 | 3005 | 44.2209 | 0.00563323 | 18.455 | 0.816095 | 1976.57
POUTRE | 5034.08 | 19450 | 33902.9 | +4.991 | +5.077 | 152 | K21 | 3 | 3005 | 44.2209 | 0.00563323 | 18.455 | 0.816095 | 1976.57
POUTRE | 5034.08 | 19450 | 57252.9 | +4.991 | +5.077 | 152 | K21 | 1 | 1005 | 44.2209 | 0.00563323 | 18.455 | 0.816095 | 1976.57
POUTRE | 3934.18 | 19450 | 43794.5 | +3.850 | +4.019 | 150 | K21 | 3 | 3005 | 11.4178 | 0.0014545 | 18.8253 | 0.214944 | 510.352
POUTRE | 3934.18 | 19450 | 67144.5 | +3.850 | +4.019 | 150 | K21 | 1 | 1005 | 11.4178 | 0.0014545 | 18.8253 | 0.214944 | 510.352

# IfcBeam: PL15*200 (10)
In: Undefined
Description: PL15*200; Material: STEEL/E24-2
Tekla Common - Center of gravity Z: 5783.54 mm; Bottom elevation: +5.761; Top elevation: +5.807; Finish: GRENAILLE-PEINT; Grade: E24-2; Profile: PL15*200; Name: POUTRE; sets with these values: 2
Tekla Quantity - Net weight: 6.05163 kg; Gross weight: 6.05163 kg; Weight: 6.05163 kg; Net volume: 0.000770908 m3; Gross volume: 0.000770908 m3; Gross footprint area: 0 m2; Area per tons: 19.2505 m2; Net surface area: 0.116497 m2; Gross area: 0.116497 m2; Height: 200 mm; Width: 15 mm; Length: 256.969 mm; sets with these values: 2
BaseQuantities - Length: 256.969 mm; OuterSurfaceArea: 0.116497 m2; NetVolume: 0.000770908 m3; NetWeight: 6.05163 kg
Name | Center of gravity Y (mm) | Center of gravity X (mm) | Part mark | Assembly mark | Phase | Class
POUTRE | 19450 | 21078.4 | 162 | P29 | 2 | 2001
POUTRE | 40250 | 32753.4 | 162 | P31 | 3 | 3001
POUTRE | 40250 | 56103.4 | 151 | P35 | 1 | 1001
POUTRE | 40250 | 21078.4 | 162 | P30 | 2 | 2001
POUTRE | 40250 | 44428.4 | 151 | P35 | 1 | 1001
POUTRE | 40250 | 67778.4 | 151 | P33 | 1 | 1001
POUTRE | 19450 | 56103.4 | 151 | P36 | 1 | 1001
POUTRE | 19450 | 44428.4 | 151 | P36 | 1 | 1001
POUTRE | 19450 | 32753.4 | 162 | P32 | 3 | 3001
POUTRE | 19450 | 67778.4 | 151 | P28 | 1 | 1001

# IfcBeam: PL15*230, PLATINE
In: Undefined
Description: PL15*230; Material: STEEL/E24-2
Tekla Common - Center of gravity Z: 4653.72 mm; Center of gravity Y: -76.5 mm; Center of gravity X: 79142.5 mm; Bottom elevation: +4.539; Top elevation: +4.769; Part mark: 153; Assembly mark: P122; Phase: 1; Class: 1011; Finish: GRENAILLE-PEINT; Grade: E24-2; Profile: PL15*230; Name: PLATINE; sets with these values: 2
Tekla Quantity - Net weight: 7.66435 kg; Gross weight: 7.66435 kg; Weight: 7.66435 kg; Net volume: 0.00097635 m3; Gross volume: 0.00097635 m3; Gross footprint area: 0.004245 m2; Area per tons: 18.9931 m2; Net surface area: 0.14557 m2; Gross area: 0.14557 m2; Height: 230 mm; Width: 15 mm; Length: 283 mm; sets with these values: 2
BaseQuantities - Length: 283 mm; OuterSurfaceArea: 0.14557 m2; NetVolume: 0.00097635 m3; NetWeight: 7.66435 kg

# IfcBeam: PL150*10 (52)
In: Undefined
Description: PL150*10
Tekla Common - Finish: GRENAILLE-PEINT; Profile: PL150*10; sets with these values: 2
Tekla Quantity - Height: 150 mm; Width: 10 mm; sets with these values: 2
Name | Material | Center of gravity Z (mm) | Center of gravity Y (mm) | Center of gravity X (mm) | Bottom elevation | Top elevation | Part mark | Assembly mark | Phase | Class | Grade | Net weight (kg) = Weight (kg) = NetWeight (kg) | Gross weight (kg) | Net volume (m3) = Gross volume (m3) = NetVolume (m3) | Gross footprint area (m2) | Area per tons (m2) | Net surface area (m2) = Gross area (m2) = OuterSurfaceArea (m2) | Tekla Quantity, Length (mm) = BaseQuantities, Length (mm) | Name
 | STEEL/E24-2 | 5 | 19620 | 78197.5 | +0.000 | +0.010 | 194 | P132 | 7 | 7001 | E24-2 | 2.29612 | 2.29612 | 0.0002925 | 0.02925 | 28.4828 | 0.0654 | 195
 | STEEL/E24-2 | 5 | 19620 | 74992.5 | +0.000 | +0.010 | 194 | P133 | 7 | 7001 | E24-2 | 2.29612 | 2.29612 | 0.0002925 | 0.02925 | 28.4828 | 0.0654 | 195
PLAT | STEEL/S235JR | 3578.73 | 49365 | 9284.9 | +3.482 | +3.675 | 279 | K86 | 2 | 2005 | S235JR | 2.27226 | 2.27226 | 0.00028946 | 0.0015 | 28.4965 | 0.0647515 | 192.973 | PLAT
PLAT | STEEL/S235JR | 3373.67 | 48525 | 9305.1 | +3.246 | +3.502 | 258 | K101 | 2 | 2005 | S235JR | 3.01439 | 3.01439 | 0.000383999 | 0.0015 | 28.1714 | 0.0849198 | 255.999 | PLAT
PLAT | STEEL/S235JR | 3550.24 | 48525 | 9284.9 | +3.425 | +3.675 | 259 | K82 | 2 | 2005 | S235JR | 2.9432 | 2.9432 | 0.00037493 | 0.0015 | 28.1955 | 0.0829851 | 249.953 | PLAT
PLAT | STEEL/S235JR | 3373.67 | 45766.7 | 9305.1 | +3.246 | +3.502 | 258 | K60 | 2 | 2005 | S235JR | 3.01439 | 3.01439 | 0.000383999 | 0.0015 | 28.1714 | 0.0849198 | 255.999 | PLAT
PLAT | STEEL/S235JR | 3550.24 | 45766.7 | 9284.9 | +3.425 | +3.675 | 259 | K83 | 2 | 2005 | S235JR | 2.9432 | 2.9432 | 0.00037493 | 0.0015 | 28.1955 | 0.0829851 | 249.953 | PLAT
PLAT | STEEL/S235JR | 3550.24 | 43008.3 | 9284.9 | +3.425 | +3.675 | 259 | K83 | 2 | 2005 | S235JR | 2.9432 | 2.9432 | 0.00037493 | 0.0015 | 28.1955 | 0.0829851 | 249.953 | PLAT
PLAT | STEEL/S235JR | 3373.67 | 43008.3 | 9305.1 | +3.246 | +3.502 | 258 | K67 | 2 | 2005 | S235JR | 3.01439 | 3.01439 | 0.000383999 | 0.0015 | 28.1714 | 0.0849198 | 255.999 | PLAT
PLAT | STEEL/S235JR | 3550.24 | 40250 | 9284.9 | +3.425 | +3.675 | 259 | K83 | 2 | 2005 | S235JR | 2.9432 | 2.9432 | 0.00037493 | 0.0015 | 28.1955 | 0.0829851 | 249.953 | PLAT
PLAT | STEEL/S235JR | 3373.67 | 40250 | 9305.1 | +3.246 | +3.502 | 258 | K64 | 2 | 2005 | S235JR | 3.01439 | 3.01439 | 0.000383999 | 0.0015 | 28.1714 | 0.0849198 | 255.999 | PLAT
PLAT | STEEL/S235JR | 3550.24 | 10930 | 9284.9 | +3.425 | +3.675 | 259 | K75 | 2 | 2005 | S235JR | 2.9432 | 2.9432 | 0.00037493 | 0.0015 | 28.1955 | 0.0829851 | 249.953 | PLAT
PLAT | STEEL/S235JR | 3373.67 | 10930 | 9305.1 | +3.246 | +3.502 | 258 | K102 | 2 | 2005 | S235JR | 3.01439 | 3.01439 | 0.000383999 | 0.0015 | 28.1714 | 0.0849198 | 255.999 | PLAT
PLAT | STEEL/S235JR | 3550.24 | 13060 | 9284.9 | +3.425 | +3.675 | 259 | K74 | 2 | 2005 | S235JR | 2.9432 | 2.9432 | 0.00037493 | 0.0015 | 28.1955 | 0.0829851 | 249.953 | PLAT
PLAT | STEEL/S235JR | 3373.67 | 13060 | 9305.1 | +3.246 | +3.502 | 258 | K72 | 2 | 2005 | S235JR | 3.01439 | 3.01439 | 0.000383999 | 0.0015 | 28.1714 | 0.0849198 | 255.999 | PLAT
PLAT | STEEL/S235JR | 3550.24 | 15190 | 9284.9 | +3.425 | +3.675 | 259 | K81 | 2 | 2005 | S235JR | 2.9432 | 2.9432 | 0.00037493 | 0.0015 | 28.1955 | 0.0829851 | 249.953 | PLAT
PLAT | STEEL/S235JR | 3373.67 | 15190 | 9305.1 | +3.246 | +3.502 | 258 | K63 | 2 | 2005 | S235JR | 3.01439 | 3.01439 | 0.000383999 | 0.0015 | 28.1714 | 0.0849198 | 255.999 | PLAT
PLAT | STEEL/S235JR | 3550.24 | 17320 | 9284.9 | +3.425 | +3.675 | 259 | K80 | 2 | 2005 | S235JR | 2.9432 | 2.9432 | 0.00037493 | 0.0015 | 28.1955 | 0.0829851 | 249.953 | PLAT
PLAT | STEEL/S235JR | 3373.67 | 17320 | 9305.1 | +3.246 | +3.502 | 258 | K68 | 2 | 2005 | S235JR | 3.01439 | 3.01439 | 0.000383999 | 0.0015 | 28.1714 | 0.0849198 | 255.999 | PLAT
PLAT | STEEL/S235JR | 3550.24 | 19450 | 9284.9 | +3.425 | +3.675 | 259 | K79 | 2 | 2005 | S235JR | 2.9432 | 2.9432 | 0.00037493 | 0.0015 | 28.1955 | 0.0829851 | 249.953 | PLAT
PLAT | STEEL/S235JR | 3373.67 | 19450 | 9305.1 | +3.246 | +3.502 | 258 | K66 | 2 | 2005 | S235JR | 3.01439 | 3.01439 | 0.000383999 | 0.0015 | 28.1714 | 0.0849198 | 255.999 | PLAT
PLAT | STEEL/S235JR | 3373.67 | 32243.8 | 9305.1 | +3.246 | +3.502 | 258 | K69 | 2 | 2005 | S235JR | 3.01439 | 3.01439 | 0.000383999 | 0.0015 | 28.1714 | 0.0849198 | 255.999 | PLAT
PLAT | STEEL/S235JR | 3373.67 | 21981.2 | 9305.1 | +3.246 | +3.502 | 258 | K71 | 2 | 2005 | S235JR | 3.01439 | 3.01439 | 0.000383999 | 0.0015 | 28.1714 | 0.0849198 | 255.999 | PLAT
PLAT | STEEL/S235JR | 3373.67 | 37581.2 | 9305.1 | +3.246 | +3.502 | 258 | K70 | 2 | 2005 | S235JR | 3.01439 | 3.01439 | 0.000383999 | 0.0015 | 28.1714 | 0.0849198 | 255.999 | PLAT
PLAT | STEEL/S235JR | 3550.24 | 32243.8 | 9284.9 | +3.425 | +3.675 | 259 | K73 | 2 | 2005 | S235JR | 2.9432 | 2.9432 | 0.00037493 | 0.0015 | 28.1955 | 0.0829851 | 249.953 | PLAT
PLAT | STEEL/S235JR | 3550.24 | 24512.5 | 9284.9 | +3.425 | +3.675 | 259 | K77 | 2 | 2005 | S235JR | 2.9432 | 2.9432 | 0.00037493 | 0.0015 | 28.1955 | 0.0829851 | 249.953 | PLAT
PLAT | STEEL/S235JR | 3550.24 | 27043.8 | 9284.9 | +3.425 | +3.675 | 259 | K76 | 2 | 2005 | S235JR | 2.9432 | 2.9432 | 0.00037493 | 0.0015 | 28.1955 | 0.0829851 | 249.953 | PLAT
PLAT | STEEL/S235JR | 3874.49 | 29575 | 9.3 | +3.750 | +3.999 | 261 | K84 | 2 | 2005 | S235JR | 2.9432 | 2.9432 | 0.00037493 | 0.0015 | 28.1955 | 0.0829851 | 249.953 | PLAT
PLAT | STEEL/S235JR | 3373.67 | 27043.8 | 9305.1 | +3.246 | +3.502 | 258 | K71 | 2 | 2005 | S235JR | 3.01439 | 3.01439 | 0.000383999 | 0.0015 | 28.1714 | 0.0849198 | 255.999 | PLAT
PLAT | STEEL/S235JR | 3373.67 | 24512.5 | 9305.1 | +3.246 | +3.502 | 258 | K65 | 2 | 2005 | S235JR | 3.01439 | 3.01439 | 0.000383999 | 0.0015 | 28.1714 | 0.0849198 | 255.999 | PLAT
PLAT | STEEL/S235JR | 3550.24 | 37581.2 | 9284.9 | +3.425 | +3.675 | 259 | K83 | 2 | 2005 | S235JR | 2.9432 | 2.9432 | 0.00037493 | 0.0015 | 28.1955 | 0.0829851 | 249.953 | PLAT
PLAT | STEEL/S235JR | 4744.57 | -76.5 | 38362.5 | +4.740 | +4.750 | 201 | P114 | 3 | 3001 | S235JR | 3.37942 | 3.37943 | 0.0004305 | 0.04305 | 28.0639 | 0.09484 | 287 | PLAT
PLAT | STEEL/S235JR | 4744.57 | -76.5 | 61712.5 | +4.740 | +4.750 | 211 | P116 | 1 | 1001 | S235JR | 3.37942 | 3.37942 | 0.0004305 | 0.04305 | 28.0639 | 0.09484 | 287 | PLAT
PLAT | STEEL/S235JR | 4866.63 | -76.5 | 74420 | +4.862 | +4.872 | 211 | P117 | 1 | 1001 | S235JR | 3.37942 | 3.37942 | 0.0004305 | 0.04305 | 28.0639 | 0.09484 | 287 | PLAT
PLAT | STEEL/S235JR | 4744.57 | -76.5 | 50037.5 | +4.740 | +4.750 | 211 | P115 | 1 | 1001 | S235JR | 3.37942 | 3.37942 | 0.0004305 | 0.04305 | 28.0639 | 0.09484 | 287 | PLAT
PLAT | STEEL/S235JR | 4506.94 | -76.5 | 28633 | +4.502 | +4.512 | 201 | P121 | 3 | 3001 | S235JR | 3.37942 | 3.37942 | 0.0004305 | 0.04305 | 28.0639 | 0.09484 | 287 | PLAT
PLAT | STEEL/S235JR | 4982.2 | -76.5 | 24742 | +4.977 | +4.987 | 201 | P120 | 3 | 3001 | S235JR | 3.37942 | 3.37942 | 0.0004305 | 0.04305 | 28.0639 | 0.09484 | 287 | PLAT
 | STEEL/E24-2 | 4929.03 | 8.60725e-17 | 71049.6 | +4.911 | +4.947 | 246 | K28 | 1 | 1010 | E24-2 | 1.17752 | 1.17752 | 0.000150002 | 0 | 29.724 | 0.0350005 | 100.002
PLAT | STEEL/S235JR | 3550.24 | 21981.2 | 9284.9 | +3.425 | +3.675 | 259 | K78 | 2 | 2005 | S235JR | 2.9432 | 2.9432 | 0.00037493 | 0.0015 | 28.1955 | 0.0829851 | 249.953 | PLAT
PLAT | STEEL/S235JR | 3373.67 | 29575 | 9305.1 | +3.246 | +3.502 | 258 | K62 | 2 | 2005 | S235JR | 3.01439 | 3.01439 | 0.000383999 | 0.0015 | 28.1714 | 0.0849198 | 255.999 | PLAT
PLAT | STEEL/S235JR | 3550.24 | 29575 | 9284.9 | +3.425 | +3.675 | 259 | K84 | 2 | 2005 | S235JR | 2.9432 | 2.9432 | 0.00037493 | 0.0015 | 28.1955 | 0.0829851 | 249.953 | PLAT
PLAT | STEEL/S235JR | 3598.33 | 29575 | 20769 | +3.493 | +3.703 | 260 | K62 | 2 | 2005 | S235JR | 2.47278 | 2.47278 | 0.000315004 | 0.0015 | 28.3894 | 0.0702009 | 210.003 | PLAT
PLAT | STEEL/S235JR | 3598.33 | 34912.5 | 20769 | +3.493 | +3.703 | 260 | K61 | 2 | 2005 | S235JR | 2.47278 | 2.47278 | 0.000315004 | 0.0015 | 28.3894 | 0.0702009 | 210.003 | PLAT
PLAT | STEEL/S235JR | 3373.67 | 34912.5 | 9305.1 | +3.246 | +3.502 | 258 | K61 | 2 | 2005 | S235JR | 3.01439 | 3.01439 | 0.000383999 | 0.0015 | 28.1714 | 0.0849198 | 255.999 | PLAT
PLAT | STEEL/S235JR | 3550.24 | 34912.5 | 9284.9 | +3.425 | +3.675 | 259 | K85 | 2 | 2005 | S235JR | 2.9432 | 2.9432 | 0.00037493 | 0.0015 | 28.1955 | 0.0829851 | 249.953 | PLAT
PLAT | STEEL/S235JR | 3874.49 | 34912.5 | 9.3 | +3.750 | +3.999 | 261 | K85 | 2 | 2005 | S235JR | 2.9432 | 2.9432 | 0.00037493 | 0.0015 | 28.1955 | 0.0829851 | 249.953 | PLAT
 | STEEL/E24-2 | 3210.22 | -2200.07 | 24742.1 | +3.067 | +3.354 | 227 | K50 | 3 | 3003 | E24-2 | 3.38012 | 3.38012 | 0.000430589 | 0.0015 | 28.0638 | 0.094859 | 287.059
 | STEEL/E24-2 | 3210.22 | -2249.68 | 20850 | +3.067 | +3.354 | 227 | K94 | 3 | 3003 | E24-2 | 3.38012 | 3.38012 | 0.000430589 | 0.0015 | 28.0638 | 0.094859 | 287.059
 | STEEL/E24-2 | 3207.48 | -2064.86 | 28633.2 | +3.064 | +3.351 | 227 | K52 | 3 | 3003 | E24-2 | 3.38012 | 3.38012 | 0.000430589 | 0.0015 | 28.0638 | 0.094859 | 287.059
 | STEEL/E24-2 | 3193.42 | -1350.45 | 38363 | +3.050 | +3.337 | 227 | K51 | 3 | 3003 | E24-2 | 3.38012 | 3.38012 | 0.000430589 | 0.0015 | 28.0638 | 0.094859 | 287.059
 | STEEL/E24-2 | 3179.29 | -661.628 | 44200.7 | +3.036 | +3.323 | 227 | K20 | 3 | 3003 | E24-2 | 3.38012 | 3.38012 | 0.000430589 | 0.0015 | 28.0638 | 0.094859 | 287.059
 | STEEL/E24-2 | 3203.23 | -1843.73 | 32525.3 | +3.060 | +3.347 | 227 | K53 | 3 | 3003 | E24-2 | 3.38012 | 3.38012 | 0.000430589 | 0.0015 | 28.0638 | 0.094859 | 287.059

# IfcBeam: PL150*6 (11)
In: Undefined
Description: PL150*6; Material: STEEL/E24-2
Tekla Common - Finish: GRENAILLE-PEINT; Grade: E24-2; Profile: PL150*6; sets with these values: 2
Tekla Quantity - Height: 150 mm; Width: 6 mm; sets with these values: 2
Name | Center of gravity Z (mm) | Center of gravity Y (mm) | Center of gravity X (mm) | Bottom elevation | Top elevation | Part mark | Assembly mark | Phase | Class | Net weight (kg) = Gross weight (kg) = Weight (kg) = NetWeight (kg) | Net volume (m3) = Gross volume (m3) = NetVolume (m3) | Gross footprint area (m2) | Area per tons (m2) | Net surface area (m2) = Gross area (m2) = OuterSurfaceArea (m2) | Tekla Quantity, Length (mm) = BaseQuantities, Length (mm)
 | 3074 | 19620 | 74370 | +3.071 | +3.077 | 339 | M15 | 7 | 7001 | 0.4239 | 0.000054 | 0.009 | 48.4076 | 0.02052 | 60
 | 3068 | 19620 | 74370 | +3.065 | +3.071 | 341 | L113 | 7 | 7001 | 0.4239 | 0.000054 | 0.009 | 48.4076 | 0.02052 | 60
 | 3397 | 19620 | 74370 | +3.394 | +3.400 | 341 | M15 | 7 | 7001 | 0.4239 | 0.000054 | 0.009 | 48.4076 | 0.02052 | 60
 | 3435 | 19620 | 78092 | +3.405 | +3.465 | 339 | L114 | 7 | 7001 | 0.4239 | 0.000054 | 0.0009 | 48.4076 | 0.02052 | 60
 | 2997 | -145 | 22532 | +2.994 | +3.000 | 339 | M16 | 3 | 3003 | 0.4239 | 0.000054 | 0.009 | 48.4076 | 0.02052 | 60
 | 5753.06 | 69162 | 33089.6 | +5.738 | +5.768 | 327 | L106 | 3 | 3003 | 1.413 | 0.00018 | 0 | 45.4352 | 0.0642 | 200
 | 3035 | 19620 | 78092 | +3.005 | +3.065 | 339 | L113 | 7 | 7001 | 0.4239 | 0.000054 | 0.0009 | 48.4076 | 0.02052 | 60
 | 3068 | 19620 | 75060 | +3.065 | +3.071 | 339 | L113 | 7 | 7001 | 0.4239 | 0.000054 | 0.009 | 48.4076 | 0.02052 | 60
 | 3074 | 19620 | 75060 | +3.071 | +3.077 | 339 | M23 | 7 | 7001 | 0.4239 | 0.000054 | 0.009 | 48.4076 | 0.02052 | 60
 | 3397 | 19620 | 75060 | +3.394 | +3.400 | 339 | M23 | 7 | 7001 | 0.4239 | 0.000054 | 0.009 | 48.4076 | 0.02052 | 60
 | 2997 | 19620 | 75060 | +2.994 | +3.000 | 339 | P133 | 7 | 7001 | 0.4239 | 0.000054 | 0.009 | 48.4076 | 0.02052 | 60

# IfcBeam: PL160*10 (3)
In: Undefined
Description: PL160*10; Material: STEEL/E24-2
Tekla Common - Finish: GRENAILLE-PEINT; Grade: E24-2; Profile: PL160*10; sets with these values: 2
Tekla Quantity - Height: 160 mm; Width: 10 mm; sets with these values: 2
Name | Center of gravity Z (mm) | Center of gravity Y (mm) | Center of gravity X (mm) | Bottom elevation | Top elevation | Part mark | Assembly mark | Phase | Class | Net weight (kg) = Gross weight (kg) = Weight (kg) = NetWeight (kg) | Net volume (m3) = Gross volume (m3) = NetVolume (m3) | Gross footprint area (m2) | Area per tons (m2) | Net surface area (m2) = Gross area (m2) = OuterSurfaceArea (m2) | Tekla Quantity, Length (mm) = BaseQuantities, Length (mm) | Name
 | 3890.15 | 13530 | 75519.8 | +3.883 | +3.897 | 249 | M5 | 1 | 1007 | 1.7584 | 0.000224 | 0 | 28.8899 | 0.0508 | 140
PLAT | 3877.32 | 29575 | -9.3 | +3.752 | +4.002 | 238 | L53 | 5 | 5001 | 3.14 | 0.0004 | 0.0016 | 28.0892 | 0.0882 | 250 | PLAT
PLAT | 3872.32 | 32243.8 | -9.3 | +3.742 | +4.002 | 237 | L32 | 5 | 5001 | 3.2656 | 0.000416 | 0.0016 | 28.05 | 0.0916 | 260 | PLAT

# IfcBeam: PL160*12 (2)
In: Undefined
Description: PL160*12; Material: STEEL/S235JR
Tekla Common - Center of gravity Z: 3475 mm; Center of gravity X: -91.5 mm; Bottom elevation: +3.316; Top elevation: +3.634; Part mark: 1260; Assembly mark: E3; Phase: 4; Class: 4000; Finish: GALVANISE; Grade: S235JR; Profile: PL160*12; Name: SUPPORT; sets with these values: 2
Tekla Quantity - Net weight: 4.7929 kg; Gross weight: 4.7929 kg; Weight: 4.7929 kg; Net volume: 0.00061056 m3; Gross volume: 0.00061056 m3; Gross footprint area: 0.00192 m2; Area per tons: 23.625 m2; Net surface area: 0.113232 m2; Gross area: 0.113232 m2; Height: 160 mm; Width: 12 mm; Length: 318 mm; sets with these values: 2
BaseQuantities - Length: 318 mm; OuterSurfaceArea: 0.113232 m2; NetVolume: 0.00061056 m3; NetWeight: 4.7929 kg
Name | Center of gravity Y (mm)
SUPPORT | 40250
SUPPORT | 48525

# IfcBeam: PL160*20 (6)
In: Undefined
Description: PL160*20; Material: STEEL/E36-3
Tekla Common - Center of gravity Z: 3171.25 mm; Center of gravity Y: -235 mm; Bottom elevation: +3.028; Top elevation: +3.315; Part mark: 306; Phase: 3; Class: 3003; Finish: GRENAILLE-PEINT; Grade: E36-3; Profile: PL160*20; sets with these values: 2
Tekla Quantity - Net weight: 7.21093 kg; Gross weight: 7.21093 kg; Weight: 7.21093 kg; Net volume: 0.00091859 m3; Gross volume: 0.00091859 m3; Gross footprint area: 0.0032 m2; Area per tons: 15.2188 m2; Net surface area: 0.109741 m2; Gross area: 0.109741 m2; Height: 160 mm; Width: 20 mm; Length: 287.059 mm; sets with these values: 2
BaseQuantities - Length: 287.059 mm; OuterSurfaceArea: 0.109741 m2; NetVolume: 0.00091859 m3; NetWeight: 7.21093 kg
Name | Center of gravity X (mm) | Assembly mark
 | 44200 | K20
 | 38362.5 | K51
 | 32525 | K53
 | 28633 | K52
 | 24742 | K50
 | 20850 | K94

# IfcBeam: PL1620*200 (2)
In: Undefined
Description: PL1620*200; Material: CONCRETE/BETON COURANT
Tekla Common - Bottom elevation: +6.140; Top elevation: +7.760; Phase: 10; Class: 75; Grade: BETON COURANT; Profile: PL1620*200; Name: MACONNERIE; sets with these values: 2
Tekla Quantity - Height: 1620 mm; Width: 200 mm; sets with these values: 2
Name | Center of gravity Z (mm) | Center of gravity Y (mm) | Center of gravity X (mm) | Part mark = Assembly mark | Net weight (kg) = Weight (kg) = NetWeight (kg) | Gross weight (kg) | Net volume (m3) = NetVolume (m3) | Gross volume (m3) | Gross footprint area (m2) | Area per tons (m2) | Net surface area (m2) = OuterSurfaceArea (m2) | Gross area (m2) | Tekla Quantity, Length (mm) = BaseQuantities, Length (mm)
MACONNERIE | 6853.56 | 69455 | 26748.2 | Z44 | 7768.28 | 8957.47 | 3.69918 | 4.26546 | 1.06 | 5.52321 | 42.9058 | 48.5686 | 13165
MACONNERIE | 6950 | 68137.5 | 32825 | Z24 | 1928.93 | 1928.93 | 0.91854 | 0.91854 | 0.567 | 5.68573 | 10.9674 | 10.9674 | 2835

# IfcBeam: PL170*10 (2)
In: Undefined
Description: PL170*10; Material: STEEL/E24-2
Tekla Common - Center of gravity Y: 32450 mm; Assembly mark: K99; Phase: 1; Class: 1010; Finish: GRENAILLE-PEINT; Grade: E24-2; Profile: PL170*10; Name: PLAT; sets with these values: 2
Tekla Quantity - Gross footprint area: 0 m2; Height: 170 mm; Width: 10 mm; sets with these values: 2
Name | Center of gravity Z (mm) | Center of gravity X (mm) | Bottom elevation | Top elevation | Part mark | Net weight (kg) = Gross weight (kg) = Weight (kg) = NetWeight (kg) | Net volume (m3) = Gross volume (m3) = NetVolume (m3) | Area per tons (m2) | Net surface area (m2) = Gross area (m2) = OuterSurfaceArea (m2) | Tekla Quantity, Length (mm) = BaseQuantities, Length (mm)
PLAT | 5464.31 | 67785.6 | +5.432 | +5.496 | 252 | 0.840735 | 0.0001071 | 31.0205 | 0.02608 | 63
PLAT | 5500.73 | 67747.3 | +5.491 | +5.510 | 270 | 1.00087 | 0.0001275 | 30.3734 | 0.0304 | 75

# IfcBeam: PL170*6 (16)
In: Undefined
Description: PL170*6; Material: STEEL/E24-2
Tekla Common - Phase: 1; Class: 1003; Finish: GRENAILLE-PEINT; Grade: E24-2; Profile: PL170*6; sets with these values: 2
Tekla Quantity - Height: 170 mm; Width: 6 mm; sets with these values: 2
Name | Center of gravity Z (mm) | Center of gravity Y (mm) | Center of gravity X (mm) | Bottom elevation | Top elevation | Part mark | Assembly mark | Net weight (kg) = Gross weight (kg) = Weight (kg) = NetWeight (kg) | Net volume (m3) = Gross volume (m3) = NetVolume (m3) | Gross footprint area (m2) | Area per tons (m2) | Net surface area (m2) = Gross area (m2) = OuterSurfaceArea (m2) | Tekla Quantity, Length (mm) = BaseQuantities, Length (mm)
 | 2397 | 69285 | 57500 | +2.394 | +2.400 | 320 | P47 | 0.56049 | 0.0000714 | 0.0119 | 47.6012 | 0.02668 | 70
 | 2397 | -135 | 59830 | +2.394 | +2.400 | 320 | P45 | 0.56049 | 0.0000714 | 0.0119 | 47.6012 | 0.02668 | 70
 | 2397 | -135 | 57660 | +2.394 | +2.400 | 320 | P44 | 0.56049 | 0.0000714 | 0.0119 | 47.6012 | 0.02668 | 70
 | 2397 | 69285 | 60170 | +2.394 | +2.400 | 320 | P46 | 0.56049 | 0.0000714 | 0.0119 | 47.6012 | 0.02668 | 70
 | 2473 | 64435 | 79245 | +2.470 | +2.476 | 322 | L28 | 0.48042 | 0.0000612 | 0.0102 | 48.2078 | 0.02316 | 60
 | 2473 | 60960 | 79245 | +2.470 | +2.476 | 322 | L27 | 0.48042 | 0.0000612 | 0.0102 | 48.2078 | 0.02316 | 60
 | 3509 | 69285 | 70050 | +3.506 | +3.512 | 320 | P42 | 0.56049 | 0.0000714 | 0.0119 | 47.6012 | 0.02668 | 70
 | 3509 | 69285 | 71520 | +3.506 | +3.512 | 320 | P43 | 0.56049 | 0.0000714 | 0.0119 | 47.6012 | 0.02668 | 70
 | 2435 | 69285 | 71482 | +2.400 | +2.470 | 320 | L25 | 0.56049 | 0.0000714 | 0.00102 | 47.6012 | 0.02668 | 70
 | 2435 | 69285 | 70088 | +2.400 | +2.470 | 320 | L25 | 0.56049 | 0.0000714 | 0.00102 | 47.6012 | 0.02668 | 70
 | 2397 | 64270 | 79245 | +2.394 | +2.400 | 320 | P51 | 0.56049 | 0.0000714 | 0.0119 | 47.6012 | 0.02668 | 70
 | 2473 | 61140 | 79245 | +2.470 | +2.476 | 322 | L28 | 0.48042 | 0.0000612 | 0.0102 | 48.2078 | 0.02316 | 60
 | 2397 | 61600 | 79245 | +2.394 | +2.400 | 320 | P50 | 0.56049 | 0.0000714 | 0.0119 | 47.6012 | 0.02668 | 70
 | 2435 | 66632 | 79245 | +2.400 | +2.470 | 320 | L26 | 0.56049 | 0.0000714 | 0.00102 | 47.6012 | 0.02668 | 70
 | 2435 | 59948 | 79245 | +2.400 | +2.470 | 320 | L27 | 0.56049 | 0.0000714 | 0.00102 | 47.6012 | 0.02668 | 70
 | 2473 | 64615 | 79245 | +2.470 | +2.476 | 322 | L26 | 0.48042 | 0.0000612 | 0.0102 | 48.2078 | 0.02316 | 60

# IfcBeam: PL1760*400, MACONNERIE
In: Undefined
Description: PL1760*400; Material: CONCRETE/BETON COURANT
Tekla Common - Center of gravity Z: 5080 mm; Center of gravity Y: 61050 mm; Center of gravity X: 30185 mm; Bottom elevation: +4.200; Top elevation: +5.960; Part mark: Z80; Assembly mark: Z80; Phase: 10; Class: 72; Grade: BETON COURANT; Profile: PL1760*400; Name: MACONNERIE; sets with these values: 2
Tekla Quantity - Net weight: 5144.83 kg; Gross weight: 5144.83 kg; Weight: 5144.83 kg; Net volume: 2.44992 m3; Gross volume: 2.44992 m3; Gross footprint area: 1.392 m2; Area per tons: 3.19575 m2; Net surface area: 16.4416 m2; Gross area: 16.4416 m2; Height: 1760 mm; Width: 400 mm; Length: 3480 mm; sets with these values: 2
BaseQuantities - Length: 3480 mm; OuterSurfaceArea: 16.4416 m2; NetVolume: 2.44992 m3; NetWeight: 5144.83 kg

# IfcBeam: PL180*12 (8)
In: Undefined
Description: PL180*12; Material: STEEL/E24-2
Tekla Common - Assembly mark: B18; Phase: 2; Class: 2002; Finish: GRENAILLE-PEINT; Grade: E24-2; Profile: PL180*12; Name: ATTACHE; sets with these values: 2
Tekla Quantity - Gross footprint area: 0 m2; Height: 180 mm; Width: 12 mm; sets with these values: 2
Name | Center of gravity Z (mm) | Center of gravity Y (mm) | Center of gravity X (mm) | Bottom elevation | Top elevation | Part mark | Net weight (kg) = Gross weight (kg) = Weight (kg) = NetWeight (kg) | Net volume (m3) = Gross volume (m3) = NetVolume (m3) | Area per tons (m2) | Net surface area (m2) = Gross area (m2) = OuterSurfaceArea (m2) | Tekla Quantity, Length (mm) = BaseQuantities, Length (mm)
ATTACHE | 2954.81 | 48513 | 10104 | +2.848 | +3.061 | 1267 | 2.28906 | 0.0002916 | 24.5341 | 0.05616 | 135
ATTACHE | -254.478 | 10942 | 20095 | -0.361 | -0.148 | 1267 | 2.28906 | 0.0002916 | 24.5341 | 0.05616 | 135
ATTACHE | -232 | 10942 | 20025 | -0.320 | -0.144 | 1268 | 3.05208 | 0.0003888 | 24.0623 | 0.07344 | 180
ATTACHE | 2932.33 | 10942 | 10174 | +2.845 | +3.020 | 1268 | 3.05208 | 0.0003888 | 24.0623 | 0.07344 | 180
ATTACHE | 2954.81 | 10942 | 10104 | +2.848 | +3.061 | 1267 | 2.28906 | 0.0002916 | 24.5341 | 0.05616 | 135
ATTACHE | 2932.33 | 48513 | 10174 | +2.845 | +3.020 | 1268 | 3.05208 | 0.0003888 | 24.0623 | 0.07344 | 180
ATTACHE | -232 | 48513 | 20025 | -0.320 | -0.144 | 1268 | 3.05208 | 0.0003888 | 24.0623 | 0.07344 | 180
ATTACHE | -254.478 | 48513 | 20095 | -0.361 | -0.148 | 1267 | 2.28906 | 0.0002916 | 24.5341 | 0.05616 | 135

# IfcBeam: PL2*240 (8)
In: Undefined
Description: PL2*240; Material: STEEL/S235JR
Tekla Common - Part mark: Y8; Assembly mark: Y8; Phase: 1; Class: 1008; Finish: GALVANISE; Grade: S235JR; Profile: PL2*240; Name: CALE; sets with these values: 2
Tekla Quantity - Net weight: 1.28112 kg; Gross weight: 1.28112 kg; Weight: 1.28112 kg; Net volume: 0.0001632 m3; Gross volume: 0.0001632 m3; Gross footprint area: 0 m2; Area per tons: 129.199 m2; Net surface area: 0.16552 m2; Gross area: 0.16552 m2; Height: 240 mm; Width: 2 mm; Length: 340 mm; sets with these values: 2
BaseQuantities - Length: 340 mm; OuterSurfaceArea: 0.16552 m2; NetVolume: 0.0001632 m3; NetWeight: 1.28112 kg
Name | Center of gravity Z (mm) | Center of gravity Y (mm) | Center of gravity X (mm) | Bottom elevation | Top elevation
CALE | 3840.16 | 18227 | 77003.7 | +3.835 | +3.845
CALE | 3810.99 | 18227 | 77944.7 | +3.806 | +3.816
CALE | 3938.55 | 20847 | 73829.7 | +3.934 | +3.943
CALE | 3876.76 | 20847 | 75823.7 | +3.872 | +3.881
CALE | 3840.16 | 22320 | 77003.7 | +3.835 | +3.845
CALE | 3810.99 | 22320 | 77944.7 | +3.806 | +3.816
CALE | 3938.55 | 24940 | 73829.7 | +3.934 | +3.943
CALE | 3876.76 | 24940 | 75823.7 | +3.872 | +3.881

# IfcBeam: PL2*250 (4)
In: Undefined
Description: PL2*250; Material: STEEL/S235JR
Tekla Common - Part mark: Y9; Assembly mark: Y9; Phase: 1; Class: 1008; Finish: GALVANISE; Grade: S235JR; Profile: PL2*250; Name: CALE; sets with these values: 2
Tekla Quantity - Net weight: 1.3345 kg; Gross weight: 1.3345 kg; Weight: 1.3345 kg; Net volume: 0.00017 m3; Gross volume: 0.00017 m3; Gross footprint area: 0 m2; Area per tons: 129.157 m2; Net surface area: 0.17236 m2; Gross area: 0.17236 m2; Height: 250 mm; Width: 2 mm; Length: 340 mm; sets with these values: 2
BaseQuantities - Length: 340 mm; OuterSurfaceArea: 0.17236 m2; NetVolume: 0.00017 m3; NetWeight: 1.3345 kg
Name | Center of gravity Z (mm) | Center of gravity Y (mm) | Center of gravity X (mm) | Bottom elevation | Top elevation
CALE | 3876.76 | 19800 | 75823.7 | +3.870 | +3.883
CALE | 3938.55 | 19800 | 73829.7 | +3.932 | +3.945
CALE | 3876.76 | 15633.3 | 75823.7 | +3.870 | +3.883
CALE | 3938.55 | 15633.3 | 73829.7 | +3.932 | +3.945

# IfcBeam: PL2*340 (171)
In: Undefined
Description: PL2*340; Material: STEEL/S235JR
Tekla Common - Finish: GALVANISE; Grade: S235JR; Profile: PL2*340; Name: CALE; sets with these values: 2
Tekla Quantity - Gross footprint area: 0 m2; Height: 340 mm; Width: 2 mm; sets with these values: 2
Name | Center of gravity Z (mm) | Center of gravity Y (mm) | Center of gravity X (mm) | Bottom elevation | Top elevation | Part mark = Assembly mark | Phase | Class | Net weight (kg) = Gross weight (kg) = Weight (kg) = NetWeight (kg) | Net volume (m3) = Gross volume (m3) = NetVolume (m3) | Area per tons (m2) | Net surface area (m2) = Gross area (m2) = OuterSurfaceArea (m2) | Tekla Quantity, Length (mm) = BaseQuantities, Length (mm)
CALE | 10569 | 50520 | 20359.8 | +10.564 | +10.574 | Y7 | 2 | 2007 | 1.25977 | 0.00016048 | 129.217 | 0.162784 | 236
CALE | 10481.2 | 50630 | 23190.8 | +10.477 | +10.486 | Y7 | 2 | 2007 | 1.25977 | 0.00016048 | 129.217 | 0.162784 | 236
CALE | 10393.5 | 50520 | 26018.8 | +10.389 | +10.398 | Y7 | 2 | 2007 | 1.25977 | 0.00016048 | 129.217 | 0.162784 | 236
CALE | 10569 | 52690 | 20359.7 | +10.563 | +10.575 | Y6 | 2 | 2007 | 1.44126 | 0.0001836 | 129.081 | 0.18604 | 270
CALE | 10569 | 55455 | 20359.7 | +10.563 | +10.575 | Y6 | 2 | 2007 | 1.44126 | 0.0001836 | 129.081 | 0.18604 | 270
CALE | 10569 | 58220 | 20359.7 | +10.563 | +10.575 | Y6 | 2 | 2007 | 1.44126 | 0.0001836 | 129.081 | 0.18604 | 270
CALE | 10569 | 60985 | 20359.7 | +10.563 | +10.575 | Y6 | 2 | 2007 | 1.44126 | 0.0001836 | 129.081 | 0.18604 | 270
CALE | 3841.78 | 40250 | 5691.35 | +3.835 | +3.849 | Y6 | 2 | 2007 | 1.44126 | 0.0001836 | 129.081 | 0.18604 | 270
CALE | 4027.18 | 40250 | 394.683 | +4.020 | +4.034 | Y6 | 2 | 2007 | 1.44126 | 0.0001836 | 129.081 | 0.18604 | 270
CALE | 3749.09 | 40250 | 8339.68 | +3.742 | +3.756 | Y6 | 2 | 2007 | 1.44126 | 0.0001836 | 129.081 | 0.18604 | 270
CALE | 3841.78 | 37581.2 | 5691.35 | +3.835 | +3.849 | Y6 | 2 | 2007 | 1.44126 | 0.0001836 | 129.081 | 0.18604 | 270
CALE | 4027.18 | 37581.2 | 394.683 | +4.020 | +4.034 | Y6 | 2 | 2007 | 1.44126 | 0.0001836 | 129.081 | 0.18604 | 270
CALE | 3749.09 | 37581.2 | 8339.68 | +3.742 | +3.756 | Y6 | 2 | 2007 | 1.44126 | 0.0001836 | 129.081 | 0.18604 | 270
CALE | 3841.78 | 34912.5 | 5691.35 | +3.835 | +3.849 | Y6 | 2 | 2007 | 1.44126 | 0.0001836 | 129.081 | 0.18604 | 270
CALE | 4027.18 | 34912.5 | 394.683 | +4.020 | +4.034 | Y6 | 2 | 2007 | 1.44126 | 0.0001836 | 129.081 | 0.18604 | 270
CALE | 3749.09 | 34912.5 | 8339.68 | +3.742 | +3.756 | Y6 | 2 | 2007 | 1.44126 | 0.0001836 | 129.081 | 0.18604 | 270
CALE | 3749.09 | 32243.7 | 8339.68 | +3.742 | +3.756 | Y6 | 2 | 2007 | 1.44126 | 0.0001836 | 129.081 | 0.18604 | 270
CALE | 4027.18 | 32243.7 | 394.683 | +4.020 | +4.034 | Y6 | 2 | 2007 | 1.44126 | 0.0001836 | 129.081 | 0.18604 | 270
CALE | 3841.78 | 32243.7 | 5691.35 | +3.835 | +3.849 | Y6 | 2 | 2007 | 1.44126 | 0.0001836 | 129.081 | 0.18604 | 270
CALE | 3749.09 | 29575 | 8339.68 | +3.742 | +3.756 | Y6 | 2 | 2007 | 1.44126 | 0.0001836 | 129.081 | 0.18604 | 270
CALE | 3841.78 | 29575 | 5691.35 | +3.835 | +3.849 | Y6 | 2 | 2007 | 1.44126 | 0.0001836 | 129.081 | 0.18604 | 270
CALE | 4027.18 | 29575 | 394.683 | +4.020 | +4.034 | Y6 | 2 | 2007 | 1.44126 | 0.0001836 | 129.081 | 0.18604 | 270
CALE | 3749.09 | 27043.7 | 8339.68 | +3.742 | +3.756 | Y6 | 2 | 2007 | 1.44126 | 0.0001836 | 129.081 | 0.18604 | 270
CALE | 3841.78 | 27043.7 | 5691.35 | +3.835 | +3.849 | Y6 | 2 | 2007 | 1.44126 | 0.0001836 | 129.081 | 0.18604 | 270
CALE | 4027.18 | 27043.7 | 394.683 | +4.020 | +4.034 | Y6 | 2 | 2007 | 1.44126 | 0.0001836 | 129.081 | 0.18604 | 270
CALE | 3749.09 | 24512.5 | 8339.68 | +3.742 | +3.756 | Y6 | 2 | 2007 | 1.44126 | 0.0001836 | 129.081 | 0.18604 | 270
CALE | 3841.78 | 24512.5 | 5691.35 | +3.835 | +3.849 | Y6 | 2 | 2007 | 1.44126 | 0.0001836 | 129.081 | 0.18604 | 270
CALE | 4027.18 | 24512.5 | 394.683 | +4.020 | +4.034 | Y6 | 2 | 2007 | 1.44126 | 0.0001836 | 129.081 | 0.18604 | 270
CALE | 3749.09 | 21981.2 | 8339.68 | +3.742 | +3.756 | Y6 | 2 | 2007 | 1.44126 | 0.0001836 | 129.081 | 0.18604 | 270
CALE | 4027.18 | 21981.2 | 394.683 | +4.020 | +4.034 | Y6 | 2 | 2007 | 1.44126 | 0.0001836 | 129.081 | 0.18604 | 270
CALE | 3841.78 | 21981.2 | 5691.35 | +3.835 | +3.849 | Y6 | 2 | 2007 | 1.44126 | 0.0001836 | 129.081 | 0.18604 | 270
CALE | 4027.18 | 19450 | 394.683 | +4.020 | +4.034 | Y6 | 2 | 2007 | 1.44126 | 0.0001836 | 129.081 | 0.18604 | 270
CALE | 3841.78 | 19450 | 5691.35 | +3.835 | +3.849 | Y6 | 2 | 2007 | 1.44126 | 0.0001836 | 129.081 | 0.18604 | 270
CALE | 3749.09 | 19450 | 8339.68 | +3.742 | +3.756 | Y6 | 2 | 2007 | 1.44126 | 0.0001836 | 129.081 | 0.18604 | 270
CALE | 4027.18 | 17320 | 394.683 | +4.020 | +4.034 | Y6 | 2 | 2007 | 1.44126 | 0.0001836 | 129.081 | 0.18604 | 270
CALE | 3841.78 | 17320 | 5691.35 | +3.835 | +3.849 | Y6 | 2 | 2007 | 1.44126 | 0.0001836 | 129.081 | 0.18604 | 270
CALE | 3749.09 | 17320 | 8339.68 | +3.742 | +3.756 | Y6 | 2 | 2007 | 1.44126 | 0.0001836 | 129.081 | 0.18604 | 270
CALE | 4027.18 | 15190 | 394.683 | +4.020 | +4.034 | Y6 | 2 | 2007 | 1.44126 | 0.0001836 | 129.081 | 0.18604 | 270
CALE | 3841.78 | 15190 | 5691.35 | +3.835 | +3.849 | Y6 | 2 | 2007 | 1.44126 | 0.0001836 | 129.081 | 0.18604 | 270
CALE | 3749.09 | 15190 | 8339.68 | +3.742 | +3.756 | Y6 | 2 | 2007 | 1.44126 | 0.0001836 | 129.081 | 0.18604 | 270
CALE | 3841.78 | 13060 | 5691.35 | +3.835 | +3.849 | Y6 | 2 | 2007 | 1.44126 | 0.0001836 | 129.081 | 0.18604 | 270
CALE | 3841.78 | 10930 | 5691.35 | +3.835 | +3.849 | Y6 | 2 | 2007 | 1.44126 | 0.0001836 | 129.081 | 0.18604 | 270
CALE | 4020.53 | 10930 | 584.683 | +4.014 | +4.027 | Y6 | 2 | 2007 | 1.44126 | 0.0001836 | 129.081 | 0.18604 | 270
CALE | 4027.18 | 13060 | 394.683 | +4.020 | +4.034 | Y6 | 2 | 2007 | 1.44126 | 0.0001836 | 129.081 | 0.18604 | 270
CALE | 3749.09 | 13060 | 8339.68 | +3.742 | +3.756 | Y6 | 2 | 2007 | 1.44126 | 0.0001836 | 129.081 | 0.18604 | 270
CALE | 3749.09 | 10930 | 8339.68 | +3.742 | +3.756 | Y6 | 2 | 2007 | 1.44126 | 0.0001836 | 129.081 | 0.18604 | 270
CALE | 5407.24 | 26895 | 78044.8 | +5.404 | +5.411 | Y7 | 1 | 1008 | 1.25977 | 0.00016048 | 129.217 | 0.162784 | 236
CALE | 5460.97 | 26895 | 75358.5 | +5.458 | +5.464 | Y7 | 1 | 1008 | 1.25977 | 0.00016048 | 129.217 | 0.162784 | 236
CALE | 5410.66 | 32660 | 70900.9 | +5.395 | +5.426 | Y7 | 1 | 1008 | 1.25977 | 0.00016048 | 129.217 | 0.162784 | 236
CALE | 5514.96 | 31395 | 72658.5 | +5.512 | +5.518 | Y7 | 1 | 1008 | 1.25977 | 0.00016048 | 129.217 | 0.162784 | 236
CALE | 5514.96 | 30545 | 72658.5 | +5.511 | +5.519 | Y6 | 1 | 1008 | 1.44126 | 0.0001836 | 129.081 | 0.18604 | 270
CALE | 5514.96 | 27745 | 72658.5 | +5.511 | +5.519 | Y6 | 1 | 1008 | 1.44126 | 0.0001836 | 129.081 | 0.18604 | 270
CALE | 5410.66 | 24650 | 70900.9 | +5.389 | +5.432 | Y6 | 1 | 1008 | 1.44126 | 0.0001836 | 129.081 | 0.18604 | 270
CALE | 5423.17 | 18660 | 68124.8 | +5.419 | +5.428 | Y7 | 1 | 1008 | 1.25977 | 0.00016048 | 129.217 | 0.162784 | 236
CALE | 5346.44 | 18660 | 70599.8 | +5.342 | +5.351 | Y7 | 1 | 1008 | 1.25977 | 0.00016048 | 129.217 | 0.162784 | 236
CALE | 5410.66 | 19950 | 70900.9 | +5.395 | +5.426 | Y7 | 1 | 1008 | 1.25977 | 0.00016048 | 129.217 | 0.162784 | 236
CALE | 5346.45 | 17090 | 70599.8 | +5.340 | +5.353 | Y6 | 1 | 1008 | 1.44126 | 0.0001836 | 129.081 | 0.18604 | 270
CALE | 5423.17 | 17090 | 68124.8 | +5.417 | +5.429 | Y6 | 1 | 1008 | 1.44126 | 0.0001836 | 129.081 | 0.18604 | 270
CALE | 5346.45 | 14730 | 70599.8 | +5.340 | +5.353 | Y6 | 1 | 1008 | 1.44126 | 0.0001836 | 129.081 | 0.18604 | 270
CALE | 5514.96 | 26895 | 72658.5 | +5.512 | +5.518 | Y7 | 1 | 1008 | 1.25977 | 0.00016048 | 129.217 | 0.162784 | 236
CALE | 5269.73 | 2550 | 73074.8 | +5.263 | +5.276 | Y6 | 1 | 1008 | 1.44126 | 0.0001836 | 129.081 | 0.18604 | 270
CALE | 5423.17 | 14730 | 68124.8 | +5.417 | +5.429 | Y6 | 1 | 1008 | 1.44126 | 0.0001836 | 129.081 | 0.18604 | 270
CALE | 5423.17 | 649.998 | 68124.8 | +5.419 | +5.428 | Y7 | 1 | 1008 | 1.25977 | 0.00016048 | 129.217 | 0.162784 | 236
CALE | 5346.45 | 2550 | 70599.8 | +5.340 | +5.353 | Y6 | 1 | 1008 | 1.44126 | 0.0001836 | 129.081 | 0.18604 | 270
CALE | 5193 | 5100 | 75549.8 | +5.187 | +5.199 | Y6 | 1 | 1008 | 1.44126 | 0.0001836 | 129.081 | 0.18604 | 270
CALE | 5423.17 | 2550 | 68124.8 | +5.417 | +5.429 | Y6 | 1 | 1008 | 1.44126 | 0.0001836 | 129.081 | 0.18604 | 270
CALE | 5269.73 | 5100 | 73074.8 | +5.263 | +5.276 | Y6 | 1 | 1008 | 1.44126 | 0.0001836 | 129.081 | 0.18604 | 270
CALE | 5193 | 2550 | 75549.8 | +5.187 | +5.199 | Y6 | 1 | 1008 | 1.44126 | 0.0001836 | 129.081 | 0.18604 | 270
CALE | 5116.27 | 5100 | 78024.8 | +5.110 | +5.123 | Y6 | 1 | 1008 | 1.44126 | 0.0001836 | 129.081 | 0.18604 | 270
CALE | 5346.45 | 5100 | 70599.8 | +5.340 | +5.353 | Y6 | 1 | 1008 | 1.44126 | 0.0001836 | 129.081 | 0.18604 | 270
CALE | 5116.27 | 2550 | 78024.8 | +5.110 | +5.123 | Y6 | 1 | 1008 | 1.44126 | 0.0001836 | 129.081 | 0.18604 | 270
CALE | 5423.17 | 5100 | 68124.8 | +5.417 | +5.429 | Y6 | 1 | 1008 | 1.44126 | 0.0001836 | 129.081 | 0.18604 | 270
CALE | 5423.17 | 7650 | 68124.8 | +5.417 | +5.429 | Y6 | 1 | 1008 | 1.44126 | 0.0001836 | 129.081 | 0.18604 | 270
CALE | 5346.45 | 7650 | 70599.8 | +5.340 | +5.353 | Y6 | 1 | 1008 | 1.44126 | 0.0001836 | 129.081 | 0.18604 | 270
CALE | 5269.73 | 7650 | 73074.8 | +5.263 | +5.276 | Y6 | 1 | 1008 | 1.44126 | 0.0001836 | 129.081 | 0.18604 | 270
CALE | 5193 | 7650 | 75549.8 | +5.187 | +5.199 | Y6 | 1 | 1008 | 1.44126 | 0.0001836 | 129.081 | 0.18604 | 270
CALE | 5116.27 | 7650 | 78024.8 | +5.110 | +5.123 | Y6 | 1 | 1008 | 1.44126 | 0.0001836 | 129.081 | 0.18604 | 270
CALE | 5346.44 | 649.998 | 70599.8 | +5.342 | +5.351 | Y7 | 1 | 1008 | 1.25977 | 0.00016048 | 129.217 | 0.162784 | 236
CALE | 5423.17 | 10010 | 68124.8 | +5.417 | +5.429 | Y6 | 1 | 1008 | 1.44126 | 0.0001836 | 129.081 | 0.18604 | 270
CALE | 5346.45 | 10010 | 70599.8 | +5.340 | +5.353 | Y6 | 1 | 1008 | 1.44126 | 0.0001836 | 129.081 | 0.18604 | 270
CALE | 5269.73 | 10010 | 73074.8 | +5.263 | +5.276 | Y6 | 1 | 1008 | 1.44126 | 0.0001836 | 129.081 | 0.18604 | 270
CALE | 5193 | 10010 | 75549.8 | +5.187 | +5.199 | Y6 | 1 | 1008 | 1.44126 | 0.0001836 | 129.081 | 0.18604 | 270
CALE | 5116.27 | 10010 | 78024.8 | +5.110 | +5.123 | Y6 | 1 | 1008 | 1.44126 | 0.0001836 | 129.081 | 0.18604 | 270
CALE | 5269.72 | 649.998 | 73074.8 | +5.265 | +5.274 | Y7 | 1 | 1008 | 1.25977 | 0.00016048 | 129.217 | 0.162784 | 236
CALE | 5423.17 | 12370 | 68124.8 | +5.417 | +5.429 | Y6 | 1 | 1008 | 1.44126 | 0.0001836 | 129.081 | 0.18604 | 270
CALE | 5346.45 | 12370 | 70599.8 | +5.340 | +5.353 | Y6 | 1 | 1008 | 1.44126 | 0.0001836 | 129.081 | 0.18604 | 270
CALE | 5269.73 | 12370 | 73074.8 | +5.263 | +5.276 | Y6 | 1 | 1008 | 1.44126 | 0.0001836 | 129.081 | 0.18604 | 270
CALE | 5193 | 12370 | 75549.8 | +5.187 | +5.199 | Y6 | 1 | 1008 | 1.44126 | 0.0001836 | 129.081 | 0.18604 | 270
CALE | 5116.27 | 12370 | 78024.8 | +5.110 | +5.123 | Y6 | 1 | 1008 | 1.44126 | 0.0001836 | 129.081 | 0.18604 | 270
CALE | 5192.99 | 649.998 | 75549.8 | +5.188 | +5.198 | Y7 | 1 | 1008 | 1.25977 | 0.00016048 | 129.217 | 0.162784 | 236
CALE | 5116.27 | 649.998 | 78024.8 | +5.112 | +5.121 | Y7 | 1 | 1008 | 1.25977 | 0.00016048 | 129.217 | 0.162784 | 236
CALE | 5410.66 | 22050 | 70900.9 | +5.389 | +5.432 | Y6 | 1 | 1008 | 1.44126 | 0.0001836 | 129.081 | 0.18604 | 270
CALE | 5410.66 | 26545 | 70900.9 | +5.395 | +5.426 | Y7 | 1 | 1008 | 1.25977 | 0.00016048 | 129.217 | 0.162784 | 236
CALE | 5514.96 | 29145 | 72658.5 | +5.511 | +5.519 | Y6 | 1 | 1008 | 1.44126 | 0.0001836 | 129.081 | 0.18604 | 270
CALE | 5460.97 | 31395 | 75358.5 | +5.458 | +5.464 | Y7 | 1 | 1008 | 1.25977 | 0.00016048 | 129.217 | 0.162784 | 236
CALE | 5460.97 | 30545 | 75358.5 | +5.457 | +5.465 | Y6 | 1 | 1008 | 1.44126 | 0.0001836 | 129.081 | 0.18604 | 270
CALE | 5460.97 | 29145 | 75358.5 | +5.457 | +5.465 | Y6 | 1 | 1008 | 1.44126 | 0.0001836 | 129.081 | 0.18604 | 270
CALE | 5460.97 | 27745 | 75358.5 | +5.457 | +5.465 | Y6 | 1 | 1008 | 1.44126 | 0.0001836 | 129.081 | 0.18604 | 270
CALE | 5407.24 | 31395 | 78044.8 | +5.404 | +5.411 | Y7 | 1 | 1008 | 1.25977 | 0.00016048 | 129.217 | 0.162784 | 236
CALE | 5407.24 | 30545 | 78044.8 | +5.403 | +5.412 | Y6 | 1 | 1008 | 1.44126 | 0.0001836 | 129.081 | 0.18604 | 270
CALE | 5407.24 | 29145 | 78044.8 | +5.403 | +5.412 | Y6 | 1 | 1008 | 1.44126 | 0.0001836 | 129.081 | 0.18604 | 270
CALE | 5407.24 | 27745 | 78044.8 | +5.403 | +5.412 | Y6 | 1 | 1008 | 1.44126 | 0.0001836 | 129.081 | 0.18604 | 270
CALE | 3841.78 | 43008.3 | 5691.35 | +3.835 | +3.849 | Y6 | 2 | 2007 | 1.44126 | 0.0001836 | 129.081 | 0.18604 | 270
CALE | 4027.18 | 43008.3 | 394.683 | +4.020 | +4.034 | Y6 | 2 | 2007 | 1.44126 | 0.0001836 | 129.081 | 0.18604 | 270
CALE | 3749.09 | 43008.3 | 8339.68 | +3.742 | +3.756 | Y6 | 2 | 2007 | 1.44126 | 0.0001836 | 129.081 | 0.18604 | 270
CALE | 3841.78 | 45766.7 | 5691.35 | +3.835 | +3.849 | Y6 | 2 | 2007 | 1.44126 | 0.0001836 | 129.081 | 0.18604 | 270
CALE | 4027.18 | 45766.7 | 394.683 | +4.020 | +4.034 | Y6 | 2 | 2007 | 1.44126 | 0.0001836 | 129.081 | 0.18604 | 270
CALE | 3749.09 | 45766.7 | 8339.68 | +3.742 | +3.756 | Y6 | 2 | 2007 | 1.44126 | 0.0001836 | 129.081 | 0.18604 | 270
CALE | 3749.09 | 48525 | 8339.68 | +3.742 | +3.756 | Y6 | 2 | 2007 | 1.44126 | 0.0001836 | 129.081 | 0.18604 | 270
CALE | 3841.78 | 48525 | 5691.35 | +3.835 | +3.849 | Y6 | 2 | 2007 | 1.44126 | 0.0001836 | 129.081 | 0.18604 | 270
CALE | 4020.53 | 48525 | 584.683 | +4.014 | +4.027 | Y6 | 2 | 2007 | 1.44126 | 0.0001836 | 129.081 | 0.18604 | 270
CALE | 10481.2 | 65860 | 23190.8 | +10.477 | +10.486 | Y7 | 2 | 2007 | 1.25977 | 0.00016048 | 129.217 | 0.162784 | 236
CALE | 10569 | 65970 | 20359.8 | +10.564 | +10.574 | Y7 | 2 | 2007 | 1.25977 | 0.00016048 | 129.217 | 0.162784 | 236
CALE | 10218.2 | 65970 | 31674.8 | +10.214 | +10.223 | Y7 | 2 | 2007 | 1.25977 | 0.00016048 | 129.217 | 0.162784 | 236
CALE | 10393.5 | 65970 | 26018.8 | +10.389 | +10.398 | Y7 | 2 | 2007 | 1.25977 | 0.00016048 | 129.217 | 0.162784 | 236
CALE | 10305.8 | 65970 | 28846.8 | +10.301 | +10.310 | Y7 | 2 | 2007 | 1.25977 | 0.00016048 | 129.217 | 0.162784 | 236
CALE | 10569 | 63750 | 20359.7 | +10.563 | +10.575 | Y6 | 2 | 2007 | 1.44126 | 0.0001836 | 129.081 | 0.18604 | 270
CALE | 10481.2 | 63750 | 23190.7 | +10.475 | +10.487 | Y6 | 2 | 2007 | 1.44126 | 0.0001836 | 129.081 | 0.18604 | 270
CALE | 10393.5 | 63750 | 26018.7 | +10.387 | +10.400 | Y6 | 2 | 2007 | 1.44126 | 0.0001836 | 129.081 | 0.18604 | 270
CALE | 10305.9 | 63750 | 28846.7 | +10.300 | +10.312 | Y6 | 2 | 2007 | 1.44126 | 0.0001836 | 129.081 | 0.18604 | 270
CALE | 10218.2 | 63750 | 31674.7 | +10.212 | +10.224 | Y6 | 2 | 2007 | 1.44126 | 0.0001836 | 129.081 | 0.18604 | 270
CALE | 10218.2 | 60985 | 31674.7 | +10.212 | +10.224 | Y6 | 2 | 2007 | 1.44126 | 0.0001836 | 129.081 | 0.18604 | 270
CALE | 10305.9 | 60985 | 28846.7 | +10.300 | +10.312 | Y6 | 2 | 2007 | 1.44126 | 0.0001836 | 129.081 | 0.18604 | 270
CALE | 10393.5 | 60985 | 26018.7 | +10.387 | +10.400 | Y6 | 2 | 2007 | 1.44126 | 0.0001836 | 129.081 | 0.18604 | 270
CALE | 10481.2 | 60985 | 23190.7 | +10.475 | +10.487 | Y6 | 2 | 2007 | 1.44126 | 0.0001836 | 129.081 | 0.18604 | 270
CALE | 10218.2 | 58220 | 31674.7 | +10.212 | +10.224 | Y6 | 2 | 2007 | 1.44126 | 0.0001836 | 129.081 | 0.18604 | 270
CALE | 10305.9 | 58220 | 28846.7 | +10.300 | +10.312 | Y6 | 2 | 2007 | 1.44126 | 0.0001836 | 129.081 | 0.18604 | 270
CALE | 10393.5 | 58220 | 26018.7 | +10.387 | +10.400 | Y6 | 2 | 2007 | 1.44126 | 0.0001836 | 129.081 | 0.18604 | 270
CALE | 10481.2 | 58220 | 23190.7 | +10.475 | +10.487 | Y6 | 2 | 2007 | 1.44126 | 0.0001836 | 129.081 | 0.18604 | 270
CALE | 10218.2 | 55455 | 31674.7 | +10.212 | +10.224 | Y6 | 2 | 2007 | 1.44126 | 0.0001836 | 129.081 | 0.18604 | 270
CALE | 10305.9 | 55455 | 28846.7 | +10.300 | +10.312 | Y6 | 2 | 2007 | 1.44126 | 0.0001836 | 129.081 | 0.18604 | 270
CALE | 10393.5 | 55455 | 26018.7 | +10.387 | +10.400 | Y6 | 2 | 2007 | 1.44126 | 0.0001836 | 129.081 | 0.18604 | 270
CALE | 10481.2 | 55455 | 23190.7 | +10.475 | +10.487 | Y6 | 2 | 2007 | 1.44126 | 0.0001836 | 129.081 | 0.18604 | 270
CALE | 10218.2 | 52690 | 31674.7 | +10.212 | +10.224 | Y6 | 2 | 2007 | 1.44126 | 0.0001836 | 129.081 | 0.18604 | 270
CALE | 10305.9 | 52690 | 28846.7 | +10.300 | +10.312 | Y6 | 2 | 2007 | 1.44126 | 0.0001836 | 129.081 | 0.18604 | 270
CALE | 10393.5 | 52690 | 26018.7 | +10.387 | +10.400 | Y6 | 2 | 2007 | 1.44126 | 0.0001836 | 129.081 | 0.18604 | 270
CALE | 10481.2 | 52690 | 23190.7 | +10.475 | +10.487 | Y6 | 2 | 2007 | 1.44126 | 0.0001836 | 129.081 | 0.18604 | 270
CALE | 10218.2 | 50520 | 31674.8 | +10.214 | +10.223 | Y7 | 2 | 2007 | 1.25977 | 0.00016048 | 129.217 | 0.162784 | 236
CALE | 10305.8 | 50520 | 28846.8 | +10.301 | +10.310 | Y7 | 2 | 2007 | 1.25977 | 0.00016048 | 129.217 | 0.162784 | 236
CALE | 3934.49 | 48525 | 3043.01 | +3.928 | +3.941 | Y6 | 2 | 2007 | 1.44126 | 0.0001836 | 129.081 | 0.18604 | 270
CALE | 3934.49 | 45766.7 | 3043.01 | +3.928 | +3.941 | Y6 | 2 | 2007 | 1.44126 | 0.0001836 | 129.081 | 0.18604 | 270
CALE | 3934.49 | 43008.3 | 3043.01 | +3.928 | +3.941 | Y6 | 2 | 2007 | 1.44126 | 0.0001836 | 129.081 | 0.18604 | 270
CALE | 3934.49 | 40250 | 3043.01 | +3.928 | +3.941 | Y6 | 2 | 2007 | 1.44126 | 0.0001836 | 129.081 | 0.18604 | 270
CALE | 3934.49 | 37581.2 | 3043.01 | +3.928 | +3.941 | Y6 | 2 | 2007 | 1.44126 | 0.0001836 | 129.081 | 0.18604 | 270
CALE | 3934.49 | 34912.5 | 3043.01 | +3.928 | +3.941 | Y6 | 2 | 2007 | 1.44126 | 0.0001836 | 129.081 | 0.18604 | 270
CALE | 3934.49 | 32243.7 | 3043.01 | +3.928 | +3.941 | Y6 | 2 | 2007 | 1.44126 | 0.0001836 | 129.081 | 0.18604 | 270
CALE | 3934.49 | 29575 | 3043.01 | +3.928 | +3.941 | Y6 | 2 | 2007 | 1.44126 | 0.0001836 | 129.081 | 0.18604 | 270
CALE | 3934.49 | 27043.7 | 3043.01 | +3.928 | +3.941 | Y6 | 2 | 2007 | 1.44126 | 0.0001836 | 129.081 | 0.18604 | 270
CALE | 3934.49 | 24512.5 | 3043.01 | +3.928 | +3.941 | Y6 | 2 | 2007 | 1.44126 | 0.0001836 | 129.081 | 0.18604 | 270
CALE | 3934.49 | 21981.2 | 3043.01 | +3.928 | +3.941 | Y6 | 2 | 2007 | 1.44126 | 0.0001836 | 129.081 | 0.18604 | 270
CALE | 3934.49 | 19450 | 3043.01 | +3.928 | +3.941 | Y6 | 2 | 2007 | 1.44126 | 0.0001836 | 129.081 | 0.18604 | 270
CALE | 3934.49 | 17320 | 3043.01 | +3.928 | +3.941 | Y6 | 2 | 2007 | 1.44126 | 0.0001836 | 129.081 | 0.18604 | 270
CALE | 3934.49 | 15190 | 3043.01 | +3.928 | +3.941 | Y6 | 2 | 2007 | 1.44126 | 0.0001836 | 129.081 | 0.18604 | 270
CALE | 3934.49 | 10930 | 3043.01 | +3.928 | +3.941 | Y6 | 2 | 2007 | 1.44126 | 0.0001836 | 129.081 | 0.18604 | 270
CALE | 3934.49 | 13060 | 3043.01 | +3.928 | +3.941 | Y6 | 2 | 2007 | 1.44126 | 0.0001836 | 129.081 | 0.18604 | 270
CALE | 3388.22 | 15190 | 10405.3 | +3.382 | +3.394 | Y6 | 2 | 2007 | 1.44126 | 0.0001836 | 129.081 | 0.18604 | 270
CALE | 3388.22 | 13060 | 10405.3 | +3.382 | +3.394 | Y6 | 2 | 2007 | 1.44126 | 0.0001836 | 129.081 | 0.18604 | 270
CALE | 3388.22 | 17320 | 10405.3 | +3.382 | +3.394 | Y6 | 2 | 2007 | 1.44126 | 0.0001836 | 129.081 | 0.18604 | 270
CALE | 3388.22 | 21981.2 | 10405.3 | +3.382 | +3.394 | Y6 | 2 | 2007 | 1.44126 | 0.0001836 | 129.081 | 0.18604 | 270
CALE | 3388.22 | 27043.8 | 10405.3 | +3.382 | +3.394 | Y6 | 2 | 2007 | 1.44126 | 0.0001836 | 129.081 | 0.18604 | 270
CALE | 3388.22 | 32243.8 | 10405.3 | +3.382 | +3.394 | Y6 | 2 | 2007 | 1.44126 | 0.0001836 | 129.081 | 0.18604 | 270
CALE | 3388.22 | 37581.2 | 10405.3 | +3.382 | +3.394 | Y6 | 2 | 2007 | 1.44126 | 0.0001836 | 129.081 | 0.18604 | 270
CALE | 3388.22 | 43008.3 | 10405.3 | +3.382 | +3.394 | Y6 | 2 | 2007 | 1.44126 | 0.0001836 | 129.081 | 0.18604 | 270
CALE | 3388.22 | 19450 | 10405.3 | +3.382 | +3.394 | Y6 | 2 | 2007 | 1.44126 | 0.0001836 | 129.081 | 0.18604 | 270
CALE | 3388.22 | 24512.5 | 10405.3 | +3.382 | +3.394 | Y6 | 2 | 2007 | 1.44126 | 0.0001836 | 129.081 | 0.18604 | 270
CALE | 3388.22 | 29575 | 10405.3 | +3.382 | +3.394 | Y6 | 2 | 2007 | 1.44126 | 0.0001836 | 129.081 | 0.18604 | 270
CALE | 3388.22 | 34912.5 | 10405.3 | +3.382 | +3.394 | Y6 | 2 | 2007 | 1.44126 | 0.0001836 | 129.081 | 0.18604 | 270
CALE | 3388.22 | 45766.7 | 10405.3 | +3.382 | +3.394 | Y6 | 2 | 2007 | 1.44126 | 0.0001836 | 129.081 | 0.18604 | 270
CALE | 3388.22 | 40250 | 10405.3 | +3.382 | +3.394 | Y6 | 2 | 2007 | 1.44126 | 0.0001836 | 129.081 | 0.18604 | 270
CALE | 3388.2 | 48065 | 10405.2 | +3.384 | +3.393 | Y7 | 2 | 2007 | 1.25977 | 0.00016048 | 129.217 | 0.162784 | 236
CALE | 3388.2 | 11385 | 10405.2 | +3.384 | +3.393 | Y7 | 2 | 2007 | 1.25977 | 0.00016048 | 129.217 | 0.162784 | 236

# IfcBeam: PL20*110, CALAGE
In: Undefined
Description: PL20*110; Material: STEEL/E24-2
Tekla Common - Center of gravity Z: 2266.38 mm; Center of gravity Y: 69165 mm; Center of gravity X: 50037.5 mm; Bottom elevation: +2.161; Top elevation: +2.371; Part mark: Y1; Assembly mark: Y1; Phase: 1; Class: 1002; Finish: GRENAILLE-PEINT; Grade: E24-2; Profile: PL20*110; Name: CALAGE; sets with these values: 2
Tekla Quantity - Net weight: 3.6267 kg; Gross weight: 3.6267 kg; Weight: 3.6267 kg; Net volume: 0.000462 m3; Gross volume: 0.000462 m3; Gross footprint area: 0.0022 m2; Area per tons: 16.2682 m2; Net surface area: 0.059 m2; Gross area: 0.059 m2; Height: 110 mm; Width: 20 mm; Length: 210 mm; sets with these values: 2
