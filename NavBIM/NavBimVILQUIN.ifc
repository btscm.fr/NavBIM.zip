Properties of the parts of a building model (IFC2X3), part 25 of 32

# IfcPlate: PL10*147 (176)
Name | Center of gravity Z (mm) | Center of gravity Y (mm) | Center of gravity X (mm) | Bottom elevation | Top elevation | Part mark | Assembly mark | Phase | Class | Net weight (kg) = Weight (kg) | Gross weight (kg) | Net volume (m3) | Gross volume (m3) | Gross footprint area (m2) | Area per tons (m2) | Net surface area (m2) | Gross area (m2) | Height (mm) | Length (mm)
PLATINE | 5641.71 | 5108.05 | 55953.7 | +5.501 | +5.770 | 286 | N16 | 1 | 1006 | 2.91065 | 3.10164 | 0.000370783 | 0.000370783 | 0.0014695 | 28.7176 | 0.0835868 | 0.0395114 | 146.95 | 268.876
PLATINE | 5641.71 | 10018 | 55953.7 | +5.501 | +5.770 | 286 | N47 | 1 | 1006 | 2.91065 | 3.10164 | 0.000370783 | 0.000370783 | 0.0014695 | 28.7176 | 0.0835868 | 0.0395114 | 146.95 | 268.876
PLATINE | 5657.2 | 12378 | 55952.9 | +5.540 | +5.770 | 187 | N47 | 1 | 1006 | 2.5696 | 2.65318 | 0.000327338 | 0.000327338 | 0.0014695 | 28.9302 | 0.0743392 | 0.0337985 | 146.95 | 230
PLATINE | 5641.71 | 14738 | 55953.7 | +5.501 | +5.770 | 286 | N47 | 1 | 1006 | 2.91065 | 3.10164 | 0.000370783 | 0.000370783 | 0.0014695 | 28.7176 | 0.0835868 | 0.0395114 | 146.95 | 268.876
PLATINE | 5648.99 | 17098 | 55956.1 | +5.540 | +5.770 | 199 | N47 | 1 | 1006 | 2.36643 | 2.65318 | 0.000301456 | 0.000327338 | 0.00073 | 29.2266 | 0.0691627 | 0.0337985 | 146.95 | 230
PLATINE | 5657.2 | 27258 | 55952.9 | +5.540 | +5.770 | 187 | N10 | 1 | 1006 | 2.5696 | 2.65318 | 0.000327338 | 0.000327338 | 0.0014695 | 28.9302 | 0.0743392 | 0.0337985 | 146.95 | 230
PLATINE | 5641.71 | 29858 | 55953.7 | +5.501 | +5.770 | 286 | N8 | 1 | 1006 | 2.91065 | 3.10164 | 0.000370783 | 0.000370783 | 0.0014695 | 28.7176 | 0.0835868 | 0.0395114 | 146.95 | 268.876
PLATINE | 5657.2 | 32458 | 55952.9 | +5.540 | +5.770 | 187 | N8 | 1 | 1006 | 2.5696 | 2.65318 | 0.000327338 | 0.000327338 | 0.0014695 | 28.9302 | 0.0743392 | 0.0337985 | 146.95 | 230
PLATINE | 5633.37 | 35058 | 55956.6 | +5.501 | +5.770 | 253 | N8 | 1 | 1006 | 2.7075 | 3.10169 | 0.000344905 | 0.000370787 | 0.00073 | 28.9607 | 0.0784113 | 0.0395119 | 146.95 | 268.88
PLATINE | 5648.99 | 37658.1 | 55956.1 | +5.540 | +5.770 | 199 | N8 | 1 | 1006 | 2.36643 | 2.65318 | 0.000301456 | 0.000327338 | 0.00073 | 29.2266 | 0.0691627 | 0.0337985 | 146.95 | 230
PLATINE | 5633.37 | 45441.9 | 55956.6 | +5.501 | +5.770 | 253 | N41 | 1 | 1006 | 2.7075 | 3.10169 | 0.000344905 | 0.000370787 | 0.00073 | 28.9607 | 0.0784113 | 0.0395119 | 146.95 | 268.88
PLATINE | 5657.2 | 48058.1 | 55952.9 | +5.540 | +5.770 | 187 | N41 | 1 | 1006 | 2.5696 | 2.65318 | 0.000327338 | 0.000327338 | 0.0014695 | 28.9302 | 0.0743392 | 0.0337985 | 146.95 | 230
PLATINE | 5657.2 | 66458.1 | 44277.9 | +5.540 | +5.770 | 187 | N39 | 1 | 1006 | 2.5696 | 2.65318 | 0.000327338 | 0.000327338 | 0.0014695 | 28.9302 | 0.0743392 | 0.0337985 | 146.95 | 230
PLATINE | 5641.71 | 50658.1 | 55953.7 | +5.501 | +5.770 | 286 | N41 | 1 | 1006 | 2.91065 | 3.10164 | 0.000370783 | 0.000370783 | 0.0014695 | 28.7176 | 0.0835868 | 0.0395114 | 146.95 | 268.876
PLATINE | 5641.71 | 63758.1 | 44278.7 | +5.501 | +5.770 | 286 | N39 | 1 | 1006 | 2.91068 | 3.10169 | 0.000370787 | 0.000370787 | 0.0014695 | 28.7176 | 0.0835878 | 0.0395119 | 146.95 | 268.88
PLATINE | 5657.2 | 53258.1 | 55952.9 | +5.540 | +5.770 | 187 | N13 | 1 | 1006 | 2.5696 | 2.65318 | 0.000327338 | 0.000327338 | 0.0014695 | 28.9302 | 0.0743392 | 0.0337985 | 146.95 | 230
PLATINE | 5657.2 | 48058.1 | 44277.9 | +5.540 | +5.770 | 187 | N41 | 1 | 1006 | 2.5696 | 2.65318 | 0.000327338 | 0.000327338 | 0.0014695 | 28.9302 | 0.0743392 | 0.0337985 | 146.95 | 230
PLATINE | 5633.37 | 55858 | 55956.6 | +5.501 | +5.770 | 253 | N13 | 1 | 1006 | 2.7075 | 3.10169 | 0.000344905 | 0.000370787 | 0.00073 | 28.9607 | 0.0784113 | 0.0395119 | 146.95 | 268.88
PLATINE | 5648.99 | 58458.1 | 55956.1 | +5.540 | +5.770 | 199 | N13 | 1 | 1006 | 2.36643 | 2.65318 | 0.000301456 | 0.000327338 | 0.00073 | 29.2266 | 0.0691627 | 0.0337985 | 146.95 | 230
PLATINE | 5633.37 | 45441.9 | 44281.6 | +5.501 | +5.770 | 253 | N41 | 1 | 1006 | 2.7075 | 3.10169 | 0.000344905 | 0.000370787 | 0.00073 | 28.9607 | 0.0784113 | 0.0395119 | 146.95 | 268.88
PLATINE | 5641.71 | 63758.1 | 55953.7 | +5.501 | +5.770 | 286 | N38 | 1 | 1006 | 2.91068 | 3.10169 | 0.000370787 | 0.000370787 | 0.0014695 | 28.7176 | 0.0835878 | 0.0395119 | 146.95 | 268.88
PLATINE | 5657.2 | 66458.1 | 55952.9 | +5.540 | +5.770 | 187 | N38 | 1 | 1006 | 2.5696 | 2.65318 | 0.000327338 | 0.000327338 | 0.0014695 | 28.9302 | 0.0743392 | 0.0337985 | 146.95 | 230
PLATINE | 5648.99 | 42841.9 | 44281.1 | +5.540 | +5.770 | 199 | N41 | 1 | 1006 | 2.36643 | 2.65318 | 0.000301456 | 0.000327338 | 0.00073 | 29.2266 | 0.0691627 | 0.0337985 | 146.95 | 230
PLATINE | 5648.99 | 42841.9 | 55956.1 | +5.540 | +5.770 | 199 | N41 | 1 | 1006 | 2.36643 | 2.65318 | 0.000301456 | 0.000327338 | 0.00073 | 29.2266 | 0.0691627 | 0.0337985 | 146.95 | 230
PLATINE | 5648.99 | 22042 | 55956.1 | +5.540 | +5.770 | 199 | N10 | 1 | 1006 | 2.36643 | 2.65318 | 0.000301456 | 0.000327338 | 0.00073 | 29.2266 | 0.0691627 | 0.0337985 | 146.95 | 230
PLATINE | 5633.37 | 24641.9 | 55956.6 | +5.501 | +5.770 | 253 | N10 | 1 | 1006 | 2.70747 | 3.10163 | 0.0003449 | 0.000370783 | 0.00073 | 28.9608 | 0.0784103 | 0.0395113 | 146.95 | 268.876
PLATINE | 4258.28 | 10018 | 32447.1 | +4.142 | +4.372 | 186 | N48 | 3 | 3006 | 2.5696 | 2.65318 | 0.000327338 | 0.000327338 | 0.0014695 | 28.9302 | 0.0743392 | 0.0337985 | 146.95 | 230
PLATINE | 4258.28 | 12378 | 32447.1 | +4.142 | +4.372 | 186 | N48 | 3 | 3006 | 2.5696 | 2.65318 | 0.000327338 | 0.000327338 | 0.0014695 | 28.9302 | 0.0743392 | 0.0337985 | 146.95 | 230
PLATINE | 4258.28 | 14738 | 32447.1 | +4.142 | +4.372 | 186 | N48 | 3 | 3006 | 2.5696 | 2.65318 | 0.000327338 | 0.000327338 | 0.0014695 | 28.9302 | 0.0743392 | 0.0337985 | 146.95 | 230
PLATINE | 4258.28 | 17098 | 32447.1 | +4.142 | +4.372 | 186 | N48 | 3 | 3006 | 2.5696 | 2.65318 | 0.000327338 | 0.000327338 | 0.0014695 | 28.9302 | 0.0743392 | 0.0337985 | 146.95 | 230
PLATINE | 4258.28 | 22058 | 32447.1 | +4.142 | +4.372 | 186 | N9 | 3 | 3006 | 2.5696 | 2.65318 | 0.000327338 | 0.000327338 | 0.0014695 | 28.9302 | 0.0743392 | 0.0337985 | 146.95 | 230
PLATINE | 4258.28 | 24658 | 32447.1 | +4.142 | +4.372 | 186 | N9 | 3 | 3006 | 2.5696 | 2.65318 | 0.000327338 | 0.000327338 | 0.0014695 | 28.9302 | 0.0743392 | 0.0337985 | 146.95 | 230
PLATINE | 4258.28 | 27258 | 32447.1 | +4.142 | +4.372 | 186 | N9 | 3 | 3006 | 2.5696 | 2.65318 | 0.000327338 | 0.000327338 | 0.0014695 | 28.9302 | 0.0743392 | 0.0337985 | 146.95 | 230
PLATINE | 4258.28 | 29858 | 32447.1 | +4.142 | +4.372 | 186 | N40 | 3 | 3006 | 2.5696 | 2.65318 | 0.000327338 | 0.000327338 | 0.0014695 | 28.9302 | 0.0743392 | 0.0337985 | 146.95 | 230
PLATINE | 4258.28 | 32458 | 32447.1 | +4.142 | +4.372 | 186 | N40 | 3 | 3006 | 2.5696 | 2.65318 | 0.000327338 | 0.000327338 | 0.0014695 | 28.9302 | 0.0743392 | 0.0337985 | 146.95 | 230
PLATINE | 4258.28 | 2558.05 | 44122.1 | +4.142 | +4.372 | 186 | N16 | 1 | 1006 | 2.5696 | 2.65318 | 0.000327338 | 0.000327338 | 0.0014695 | 28.9302 | 0.0743392 | 0.0337985 | 146.95 | 230
PLATINE | 4258.28 | 35058.1 | 32447.1 | +4.142 | +4.372 | 186 | N40 | 3 | 3006 | 2.5696 | 2.65318 | 0.000327338 | 0.000327338 | 0.0014695 | 28.9302 | 0.0743392 | 0.0337985 | 146.95 | 230
PLATINE | 4238.09 | 5108.05 | 44123.1 | +4.095 | +4.372 | 287 | N16 | 1 | 1006 | 3.01906 | 3.19618 | 0.000384593 | 0.000384593 | 0.0014695 | 28.6579 | 0.0865197 | 0.0407156 | 146.953 | 277.066
PLATINE | 4258.28 | 10018 | 44122.1 | +4.142 | +4.372 | 186 | N47 | 1 | 1006 | 2.5696 | 2.65318 | 0.000327338 | 0.000327338 | 0.0014695 | 28.9302 | 0.0743392 | 0.0337985 | 146.95 | 230
PLATINE | 4258.28 | 37658.1 | 32447.1 | +4.142 | +4.372 | 186 | N40 | 3 | 3006 | 2.5696 | 2.65318 | 0.000327338 | 0.000327338 | 0.0014695 | 28.9302 | 0.0743392 | 0.0337985 | 146.95 | 230
PLATINE | 4258.28 | 66458.1 | 44122.1 | +4.142 | +4.372 | 186 | N39 | 1 | 1006 | 2.5696 | 2.65318 | 0.000327338 | 0.000327338 | 0.0014695 | 28.9302 | 0.0743392 | 0.0337985 | 146.95 | 230
PLATINE | 4258.28 | 58458.1 | 44122.1 | +4.142 | +4.372 | 193 | N42 | 1 | 1006 | 2.5696 | 2.65318 | 0.000327338 | 0.000327338 | 0.0014695 | 28.9302 | 0.0743392 | 0.0337985 | 146.95 | 230
PLATINE | 4258.28 | 55858.1 | 44122.1 | +4.142 | +4.372 | 186 | N42 | 1 | 1006 | 2.5696 | 2.65318 | 0.000327338 | 0.000327338 | 0.0014695 | 28.9302 | 0.0743392 | 0.0337985 | 146.95 | 230
PLATINE | 4258.28 | 53258.1 | 44122.1 | +4.142 | +4.372 | 186 | N42 | 1 | 1006 | 2.5696 | 2.65318 | 0.000327338 | 0.000327338 | 0.0014695 | 28.9302 | 0.0743392 | 0.0337985 | 146.95 | 230
PLATINE | 4258.28 | 50658.1 | 44122.1 | +4.142 | +4.372 | 186 | N41 | 1 | 1006 | 2.5696 | 2.65318 | 0.000327338 | 0.000327338 | 0.0014695 | 28.9302 | 0.0743392 | 0.0337985 | 146.95 | 230
PLATINE | 4238.09 | 48038.1 | 32448.1 | +4.095 | +4.372 | 285 | N43 | 3 | 3003 | 3.01906 | 3.19618 | 0.000384593 | 0.000384593 | 0.0014695 | 28.6579 | 0.0865197 | 0.0407156 | 146.953 | 277.066
PLATINE | 5648.99 | 45441.9 | 20931.1 | +5.540 | +5.770 | 199 | N46 | 2 | 2006 | 2.36643 | 2.65318 | 0.000301456 | 0.000327338 | 0.00073 | 29.2266 | 0.0691627 | 0.0337985 | 146.95 | 230
PLATINE | 4258.28 | 22058 | 44122.1 | +4.142 | +4.372 | 186 | N10 | 1 | 1006 | 2.5696 | 2.65318 | 0.000327338 | 0.000327338 | 0.0014695 | 28.9302 | 0.0743392 | 0.0337985 | 146.95 | 230
PLATINE | 5648.99 | 22042 | 32606.1 | +5.540 | +5.770 | 199 | N9 | 3 | 3006 | 2.36643 | 2.65318 | 0.000301456 | 0.000327338 | 0.00073 | 29.2266 | 0.0691627 | 0.0337985 | 146.95 | 230
PLATINE | 5657.2 | 12378 | 32602.9 | +5.540 | +5.770 | 187 | N48 | 3 | 3006 | 2.5696 | 2.65318 | 0.000327338 | 0.000327338 | 0.0014695 | 28.9302 | 0.0743392 | 0.0337985 | 146.95 | 230
PLATINE | 5641.71 | 10018 | 32603.7 | +5.501 | +5.770 | 286 | N48 | 3 | 3006 | 2.91065 | 3.10164 | 0.000370783 | 0.000370783 | 0.0014695 | 28.7176 | 0.0835868 | 0.0395114 | 146.95 | 268.876
PLATINE | 5641.71 | 14738 | 32603.7 | +5.501 | +5.770 | 286 | N48 | 3 | 3006 | 2.91065 | 3.10164 | 0.000370783 | 0.000370783 | 0.0014695 | 28.7176 | 0.0835868 | 0.0395114 | 146.95 | 268.876
PLATINE | 5648.99 | 17098 | 32606.1 | +5.540 | +5.770 | 199 | N48 | 3 | 3006 | 2.36643 | 2.65318 | 0.000301456 | 0.000327338 | 0.00073 | 29.2266 | 0.0691627 | 0.0337985 | 146.95 | 230
PLATINE | 5641.71 | 5108.05 | 32603.7 | +5.501 | +5.770 | 286 | N15 | 3 | 3006 | 2.91065 | 3.10164 | 0.000370783 | 0.000370783 | 0.0014695 | 28.7176 | 0.0835868 | 0.0395114 | 146.95 | 268.876
PLATINE | 5657.2 | 2558.05 | 32602.9 | +5.540 | +5.770 | 187 | N15 | 3 | 3006 | 2.5696 | 2.65318 | 0.000327338 | 0.000327338 | 0.0014695 | 28.9302 | 0.0743392 | 0.0337985 | 146.95 | 230
PLATINE | 5657.2 | 53258.1 | 44277.9 | +5.540 | +5.770 | 187 | N42 | 1 | 1006 | 2.5696 | 2.65318 | 0.000327338 | 0.000327338 | 0.0014695 | 28.9302 | 0.0743392 | 0.0337985 | 146.95 | 230
PLATINE | 5641.71 | 29858 | 67628.7 | +5.501 | +5.770 | 286 | N7 | 1 | 1006 | 2.91065 | 3.10164 | 0.000370783 | 0.000370783 | 0.0014695 | 28.7176 | 0.0835868 | 0.0395114 | 146.95 | 268.876
PLATINE | 4258.28 | 22058 | 55797.1 | +4.142 | +4.372 | 186 | N10 | 1 | 1006 | 2.5696 | 2.65318 | 0.000327338 | 0.000327338 | 0.0014695 | 28.9302 | 0.0743392 | 0.0337985 | 146.95 | 230
PLATINE | 4258.28 | 24658 | 55797.1 | +4.142 | +4.372 | 186 | N10 | 1 | 1006 | 2.5696 | 2.65318 | 0.000327338 | 0.000327338 | 0.0014695 | 28.9302 | 0.0743392 | 0.0337985 | 146.95 | 230
PLATINE | 4238.09 | 5108.05 | 55798.1 | +4.095 | +4.372 | 287 | N16 | 1 | 1006 | 3.01906 | 3.19618 | 0.000384593 | 0.000384593 | 0.0014695 | 28.6579 | 0.0865197 | 0.0407156 | 146.953 | 277.066
PLATINE | 4258.28 | 10018 | 55797.1 | +4.142 | +4.372 | 186 | N47 | 1 | 1006 | 2.5696 | 2.65318 | 0.000327338 | 0.000327338 | 0.0014695 | 28.9302 | 0.0743392 | 0.0337985 | 146.95 | 230
PLATINE | 4258.28 | 66458.1 | 55797.1 | +4.142 | +4.372 | 186 | N38 | 1 | 1006 | 2.5696 | 2.65318 | 0.000327338 | 0.000327338 | 0.0014695 | 28.9302 | 0.0743392 | 0.0337985 | 146.95 | 230
PLATINE | 4258.28 | 58458.1 | 55797.1 | +4.142 | +4.372 | 186 | N13 | 1 | 1006 | 2.5696 | 2.65318 | 0.000327338 | 0.000327338 | 0.0014695 | 28.9302 | 0.0743392 | 0.0337985 | 146.95 | 230
PLATINE | 4258.28 | 53258.1 | 55797.1 | +4.142 | +4.372 | 186 | N13 | 1 | 1006 | 2.5696 | 2.65318 | 0.000327338 | 0.000327338 | 0.0014695 | 28.9302 | 0.0743392 | 0.0337985 | 146.95 | 230
PLATINE | 4258.28 | 48058.1 | 55797.1 | +4.142 | +4.372 | 186 | N41 | 1 | 1006 | 2.5696 | 2.65318 | 0.000327338 | 0.000327338 | 0.0014695 | 28.9302 | 0.0743392 | 0.0337985 | 146.95 | 230
PLATINE | 4258.28 | 2558.05 | 55797.1 | +4.142 | +4.372 | 186 | N16 | 1 | 1006 | 2.5696 | 2.65318 | 0.000327338 | 0.000327338 | 0.0014695 | 28.9302 | 0.0743392 | 0.0337985 | 146.95 | 230
PLATINE | 4258.28 | 37658.1 | 55797.1 | +4.142 | +4.372 | 186 | N8 | 1 | 1006 | 2.5696 | 2.65318 | 0.000327338 | 0.000327338 | 0.0014695 | 28.9302 | 0.0743392 | 0.0337985 | 146.95 | 230
PLATINE | 4258.28 | 27258 | 55797.1 | +4.142 | +4.372 | 186 | N10 | 1 | 1006 | 2.5696 | 2.65318 | 0.000327338 | 0.000327338 | 0.0014695 | 28.9302 | 0.0743392 | 0.0337985 | 146.95 | 230
PLATINE | 4258.28 | 42858.1 | 55797.1 | +4.142 | +4.372 | 186 | N41 | 1 | 1006 | 2.5696 | 2.65318 | 0.000327338 | 0.000327338 | 0.0014695 | 28.9302 | 0.0743392 | 0.0337985 | 146.95 | 230
PLATINE | 4258.28 | 12378 | 55797.1 | +4.142 | +4.372 | 186 | N47 | 1 | 1006 | 2.5696 | 2.65318 | 0.000327338 | 0.000327338 | 0.0014695 | 28.9302 | 0.0743392 | 0.0337985 | 146.95 | 230
PLATINE | 4258.28 | 14738 | 55797.1 | +4.142 | +4.372 | 186 | N47 | 1 | 1006 | 2.5696 | 2.65318 | 0.000327338 | 0.000327338 | 0.0014695 | 28.9302 | 0.0743392 | 0.0337985 | 146.95 | 230
PLATINE | 4258.28 | 32458 | 55797.1 | +4.142 | +4.372 | 186 | N8 | 1 | 1006 | 2.5696 | 2.65318 | 0.000327338 | 0.000327338 | 0.0014695 | 28.9302 | 0.0743392 | 0.0337985 | 146.95 | 230
PLATINE | 4258.28 | 29858 | 55797.1 | +4.142 | +4.372 | 186 | N8 | 1 | 1006 | 2.5696 | 2.65318 | 0.000327338 | 0.000327338 | 0.0014695 | 28.9302 | 0.0743392 | 0.0337985 | 146.95 | 230
PLATINE | 4258.28 | 35058.1 | 55797.1 | +4.142 | +4.372 | 186 | N8 | 1 | 1006 | 2.5696 | 2.65318 | 0.000327338 | 0.000327338 | 0.0014695 | 28.9302 | 0.0743392 | 0.0337985 | 146.95 | 230
PLATINE | 4258.28 | 17098 | 55797.1 | +4.142 | +4.372 | 186 | N47 | 1 | 1006 | 2.5696 | 2.65318 | 0.000327338 | 0.000327338 | 0.0014695 | 28.9302 | 0.0743392 | 0.0337985 | 146.95 | 230
PLATINE | 4258.28 | 45458.1 | 55797.1 | +4.142 | +4.372 | 186 | N41 | 1 | 1006 | 2.5696 | 2.65318 | 0.000327338 | 0.000327338 | 0.0014695 | 28.9302 | 0.0743392 | 0.0337985 | 146.95 | 230
PLATINE | 4258.28 | 50658.1 | 55797.1 | +4.142 | +4.372 | 186 | N41 | 1 | 1006 | 2.5696 | 2.65318 | 0.000327338 | 0.000327338 | 0.0014695 | 28.9302 | 0.0743392 | 0.0337985 | 146.95 | 230
PLATINE | 4258.28 | 55858.1 | 55797.1 | +4.142 | +4.372 | 186 | N13 | 1 | 1006 | 2.5696 | 2.65318 | 0.000327338 | 0.000327338 | 0.0014695 | 28.9302 | 0.0743392 | 0.0337985 | 146.95 | 230
PLATINE | 5633.37 | 24641.9 | 32606.6 | +5.501 | +5.770 | 253 | N9 | 3 | 3006 | 2.70747 | 3.10163 | 0.0003449 | 0.000370783 | 0.00073 | 28.9608 | 0.0784103 | 0.0395113 | 146.95 | 268.876
PLATINE | 5657.2 | 27258 | 32602.9 | +5.540 | +5.770 | 187 | N9 | 3 | 3006 | 2.5696 | 2.65318 | 0.000327338 | 0.000327338 | 0.0014695 | 28.9302 | 0.0743392 | 0.0337985 | 146.95 | 230
PLATINE | 5633.37 | 35058 | 32606.6 | +5.501 | +5.770 | 253 | N40 | 3 | 3006 | 2.7075 | 3.10169 | 0.000344905 | 0.000370787 | 0.00073 | 28.9607 | 0.0784113 | 0.0395119 | 146.95 | 268.88
PLATINE | 5648.99 | 37658.1 | 32606.1 | +5.540 | +5.770 | 199 | N40 | 3 | 3006 | 2.36643 | 2.65318 | 0.000301456 | 0.000327338 | 0.00073 | 29.2266 | 0.0691627 | 0.0337985 | 146.95 | 230
PLATINE | 4258.28 | 27258 | 44122.1 | +4.142 | +4.372 | 186 | N10 | 1 | 1006 | 2.5696 | 2.65318 | 0.000327338 | 0.000327338 | 0.0014695 | 28.9302 | 0.0743392 | 0.0337985 | 146.95 | 230
PLATINE | 4258.28 | 24658 | 44122.1 | +4.142 | +4.372 | 186 | N10 | 1 | 1006 | 2.5696 | 2.65318 | 0.000327338 | 0.000327338 | 0.0014695 | 28.9302 | 0.0743392 | 0.0337985 | 146.95 | 230
PLATINE | 5657.2 | 32458 | 32602.9 | +5.540 | +5.770 | 187 | N40 | 3 | 3006 | 2.5696 | 2.65318 | 0.000327338 | 0.000327338 | 0.0014695 | 28.9302 | 0.0743392 | 0.0337985 | 146.95 | 230
PLATINE | 5641.71 | 29858 | 32603.7 | +5.501 | +5.770 | 286 | N40 | 3 | 3006 | 2.91065 | 3.10164 | 0.000370783 | 0.000370783 | 0.0014695 | 28.7176 | 0.0835868 | 0.0395114 | 146.95 | 268.876
PLATINE | 4258.28 | 37658.1 | 44122.1 | +4.142 | +4.372 | 186 | N8 | 1 | 1006 | 2.5696 | 2.65318 | 0.000327338 | 0.000327338 | 0.0014695 | 28.9302 | 0.0743392 | 0.0337985 | 146.95 | 230
PLATINE | 4258.28 | 35058.1 | 44122.1 | +4.142 | +4.372 | 186 | N8 | 1 | 1006 | 2.5696 | 2.65318 | 0.000327338 | 0.000327338 | 0.0014695 | 28.9302 | 0.0743392 | 0.0337985 | 146.95 | 230
PLATINE | 4258.28 | 32458 | 44122.1 | +4.142 | +4.372 | 186 | N8 | 1 | 1006 | 2.5696 | 2.65318 | 0.000327338 | 0.000327338 | 0.0014695 | 28.9302 | 0.0743392 | 0.0337985 | 146.95 | 230
PLATINE | 4258.28 | 29858 | 44122.1 | +4.142 | +4.372 | 186 | N8 | 1 | 1006 | 2.5696 | 2.65318 | 0.000327338 | 0.000327338 | 0.0014695 | 28.9302 | 0.0743392 | 0.0337985 | 146.95 | 230
PLATINE | 5641.71 | -8.05 | 20929.5 | +5.501 | +5.770 | 283 | P119 | 2 | 2001 | 2.91073 | 3.10176 | 0.000370794 | 0.000370794 | 0.00146954 | 28.7176 | 0.0835891 | 0.0395128 | 146.954 | 268.879
PLATINE | 5641.71 | 10018 | 20928.7 | +5.501 | +5.770 | 283 | N49 | 2 | 2006 | 2.91065 | 3.10164 | 0.000370783 | 0.000370783 | 0.0014695 | 28.7176 | 0.0835868 | 0.0395114 | 146.95 | 268.876
PLATINE | 5633.37 | 42858 | 20931.6 | +5.501 | +5.770 | 241 | N46 | 2 | 2006 | 2.7075 | 3.10169 | 0.000344905 | 0.000370787 | 0.00073 | 28.9607 | 0.0784113 | 0.0395119 | 146.95 | 268.88

# IfcPlate: PL10*152, PLATINE
In: Undefined
Description: PL10*152; Material: STEEL/E24-2
Tekla Common - Center of gravity Z: 5641.19 mm; Center of gravity Y: 32458 mm; Center of gravity X: 67631.3 mm; Bottom elevation: +5.501; Top elevation: +5.770; Part mark: 256; Assembly mark: N7; Phase: 1; Class: 1006; Finish: GRENAILLE-PEINT; Grade: E24-2; Profile: PL10*152; Name: PLATINE; sets with these values: 2
Tekla Quantity - Net weight: 3.00911 kg; Gross weight: 3.20729 kg; Weight: 3.00911 kg; Net volume: 0.000383326 m3; Gross volume: 0.000383326 m3; Gross footprint area: 0.00151953 m2; Area per tons: 28.643 m2; Net surface area: 0.0861899 m2; Gross area: 0.0408572 m2; Height: 151.953 mm; Width: 10 mm; Length: 268.881 mm; sets with these values: 2

# IfcPlate: PL10*156 (2)
In: Undefined
Description: PL10*156; Material: STEEL/E24-2
Tekla Common - Center of gravity Z: 4826.64 mm; Center of gravity Y: 69150 mm; Bottom elevation: +4.748; Top elevation: +4.902; Part mark: 245; Phase: 1; Finish: GRENAILLE-PEINT; Grade: E24-2; Profile: PL10*156; sets with these values: 2
Tekla Quantity - Net weight: 3.52889 kg; Gross weight: 6.63159 kg; Weight: 3.52889 kg; Net volume: 0.00044954 m3; Gross volume: 0.00044954 m3; Gross footprint area: 0 m2; Area per tons: 29.0775 m2; Net surface area: 0.102611 m2; Gross area: 0.0844788 m2; Height: 155.652 mm; Width: 10 mm; Length: 542.74 mm; sets with these values: 2
Name | Center of gravity X (mm) | Assembly mark | Class
 | 72810.1 | K54 | 1010
 | 61135.1 | K55 | 1005

# IfcPlate: PL10*168, PLAT
In: Undefined
Description: PL10*168; Material: STEEL/E24-2
Tekla Common - Center of gravity Z: 3569.85 mm; Center of gravity Y: 19463.2 mm; Center of gravity X: 4798.86 mm; Bottom elevation: +3.562; Top elevation: +3.578; Part mark: 269; Assembly mark: H91; Phase: 2; Class: 2003; Finish: GRENAILLE-PEINT; Grade: E24-2; Profile: PL10*168; Name: PLAT; sets with these values: 2
Tekla Quantity - Net weight: 2.31201 kg; Gross weight: 2.53987 kg; Weight: 2.31201 kg; Net volume: 0.000294524 m3; Gross volume: 0.000294524 m3; Gross footprint area: 0 m2; Area per tons: 28.3741 m2; Net surface area: 0.0656014 m2; Gross area: 0.0323551 m2; Height: 167.77 mm; Width: 10 mm; Length: 192.854 mm; sets with these values: 2

# IfcPlate: PL10*170 (11)
In: Undefined
Description: PL10*170; Material: STEEL/E24-2
Tekla Common - Phase: 1; Class: 1001; Finish: GRENAILLE-PEINT; Grade: E24-2; Profile: PL10*170; Name: PLATINE; sets with these values: 2
Tekla Quantity - Width: 10 mm; sets with these values: 2
Name | Center of gravity Z (mm) | Center of gravity Y (mm) | Center of gravity X (mm) | Bottom elevation | Top elevation | Part mark | Assembly mark | Net weight (kg) = Weight (kg) | Gross weight (kg) | Net volume (m3) = Gross volume (m3) | Gross footprint area (m2) | Area per tons (m2) | Net surface area (m2) | Gross area (m2) | Height (mm) | Length (mm)
PLATINE | 4240.47 | 69158.1 | 44109.7 | +4.096 | +4.375 | 289 | P26 | 3.50536 | 3.7324 | 0.000446542 | 0.0016989 | 28.4589 | 0.0997588 | 0.0475465 | 169.89 | 279.867
PLATINE | 4240.47 | -8.05 | 44109.7 | +4.096 | +4.375 | 289 | P22 | 3.50536 | 3.7324 | 0.000446542 | 0.0016989 | 28.4589 | 0.0997588 | 0.0475465 | 169.89 | 279.867
PLATINE | 4240.47 | 69158.1 | 67459.7 | +4.096 | +4.375 | 289 | P23 | 3.50536 | 3.7324 | 0.000446542 | 0.0016989 | 28.4589 | 0.0997588 | 0.0475465 | 169.89 | 279.867
PLATINE | 5639.31 | 69158.1 | 55967.7 | +5.498 | +5.767 | 288 | P27 | 3.34301 | 3.58616 | 0.000425861 | 0.00169904 | 28.536 | 0.0953963 | 0.0456835 | 169.904 | 268.878
PLATINE | 4240.47 | -8.05 | 67459.7 | +4.096 | +4.375 | 289 | P24 | 3.50536 | 3.7324 | 0.000446542 | 0.0016989 | 28.4589 | 0.0997588 | 0.0475465 | 169.89 | 279.867
PLATINE | 5639.31 | -8.05 | 55967.7 | +5.498 | +5.767 | 288 | P25 | 3.34301 | 3.58616 | 0.000425861 | 0.00169904 | 28.536 | 0.0953963 | 0.0456835 | 169.904 | 268.878
PLATINE | 5639.31 | 69158.1 | 44292.7 | +5.498 | +5.767 | 288 | P26 | 3.34301 | 3.58616 | 0.000425861 | 0.00169904 | 28.536 | 0.0953963 | 0.0456835 | 169.904 | 268.878
PLATINE | 4240.47 | 69158.1 | 55784.7 | +4.096 | +4.375 | 289 | P27 | 3.50536 | 3.7324 | 0.000446542 | 0.0016989 | 28.4589 | 0.0997588 | 0.0475465 | 169.89 | 279.867
PLATINE | 4240.47 | -8.05 | 55784.7 | +4.096 | +4.375 | 289 | P25 | 3.50536 | 3.7324 | 0.000446542 | 0.0016989 | 28.4589 | 0.0997588 | 0.0475465 | 169.89 | 279.867
PLATINE | 5639.31 | -8.05 | 44292.7 | +5.498 | +5.767 | 288 | P22 | 3.34301 | 3.58616 | 0.000425861 | 0.00169904 | 28.536 | 0.0953963 | 0.0456835 | 169.904 | 268.878
PLATINE | 5639.31 | 69158.1 | 67642.7 | +5.498 | +5.767 | 288 | P23 | 3.34301 | 3.58616 | 0.000425861 | 0.00169904 | 28.536 | 0.0953963 | 0.0456835 | 169.904 | 268.878

# IfcPlate: PL10*172, PLATINE
In: Undefined
Description: PL10*172; Material: STEEL/E24-2
Tekla Common - Center of gravity Z: 4240.35 mm; Center of gravity Y: -8.05 mm; Center of gravity X: 32435.8 mm; Bottom elevation: +4.095; Top elevation: +4.375; Part mark: 284; Assembly mark: P113; Phase: 3; Class: 3001; Finish: GRENAILLE-PEINT; Grade: E24-2; Profile: PL10*172; Name: PLATINE; sets with these values: 2
Tekla Quantity - Net weight: 3.57039 kg; Gross weight: 3.78245 kg; Weight: 3.57039 kg; Net volume: 0.000454826 m3; Gross volume: 0.000454826 m3; Gross footprint area: 0.0017195 m2; Area per tons: 28.3049 m2; Net surface area: 0.101059 m2; Gross area: 0.0481841 m2; Height: 172.008 mm; Width: 10 mm; Length: 280.127 mm; sets with these values: 2

# IfcPlate: PL10*176 (2)
In: Undefined
Description: PL10*176; Material: STEEL/E24-2
Tekla Common - Center of gravity Y: 10062.7 mm; Part mark: 248; Assembly mark: K59; Phase: 1; Class: 1010; Finish: GRENAILLE-PEINT; Grade: E24-2; Profile: PL10*176; sets with these values: 2
Tekla Quantity - Gross footprint area: 0 m2; Width: 10 mm; sets with these values: 2
Name | Center of gravity Z (mm) | Center of gravity X (mm) | Bottom elevation | Top elevation | Net weight (kg) = Weight (kg) | Gross weight (kg) | Net volume (m3) = Gross volume (m3) | Area per tons (m2) | Net surface area (m2) | Gross area (m2) | Height (mm) | Length (mm)
 | 4879.77 | 79054.3 | +4.869 | +4.889 | 1.91859 | 3.83718 | 0.000244406 | 29.5535 | 0.0567009 | 0.0488812 | 176.415 | 277.08
 | 5101.7 | 71895.1 | +5.092 | +5.113 | 1.91863 | 3.83726 | 0.000244412 | 29.5534 | 0.0567021 | 0.0488823 | 176.416 | 277.085

# IfcPlate: PL10*178, GOUSSET
In: Undefined
Description: PL10*178; Material: STEEL/E24-2
Tekla Common - Center of gravity Z: 5531.62 mm; Center of gravity Y: 47776.6 mm; Center of gravity X: 20850 mm; Bottom elevation: +5.415; Top elevation: +5.593; Part mark: 254; Assembly mark: N46; Phase: 2; Class: 2006; Finish: GRENAILLE-PEINT; Grade: E24-2; Profile: PL10*178; Name: GOUSSET; sets with these values: 2
Tekla Quantity - Net weight: 3.96216 kg; Gross weight: 7.17803 kg; Weight: 3.96216 kg; Net volume: 0.000504734 m3; Gross volume: 0.000504734 m3; Gross footprint area: 0.00512829 m2; Area per tons: 28.548 m2; Net surface area: 0.113112 m2; Gross area: 0.0914399 m2; Height: 178.305 mm; Width: 10 mm; Length: 512.829 mm; sets with these values: 2

# IfcPlate: PL10*179 (19)
In: Undefined
Description: PL10*179; Material: STEEL/E24-2
Tekla Common - Center of gravity Z: 4325.52 mm; Bottom elevation: +4.237; Top elevation: +4.416; Part mark: 263; Finish: GRENAILLE-PEINT; Grade: E24-2; Profile: PL10*179; Name: GOUSSET; sets with these values: 2
Tekla Quantity - Net weight: 5.08796 kg; Gross weight: 5.17896 kg; Weight: 5.08796 kg; Net volume: 0.000648147 m3; Gross volume: 0.000648147 m3; Gross footprint area: 0.00330386 m2; Area per tons: 27.565 m2; Net surface area: 0.14025 m2; Gross area: 0.065974 m2; Height: 179.305 mm; Width: 10 mm; Length: 367.942 mm; sets with these values: 2
Name | Center of gravity Y (mm) | Center of gravity X (mm) | Assembly mark | Phase | Class
GOUSSET | 45779.7 | 20850 | N46 | 2 | 2006
GOUSSET | 42520.3 | 20850 | N46 | 2 | 2006
GOUSSET | 42520.3 | 32525 | N43 | 3 | 3003
GOUSSET | 37979.7 | 20850 | N44 | 2 | 2006
GOUSSET | 21720.3 | 20850 | N45 | 2 | 2006
GOUSSET | 37979.7 | 67550 | N7 | 1 | 1006
GOUSSET | 42520.3 | 67550 | N6 | 1 | 1006
GOUSSET | 58779.7 | 67550 | N13 | 1 | 1006
GOUSSET | 21720.3 | 67550 | N11 | 1 | 1006
GOUSSET | 37979.7 | 55875 | N8 | 1 | 1006
GOUSSET | 42520.3 | 55875 | N41 | 1 | 1006
GOUSSET | 58779.7 | 55875 | N13 | 1 | 1006
GOUSSET | 21720.3 | 55875 | N10 | 1 | 1006
GOUSSET | 37979.7 | 32525 | N40 | 3 | 3006
GOUSSET | 21720.3 | 32525 | N9 | 3 | 3006
GOUSSET | 42520.3 | 44200 | N41 | 1 | 1006
GOUSSET | 58779.7 | 44200 | N42 | 1 | 1006
GOUSSET | 21720.3 | 44200 | N10 | 1 | 1006
GOUSSET | 37979.7 | 44200 | N8 | 1 | 1006

# IfcPlate: PL10*181 (3)
In: Undefined
Description: PL10*181; Material: STEEL/E24-2
Tekla Common - Center of gravity Z: 5527.76 mm; Center of gravity Y: 60710.2 mm; Bottom elevation: +5.406; Top elevation: +5.593; Part mark: 300; Phase: 1; Class: 1006; Finish: GRENAILLE-PEINT; Grade: E24-2; Profile: PL10*181; Name: GOUSSET; sets with these values: 2
Tekla Quantity - Net weight: 2.66834 kg; Gross weight: 4.93496 kg; Weight: 2.66834 kg; Net volume: 0.000339917 m3; Gross volume: 0.000339917 m3; Gross footprint area: 0.00336646 m2; Area per tons: 28.7904 m2; Net surface area: 0.0768227 m2; Gross area: 0.0628658 m2; Height: 180.617 mm; Width: 10 mm; Length: 348.061 mm; sets with these values: 2
Name | Center of gravity X (mm) | Assembly mark
GOUSSET | 67550 | N13
GOUSSET | 55875 | N13
GOUSSET | 44200 | N42

# IfcPlate: PL10*200 (20)
In: Undefined
Description: PL10*200; Material: STEEL/E36-3
Tekla Common - Center of gravity Z: 5525.44 mm; Bottom elevation: +5.393; Top elevation: +5.593; Finish: GRENAILLE-PEINT; Grade: E36-3; Profile: PL10*200; Name: PLAT; sets with these values: 2
Tekla Quantity - Gross footprint area: 0.0076 m2; Width: 10 mm; Length: 770 mm; sets with these values: 2
Name | Center of gravity Y (mm) | Center of gravity X (mm) | Part mark | Assembly mark | Phase | Class | Net weight (kg) = Weight (kg) | Gross weight (kg) | Net volume (m3) = Gross volume (m3) | Area per tons (m2) | Net surface area (m2) | Gross area (m2) | Height (mm)
PLAT | 40543.4 | 44200 | 219 | N41 | 1 | 1006 | 6.27274 | 12.1006 | 0.000799076 | 28.2821 | 0.177407 | 0.154148 | 200.192
PLAT | 40543.4 | 20850 | 219 | N46 | 2 | 2006 | 6.27274 | 12.1006 | 0.000799076 | 28.2821 | 0.177407 | 0.154148 | 200.192
PLAT | 39956.7 | 32525 | 219 | N40 | 3 | 3006 | 6.26939 | 12.1005 | 0.000798649 | 28.2835 | 0.17732 | 0.154147 | 200.19
PLAT | 39956.7 | 20850 | 219 | N44 | 2 | 2006 | 6.26939 | 12.1005 | 0.000798649 | 28.2835 | 0.17732 | 0.154147 | 200.19
PLAT | 19743.4 | 20850 | 219 | N45 | 2 | 2006 | 6.27274 | 12.1006 | 0.000799076 | 28.2821 | 0.177407 | 0.154148 | 200.192
PLAT | 19156.7 | 20850 | 219 | N49 | 2 | 2006 | 6.26939 | 12.1005 | 0.000798649 | 28.2835 | 0.17732 | 0.154147 | 200.19
PLAT | 39956.6 | 67550 | 219 | N7 | 1 | 1006 | 6.27274 | 12.1006 | 0.000799075 | 28.2821 | 0.177407 | 0.154148 | 200.192
PLAT | 40543.4 | 67550 | 219 | N6 | 1 | 1006 | 6.27274 | 12.1006 | 0.000799076 | 28.2821 | 0.177407 | 0.154148 | 200.192
PLAT | 19156.6 | 67550 | 223 | N12 | 1 | 1006 | 6.27274 | 12.1006 | 0.000799075 | 28.2821 | 0.177407 | 0.154148 | 200.192
PLAT | 19743.4 | 67550 | 219 | N11 | 1 | 1006 | 6.27274 | 12.1006 | 0.000799076 | 28.2821 | 0.177407 | 0.154148 | 200.192
PLAT | 39956.6 | 55875 | 219 | N8 | 1 | 1006 | 6.27274 | 12.1006 | 0.000799075 | 28.2821 | 0.177407 | 0.154148 | 200.192
PLAT | 40543.4 | 55875 | 219 | N41 | 1 | 1006 | 6.27274 | 12.1006 | 0.000799076 | 28.2821 | 0.177407 | 0.154148 | 200.192
PLAT | 40543.4 | 32525 | 220 | N43 | 3 | 3003 | 6.27274 | 12.1006 | 0.000799076 | 28.2821 | 0.177407 | 0.154148 | 200.192
PLAT | 19743.4 | 32525 | 219 | N9 | 3 | 3006 | 6.27274 | 12.1006 | 0.000799076 | 28.2821 | 0.177407 | 0.154148 | 200.192
PLAT | 19156.7 | 32525 | 219 | N48 | 3 | 3006 | 6.26939 | 12.1005 | 0.000798649 | 28.2835 | 0.17732 | 0.154147 | 200.19
PLAT | 19743.4 | 44200 | 219 | N10 | 1 | 1006 | 6.27274 | 12.1006 | 0.000799076 | 28.2821 | 0.177407 | 0.154148 | 200.192
PLAT | 19156.6 | 44200 | 219 | N47 | 1 | 1006 | 6.27274 | 12.1006 | 0.000799075 | 28.2821 | 0.177407 | 0.154148 | 200.192
PLAT | 39956.6 | 44200 | 219 | N8 | 1 | 1006 | 6.27274 | 12.1006 | 0.000799075 | 28.2821 | 0.177407 | 0.154148 | 200.192
PLAT | 19743.4 | 55875 | 219 | N10 | 1 | 1006 | 6.27274 | 12.1006 | 0.000799076 | 28.2821 | 0.177407 | 0.154148 | 200.192
PLAT | 19156.6 | 55875 | 219 | N47 | 1 | 1006 | 6.27274 | 12.1006 | 0.000799075 | 28.2821 | 0.177407 | 0.154148 | 200.192

# IfcPlate: PL10*205, GOUSSET
In: Undefined
Description: PL10*205; Material: STEEL/E24-2
Tekla Common - Center of gravity Z: 4327.21 mm; Center of gravity Y: 48344.4 mm; Center of gravity X: 32525 mm; Bottom elevation: +4.237; Top elevation: +4.442; Part mark: 264; Assembly mark: N43; Phase: 3; Class: 3003; Finish: GRENAILLE-PEINT; Grade: E24-2; Profile: PL10*205; Name: GOUSSET; sets with these values: 2
Tekla Quantity - Net weight: 4.49208 kg; Gross weight: 5.92502 kg; Weight: 4.49208 kg; Net volume: 0.00057224 m3; Gross volume: 0.00057224 m3; Gross footprint area: 0.00176656 m2; Area per tons: 27.7673 m2; Net surface area: 0.124733 m2; Gross area: 0.0754779 m2; Height: 205.135 mm; Width: 10 mm; Length: 367.942 mm; sets with these values: 2

# IfcPlate: PL10*206, GOUSSET
In: Undefined
Description: PL10*206; Material: STEEL/E24-2
Tekla Common - Center of gravity Z: 5519.23 mm; Center of gravity Y: 49489.9 mm; Center of gravity X: 32525 mm; Bottom elevation: +5.387; Top elevation: +5.593; Part mark: 255; Assembly mark: N43; Phase: 3; Class: 3003; Finish: GRENAILLE-PEINT; Grade: E24-2; Profile: PL10*206; Name: GOUSSET; sets with these values: 2
Tekla Quantity - Net weight: 3.13115 kg; Gross weight: 5.35402 kg; Weight: 3.13115 kg; Net volume: 0.000398873 m3; Gross volume: 0.000398873 m3; Gross footprint area: 0.00331849 m2; Area per tons: 28.3932 m2; Net surface area: 0.0889033 m2; Gross area: 0.068204 m2; Height: 205.525 mm; Width: 10 mm; Length: 331.853 mm; sets with these values: 2

# IfcPlate: PL10*209 (16)
In: Undefined
Description: PL10*209; Material: STEEL/E24-2
Tekla Common - Finish: GRENAILLE-PEINT; Grade: E24-2; Profile: PL10*209; sets with these values: 2
Tekla Quantity - Gross footprint area: 0 m2; Width: 10 mm; sets with these values: 2
Name | Center of gravity Z (mm) | Center of gravity Y (mm) | Center of gravity X (mm) | Bottom elevation | Top elevation | Part mark | Assembly mark | Phase | Class | Name | Net weight (kg) = Weight (kg) | Gross weight (kg) | Net volume (m3) = Gross volume (m3) | Area per tons (m2) | Net surface area (m2) | Gross area (m2) | Height (mm) | Length (mm)
PLAT | 3476.45 | 13058.7 | 7467.39 | +3.467 | +3.487 | 267 | H84 | 2 | 2003 | PLAT | 3.09151 | 4.24351 | 0.000393824 | 27.9934 | 0.0865421 | 0.0540574 | 208.868 | 258.811
GOUSSET | 5422.95 | 40753.3 | 20850 | +5.307 | +5.523 | 299 | N46 | 2 | 2006 | GOUSSET | 2.78702 | 4.92737 | 0.000355035 | 28.551 | 0.0795723 | 0.062769 | 209.23 | 300
GOUSSET | 5422.95 | 40753.3 | 32525 | +5.307 | +5.523 | 299 | N43 | 3 | 3003 | GOUSSET | 2.78702 | 4.92737 | 0.000355035 | 28.551 | 0.0795723 | 0.062769 | 209.23 | 300
GOUSSET | 5422.95 | 39746.7 | 20850 | +5.307 | +5.523 | 299 | N44 | 2 | 2006 | GOUSSET | 2.78702 | 4.92737 | 0.000355035 | 28.551 | 0.0795723 | 0.062769 | 209.23 | 300
GOUSSET | 5422.95 | 19953.3 | 20850 | +5.307 | +5.523 | 299 | N45 | 2 | 2006 | GOUSSET | 2.78702 | 4.92737 | 0.000355035 | 28.551 | 0.0795723 | 0.062769 | 209.23 | 300
GOUSSET | 5422.95 | 39746.7 | 67550 | +5.307 | +5.523 | 299 | N7 | 1 | 1006 | GOUSSET | 2.78702 | 4.92737 | 0.000355035 | 28.551 | 0.0795723 | 0.062769 | 209.23 | 300
GOUSSET | 5422.95 | 40753.3 | 67550 | +5.307 | +5.523 | 299 | N6 | 1 | 1006 | GOUSSET | 2.78702 | 4.92737 | 0.000355035 | 28.551 | 0.0795723 | 0.062769 | 209.23 | 300
GOUSSET | 5422.95 | 19953.3 | 67550 | +5.307 | +5.523 | 299 | N11 | 1 | 1006 | GOUSSET | 2.78702 | 4.92737 | 0.000355035 | 28.551 | 0.0795723 | 0.062769 | 209.23 | 300
GOUSSET | 5422.95 | 39746.7 | 55875 | +5.307 | +5.523 | 299 | N8 | 1 | 1006 | GOUSSET | 2.78702 | 4.92737 | 0.000355035 | 28.551 | 0.0795723 | 0.062769 | 209.23 | 300
GOUSSET | 5422.95 | 40753.3 | 55875 | +5.307 | +5.523 | 299 | N41 | 1 | 1006 | GOUSSET | 2.78702 | 4.92737 | 0.000355035 | 28.551 | 0.0795723 | 0.062769 | 209.23 | 300
GOUSSET | 5422.95 | 19953.3 | 55875 | +5.307 | +5.523 | 299 | N10 | 1 | 1006 | GOUSSET | 2.78702 | 4.92737 | 0.000355035 | 28.551 | 0.0795723 | 0.062769 | 209.23 | 300
GOUSSET | 5422.95 | 39746.7 | 32525 | +5.307 | +5.523 | 299 | N40 | 3 | 3006 | GOUSSET | 2.78702 | 4.92737 | 0.000355035 | 28.551 | 0.0795723 | 0.062769 | 209.23 | 300
GOUSSET | 5422.95 | 19953.3 | 32525 | +5.307 | +5.523 | 299 | N9 | 3 | 3006 | GOUSSET | 2.78702 | 4.92737 | 0.000355035 | 28.551 | 0.0795723 | 0.062769 | 209.23 | 300
GOUSSET | 5422.95 | 40753.3 | 44200 | +5.307 | +5.523 | 299 | N41 | 1 | 1006 | GOUSSET | 2.78702 | 4.92737 | 0.000355035 | 28.551 | 0.0795723 | 0.062769 | 209.23 | 300
GOUSSET | 5422.95 | 39746.7 | 44200 | +5.307 | +5.523 | 299 | N8 | 1 | 1006 | GOUSSET | 2.78702 | 4.92737 | 0.000355035 | 28.551 | 0.0795723 | 0.062769 | 209.23 | 300
GOUSSET | 5422.95 | 19953.3 | 44200 | +5.307 | +5.523 | 299 | N10 | 1 | 1006 | GOUSSET | 2.78702 | 4.92737 | 0.000355035 | 28.551 | 0.0795723 | 0.062769 | 209.23 | 300

# IfcPlate: PL10*212, PLAT
In: Undefined
Description: PL10*212; Material: STEEL/E24-2
Tekla Common - Center of gravity Z: 3435.42 mm; Center of gravity Y: 10928.6 mm; Center of gravity X: 8639.64 mm; Bottom elevation: +3.426; Top elevation: +3.446; Part mark: 268; Assembly mark: H83; Phase: 2; Class: 2003; Finish: GRENAILLE-PEINT; Grade: E24-2; Profile: PL10*212; Name: PLAT; sets with these values: 2
Tekla Quantity - Net weight: 3.04947 kg; Gross weight: 4.22665 kg; Weight: 3.04947 kg; Net volume: 0.000388468 m3; Gross volume: 0.000388468 m3; Gross footprint area: 0 m2; Area per tons: 27.9982 m2; Net surface area: 0.0853797 m2; Gross area: 0.0538427 m2; Height: 212.401 mm; Width: 10 mm; Length: 253.496 mm; sets with these values: 2

# IfcPlate: PL10*220 (2)
In: Undefined
Description: PL10*220; Material: STEEL/E24-2
Tekla Common - Center of gravity Z: 5741.5 mm; Bottom elevation: +5.632; Top elevation: +5.852; Part mark: 188; Assembly mark: H2; Finish: GRENAILLE-PEINT; Grade: E24-2; Profile: PL10*220; Name: ATTACHE; sets with these values: 2
Tekla Quantity - Net weight: 4.23115 kg; Gross weight: 4.23115 kg; Weight: 4.23115 kg; Net volume: 0.000539 m3; Gross volume: 0.000539 m3; Gross footprint area: 0.00245 m2; Area per tons: 27.6757 m2; Net surface area: 0.1171 m2; Gross area: 0.0539 m2; Height: 220 mm; Width: 10 mm; Length: 245 mm; sets with these values: 2
Name | Center of gravity Y (mm) | Center of gravity X (mm) | Phase | Class
ATTACHE | 49597.5 | 32533 | 3 | 3006
ATTACHE | 48002.5 | 20842 | 2 | 2003

# IfcPlate: PL10*265
In: Undefined
Description: PL10*265; Material: STEEL/E24-2
Tekla Common - Center of gravity Z: 2278.4 mm; Center of gravity Y: -4.96004e-17 mm; Center of gravity X: 49902.5 mm; Bottom elevation: +2.078; Top elevation: +2.479; Part mark: 240; Assembly mark: P115; Phase: 1; Class: 1001; Finish: GRENAILLE-PEINT; Grade: E24-2; Profile: PL10*265; sets with these values: 2
Tekla Quantity - Net weight: 8.29007 kg; Gross weight: 8.313 kg; Weight: 8.29007 kg; Net volume: 0.00105606 m3; Gross volume: 0.00105606 m3; Gross footprint area: 0.0025369 m2; Area per tons: 27.0662 m2; Net surface area: 0.224381 m2; Gross area: 0.105898 m2; Height: 264.676 mm; Width: 10 mm; Length: 400.105 mm; sets with these values: 2

# IfcPlate: PL10*286
In: Undefined
Description: PL10*286; Material: STEEL/E24-2
Tekla Common - Center of gravity Z: 2267.32 mm; Center of gravity Y: 9.37846e-18 mm; Center of gravity X: 50168.4 mm; Bottom elevation: +2.078; Top elevation: +2.479; Part mark: 200; Assembly mark: P115; Phase: 1; Class: 1001; Finish: GRENAILLE-PEINT; Grade: E24-2; Profile: PL10*286; sets with these values: 2
Tekla Quantity - Net weight: 7.00483 kg; Gross weight: 8.98634 kg; Weight: 7.00483 kg; Net volume: 0.000892336 m3; Gross volume: 0.000892336 m3; Gross footprint area: 0 m2; Area per tons: 27.2219 m2; Net surface area: 0.190685 m2; Gross area: 0.114476 m2; Height: 286.11 mm; Width: 10 mm; Length: 400.11 mm; sets with these values: 2

# IfcPlate: PL10*308 (8)
In: Undefined
Description: PL10*308; Material: STEEL/E24-2
Tekla Common - Center of gravity Z: 5133.72 mm; Bottom elevation: +5.007; Top elevation: +5.317; Part mark: 206; Finish: GRENAILLE-PEINT; Grade: E24-2; Profile: PL10*308; Name: PLATINE; sets with these values: 2
Tekla Quantity - Gross footprint area: 0 m2; Area per tons: 27.2286 m2; Gross area: 0.605998 m2; Height: 307.764 mm; Width: 10 mm; Length: 1969.03 mm; sets with these values: 2
Name | Center of gravity Y (mm) | Center of gravity X (mm) | Assembly mark | Phase | Class | Net weight (kg) = Weight (kg) | Gross weight (kg) | Net volume (m3) = Gross volume (m3) | Net surface area (m2)
PLATINE | 19450 | 45248.5 | K21 | 1 | 1005 | 24.1507 | 47.5709 | 0.00307652 | 0.657588
PLATINE | 40250 | 45248.5 | K22 | 1 | 1005 | 24.1507 | 47.5709 | 0.00307652 | 0.657588
PLATINE | 40250 | 56923.5 | K24 | 1 | 1005 | 24.1507 | 47.5709 | 0.00307652 | 0.657588
PLATINE | 40250 | 33573.5 | K22 | 3 | 3005 | 24.1507 | 47.5709 | 0.00307652 | 0.657588
PLATINE | 19450 | 21898.5 | K21 | 3 | 3005 | 24.1503 | 47.5708 | 0.00307647 | 0.65758
PLATINE | 40250 | 21898.5 | K23 | 3 | 3005 | 24.1507 | 47.5709 | 0.00307652 | 0.657588
PLATINE | 19450 | 33573.5 | K21 | 3 | 3005 | 24.1507 | 47.5709 | 0.00307652 | 0.657588
PLATINE | 19450 | 56923.5 | K21 | 1 | 1005 | 24.1507 | 47.5709 | 0.00307652 | 0.657588

# IfcPlate: PL10*50 (5)
In: Undefined
Description: PL10*50; Material: STEEL/S235JR
Tekla Common - Center of gravity X: 79235 mm; Part mark: 244; Phase: 1; Class: 1011; Finish: GRENAILLE-PEINT; Grade: S235JR; Profile: PL10*50; Name: TOLE; sets with these values: 2
Tekla Quantity - Net weight: 0.688837 kg; Gross weight: 0.7065 kg; Weight: 0.688837 kg; Net volume: 0.00008775 m3; Gross volume: 0.00008775 m3; Gross footprint area: 0.008775 m2; Area per tons: 31.9005 m2; Net surface area: 0.0219743 m2; Gross area: 0.009 m2; Height: 50 mm; Width: 10 mm; Length: 180 mm; sets with these values: 2
Name | Center of gravity Z (mm) | Center of gravity Y (mm) | Bottom elevation | Top elevation | Assembly mark
TOLE | 4778.72 | 7678.31 | +4.774 | +4.784 | P6
TOLE | 4778.72 | 7621.69 | +4.774 | +4.784 | P6
TOLE | 4778.72 | 13521.7 | +4.774 | +4.784 | P8
TOLE | 3527.96 | 13578.3 | +3.523 | +3.533 | P8
TOLE | 3527.96 | 13521.7 | +3.523 | +3.533 | P8

# IfcPlate: PL10*70 (973)
In: Undefined
Description: PL10*70
Tekla Common - Profile: PL10*70; sets with these values: 2
Tekla Quantity - Width: 10 mm; sets with these values: 2
Name | Material | Center of gravity Z (mm) | Center of gravity Y (mm) | Center of gravity X (mm) | Bottom elevation | Top elevation | Part mark | Assembly mark | Phase | Class | Finish | Grade | Name | Net weight (kg) = Weight (kg) | Gross weight (kg) | Net volume (m3) = Gross volume (m3) | Gross footprint area (m2) | Area per tons (m2) | Net surface area (m2) | Gross area (m2) | Height (mm) | Length (mm)
PLATINE | STEEL/E36-3 | 3314.35 | -76.5 | 38400.9 | +3.309 | +3.319 | 179 | P114 | 3 | 3001 | GRENAILLE-PEINT | E36-3 | PLATINE | 1.50775 | 1.52541 | 0.00019207 | 0.019207 | 29.972 | 0.0451903 | 0.019432 | 70 | 277.6
PLATINE | STEEL/E36-3 | 3314.35 | -76.5 | 38324.1 | +3.309 | +3.319 | 179 | P114 | 3 | 3001 | GRENAILLE-PEINT | E36-3 | PLATINE | 1.50775 | 1.52541 | 0.00019207 | 0.019207 | 29.972 | 0.0451903 | 0.019432 | 70 | 277.6
PLATINE | STEEL/E36-3 | 3027.72 | -76.5 | 38400.9 | +3.023 | +3.033 | 179 | P114 | 3 | 3001 | GRENAILLE-PEINT | E36-3 | PLATINE | 1.50775 | 1.52541 | 0.00019207 | 0.019207 | 29.972 | 0.0451903 | 0.019432 | 70 | 277.6
PLATINE | STEEL/E36-3 | 3027.72 | -76.5 | 38324.1 | +3.023 | +3.033 | 179 | P114 | 3 | 3001 | GRENAILLE-PEINT | E36-3 | PLATINE | 1.50775 | 1.52541 | 0.00019207 | 0.019207 | 29.972 | 0.0451903 | 0.019432 | 70 | 277.6
PLATINE | STEEL/E36-3 | 2995 | -76.5 | 32486.6 | +2.990 | +3.000 | 185 | P113 | 3 | 3001 | GRENAILLE-PEINT | E36-3 | PLATINE | 1.50775 | 1.52541 | 0.00019207 | 0.019207 | 29.972 | 0.0451903 | 0.019432 | 70 | 277.6
PLATINE | STEEL/E36-3 | 3027.72 | -76.5 | 32563.4 | +3.023 | +3.033 | 179 | P113 | 3 | 3001 | GRENAILLE-PEINT | E36-3 | PLATINE | 1.50775 | 1.52541 | 0.00019207 | 0.019207 | 29.972 | 0.0451903 | 0.019432 | 70 | 277.6
PLATINE | STEEL/E36-3 | 3314.35 | -76.5 | 32486.6 | +3.309 | +3.319 | 179 | P113 | 3 | 3001 | GRENAILLE-PEINT | E36-3 | PLATINE | 1.50775 | 1.52541 | 0.00019207 | 0.019207 | 29.972 | 0.0451903 | 0.019432 | 70 | 277.6
PLATINE | STEEL/E36-3 | 3314.35 | -76.5 | 32563.4 | +3.309 | +3.319 | 179 | P113 | 3 | 3001 | GRENAILLE-PEINT | E36-3 | PLATINE | 1.50775 | 1.52541 | 0.00019207 | 0.019207 | 29.972 | 0.0451903 | 0.019432 | 70 | 277.6
PLATINE | STEEL/E36-3 | 2995 | -76.5 | 28594.6 | +2.990 | +3.000 | 185 | P121 | 3 | 3001 | GRENAILLE-PEINT | E36-3 | PLATINE | 1.50775 | 1.52541 | 0.00019207 | 0.019207 | 29.972 | 0.0451903 | 0.019432 | 70 | 277.6
PLATINE | STEEL/E36-3 | 2995 | -76.5 | 28671.4 | +2.990 | +3.000 | 185 | P121 | 3 | 3001 | GRENAILLE-PEINT | E36-3 | PLATINE | 1.50775 | 1.52541 | 0.00019207 | 0.019207 | 29.972 | 0.0451903 | 0.019432 | 70 | 277.6
PLATINE | STEEL/E36-3 | 3314.35 | -76.5 | 28594.6 | +3.309 | +3.319 | 179 | P121 | 3 | 3001 | GRENAILLE-PEINT | E36-3 | PLATINE | 1.50775 | 1.52541 | 0.00019207 | 0.019207 | 29.972 | 0.0451903 | 0.019432 | 70 | 277.6
PLATINE | STEEL/E36-3 | 3314.35 | -76.5 | 28671.4 | +3.309 | +3.319 | 179 | P121 | 3 | 3001 | GRENAILLE-PEINT | E36-3 | PLATINE | 1.50775 | 1.52541 | 0.00019207 | 0.019207 | 29.972 | 0.0451903 | 0.019432 | 70 | 277.6
PLATINE | STEEL/E36-3 | 2995 | -76.5 | 24780.4 | +2.990 | +3.000 | 185 | P120 | 3 | 3001 | GRENAILLE-PEINT | E36-3 | PLATINE | 1.50775 | 1.52541 | 0.00019207 | 0.019207 | 29.972 | 0.0451903 | 0.019432 | 70 | 277.6
PLATINE | STEEL/E36-3 | 2995 | -76.5 | 24703.6 | +2.990 | +3.000 | 185 | P120 | 3 | 3001 | GRENAILLE-PEINT | E36-3 | PLATINE | 1.50775 | 1.52541 | 0.00019207 | 0.019207 | 29.972 | 0.0451903 | 0.019432 | 70 | 277.6
PLATINE | STEEL/E36-3 | 3314.35 | -76.5 | 24703.6 | +3.309 | +3.319 | 179 | P120 | 3 | 3001 | GRENAILLE-PEINT | E36-3 | PLATINE | 1.50775 | 1.52541 | 0.00019207 | 0.019207 | 29.972 | 0.0451903 | 0.019432 | 70 | 277.6
PLATINE | STEEL/E36-3 | 3314.35 | -76.5 | 24780.4 | +3.309 | +3.319 | 179 | P120 | 3 | 3001 | GRENAILLE-PEINT | E36-3 | PLATINE | 1.50775 | 1.52541 | 0.00019207 | 0.019207 | 29.972 | 0.0451903 | 0.019432 | 70 | 277.6
PLATINE | STEEL/E36-3 | 3314.35 | -76.5 | 20811.6 | +3.309 | +3.319 | 179 | P119 | 2 | 2001 | GRENAILLE-PEINT | E36-3 | PLATINE | 1.50775 | 1.52541 | 0.00019207 | 0.019207 | 29.972 | 0.0451903 | 0.019432 | 70 | 277.6
PLATINE | STEEL/E36-3 | 3314.35 | -76.5 | 20888.4 | +3.309 | +3.319 | 179 | P119 | 2 | 2001 | GRENAILLE-PEINT | E36-3 | PLATINE | 1.50775 | 1.52541 | 0.00019207 | 0.019207 | 29.972 | 0.0451903 | 0.019432 | 70 | 277.6
PLATINE | STEEL/E36-3 | 3027.72 | -76.5 | 20811.6 | +3.023 | +3.033 | 179 | P119 | 2 | 2001 | GRENAILLE-PEINT | E36-3 | PLATINE | 1.50775 | 1.52541 | 0.00019207 | 0.019207 | 29.972 | 0.0451903 | 0.019432 | 70 | 277.6
PLAT | STEEL/E24-2 | 3649.03 | 32244.7 | 2536.66 | +3.643 | +3.655 | 196 | H82 | 2 | 2003 | GRENAILLE-PEINT | E24-2 | PLAT | 0.779239 | 0.779263 | 0.0000992661 | 0 | 30.9165 | 0.0240913 | 0.00992692 | 69.9057 | 142.004
PLATINE | STEEL/E36-3 | 5598 | -76.5 | 32486.6 | +5.593 | +5.603 | 179 | P113 | 3 | 3001 | GRENAILLE-PEINT | E36-3 | PLATINE | 1.50775 | 1.52541 | 0.00019207 | 0.019207 | 29.972 | 0.0451903 | 0.019432 | 70 | 277.6
PLATINE | STEEL/E36-3 | 5598 | -76.5 | 32563.4 | +5.593 | +5.603 | 179 | P113 | 3 | 3001 | GRENAILLE-PEINT | E36-3 | PLATINE | 1.50775 | 1.52541 | 0.00019207 | 0.019207 | 29.972 | 0.0451903 | 0.019432 | 70 | 277.6
PLATINE | STEEL/E36-3 | 4232 | -76.5 | 32486.6 | +4.227 | +4.237 | 179 | P113 | 3 | 3001 | GRENAILLE-PEINT | E36-3 | PLATINE | 1.50775 | 1.52541 | 0.00019207 | 0.019207 | 29.972 | 0.0451903 | 0.019432 | 70 | 277.6
PLATINE | STEEL/E36-3 | 4232 | -76.5 | 32563.4 | +4.227 | +4.237 | 179 | P113 | 3 | 3001 | GRENAILLE-PEINT | E36-3 | PLATINE | 1.50775 | 1.52541 | 0.00019207 | 0.019207 | 29.972 | 0.0451903 | 0.019432 | 70 | 277.6
PLATINE | STEEL/E36-3 | 3945 | -76.5 | 32486.6 | +3.940 | +3.950 | 179 | P113 | 3 | 3001 | GRENAILLE-PEINT | E36-3 | PLATINE | 1.50775 | 1.52541 | 0.00019207 | 0.019207 | 29.972 | 0.0451903 | 0.019432 | 70 | 277.6
PLATINE | STEEL/E36-3 | 3945 | -76.5 | 32563.4 | +3.940 | +3.950 | 179 | P113 | 3 | 3001 | GRENAILLE-PEINT | E36-3 | PLATINE | 1.50775 | 1.52541 | 0.00019207 | 0.019207 | 29.972 | 0.0451903 | 0.019432 | 70 | 277.6
PLAT | STEEL/E36-3 | 4088.5 | 45450 | 20888.9 | +3.950 | +4.227 | 222 | N46 | 2 | 2006 | GRENAILLE-PEINT | E36-3 | PLAT | 2.01837 | 2.08889 | 0.000257117 | 0 | 29.7642 | 0.0600752 | 0.0266101 | 70 | 380.144
PLAT | STEEL/E36-3 | 4088.5 | 45306.5 | 20888.4 | +3.950 | +4.227 | 221 | N46 | 2 | 2006 | GRENAILLE-PEINT | E36-3 | PLAT | 1.50225 | 1.51992 | 0.00019137 | 0.000549999 | 29.9751 | 0.0450302 | 0.019362 | 70 | 276.6
PLAT | STEEL/E36-3 | 4088.5 | 45306.5 | 20811.6 | +3.950 | +4.227 | 221 | N46 | 2 | 2006 | GRENAILLE-PEINT | E36-3 | PLAT | 1.50225 | 1.51992 | 0.00019137 | 0.000549999 | 29.9751 | 0.0450302 | 0.019362 | 70 | 276.6
PLAT | STEEL/E36-3 | 4088.5 | 45450 | 20811.1 | +3.950 | +4.227 | 222 | N46 | 2 | 2006 | GRENAILLE-PEINT | E36-3 | PLAT | 2.01837 | 2.08889 | 0.000257117 | 0 | 29.7642 | 0.0600752 | 0.0266101 | 70 | 380.144
PLAT | STEEL/E36-3 | 4088.5 | 45593.5 | 20888.4 | +3.950 | +4.227 | 221 | N46 | 2 | 2006 | GRENAILLE-PEINT | E36-3 | PLAT | 1.50225 | 1.51992 | 0.00019137 | 0.000549999 | 29.9751 | 0.0450302 | 0.019362 | 70 | 276.6
PLAT | STEEL/E36-3 | 4088.5 | 45593.5 | 20811.6 | +3.950 | +4.227 | 221 | N46 | 2 | 2006 | GRENAILLE-PEINT | E36-3 | PLAT | 1.50225 | 1.51992 | 0.00019137 | 0.000549999 | 29.9751 | 0.0450302 | 0.019362 | 70 | 276.6
PLAT | STEEL/E36-3 | 4088.5 | 42993.5 | 20811.6 | +3.950 | +4.227 | 221 | N46 | 2 | 2006 | GRENAILLE-PEINT | E36-3 | PLAT | 1.50225 | 1.51992 | 0.00019137 | 0.000549999 | 29.9751 | 0.0450302 | 0.019362 | 70 | 276.6
PLAT | STEEL/E36-3 | 4088.5 | 42993.5 | 20888.4 | +3.950 | +4.227 | 221 | N46 | 2 | 2006 | GRENAILLE-PEINT | E36-3 | PLAT | 1.50225 | 1.51992 | 0.00019137 | 0.000549999 | 29.9751 | 0.0450302 | 0.019362 | 70 | 276.6
PLAT | STEEL/E36-3 | 4088.5 | 42850 | 20811.1 | +3.950 | +4.227 | 222 | N46 | 2 | 2006 | GRENAILLE-PEINT | E36-3 | PLAT | 2.01837 | 2.08889 | 0.000257117 | 0 | 29.7642 | 0.0600752 | 0.0266101 | 70 | 380.144
PLAT | STEEL/E36-3 | 4088.5 | 42706.5 | 20811.6 | +3.950 | +4.227 | 221 | N46 | 2 | 2006 | GRENAILLE-PEINT | E36-3 | PLAT | 1.50225 | 1.51992 | 0.00019137 | 0.000549999 | 29.9751 | 0.0450302 | 0.019362 | 70 | 276.6
PLAT | STEEL/E36-3 | 4088.5 | 42706.5 | 20888.4 | +3.950 | +4.227 | 221 | N46 | 2 | 2006 | GRENAILLE-PEINT | E36-3 | PLAT | 1.50225 | 1.51992 | 0.00019137 | 0.000549999 | 29.9751 | 0.0450302 | 0.019362 | 70 | 276.6
PLAT | STEEL/E36-3 | 4088.5 | 42850 | 20888.9 | +3.950 | +4.227 | 222 | N46 | 2 | 2006 | GRENAILLE-PEINT | E36-3 | PLAT | 2.01837 | 2.08889 | 0.000257117 | 0 | 29.7642 | 0.0600752 | 0.0266101 | 70 | 380.144
PLAT | STEEL/E36-3 | 5741.5 | 42993.5 | 20811.6 | +5.603 | +5.880 | 221 | N46 | 2 | 2006 | GRENAILLE-PEINT | E36-3 | PLAT | 1.50225 | 1.51992 | 0.00019137 | 0.000549999 | 29.9751 | 0.0450302 | 0.019362 | 70 | 276.6
PLAT | STEEL/E36-3 | 5741.5 | 42993.5 | 20888.4 | +5.603 | +5.880 | 221 | N46 | 2 | 2006 | GRENAILLE-PEINT | E36-3 | PLAT | 1.50225 | 1.51992 | 0.00019137 | 0.000549999 | 29.9751 | 0.0450302 | 0.019362 | 70 | 276.6
PLAT | STEEL/E36-3 | 5741.5 | 42850 | 20811.1 | +5.603 | +5.880 | 222 | N46 | 2 | 2006 | GRENAILLE-PEINT | E36-3 | PLAT | 2.01837 | 2.08889 | 0.000257117 | 0 | 29.7642 | 0.0600752 | 0.0266101 | 70 | 380.144
PLAT | STEEL/E36-3 | 5741.5 | 42850 | 20888.9 | +5.603 | +5.880 | 222 | N46 | 2 | 2006 | GRENAILLE-PEINT | E36-3 | PLAT | 2.01837 | 2.08889 | 0.000257117 | 0 | 29.7642 | 0.0600752 | 0.0266101 | 70 | 380.144
PLAT | STEEL/E36-3 | 5741.5 | 42706.5 | 20811.6 | +5.603 | +5.880 | 221 | N46 | 2 | 2006 | GRENAILLE-PEINT | E36-3 | PLAT | 1.50225 | 1.51992 | 0.00019137 | 0.000549999 | 29.9751 | 0.0450302 | 0.019362 | 70 | 276.6
PLAT | STEEL/E36-3 | 5741.5 | 42706.5 | 20888.4 | +5.603 | +5.880 | 221 | N46 | 2 | 2006 | GRENAILLE-PEINT | E36-3 | PLAT | 1.50225 | 1.51992 | 0.00019137 | 0.000549999 | 29.9751 | 0.0450302 | 0.019362 | 70 | 276.6
PLAT | STEEL/E36-3 | 5741.5 | 45306.5 | 20888.4 | +5.603 | +5.880 | 221 | N46 | 2 | 2006 | GRENAILLE-PEINT | E36-3 | PLAT | 1.50225 | 1.51992 | 0.00019137 | 0.000549999 | 29.9751 | 0.0450302 | 0.019362 | 70 | 276.6
PLAT | STEEL/E36-3 | 5741.5 | 45306.5 | 20811.6 | +5.603 | +5.880 | 221 | N46 | 2 | 2006 | GRENAILLE-PEINT | E36-3 | PLAT | 1.50225 | 1.51992 | 0.00019137 | 0.000549999 | 29.9751 | 0.0450302 | 0.019362 | 70 | 276.6
PLAT | STEEL/E36-3 | 5741.5 | 45450 | 20888.9 | +5.603 | +5.880 | 222 | N46 | 2 | 2006 | GRENAILLE-PEINT | E36-3 | PLAT | 2.01837 | 2.08889 | 0.000257117 | 0 | 29.7642 | 0.0600752 | 0.0266101 | 70 | 380.144
PLAT | STEEL/E36-3 | 5741.5 | 45450 | 20811.1 | +5.603 | +5.880 | 222 | N46 | 2 | 2006 | GRENAILLE-PEINT | E36-3 | PLAT | 2.01837 | 2.08889 | 0.000257117 | 0 | 29.7642 | 0.0600752 | 0.0266101 | 70 | 380.144
PLAT | STEEL/E36-3 | 5741.5 | 45593.5 | 20888.4 | +5.603 | +5.880 | 221 | N46 | 2 | 2006 | GRENAILLE-PEINT | E36-3 | PLAT | 1.50225 | 1.51992 | 0.00019137 | 0.000549999 | 29.9751 | 0.0450302 | 0.019362 | 70 | 276.6
PLAT | STEEL/E36-3 | 5741.5 | 45593.5 | 20811.6 | +5.603 | +5.880 | 221 | N46 | 2 | 2006 | GRENAILLE-PEINT | E36-3 | PLAT | 1.50225 | 1.51992 | 0.00019137 | 0.000549999 | 29.9751 | 0.0450302 | 0.019362 | 70 | 276.6
PLAT | STEEL/E36-3 | 5741.5 | 42993.5 | 32486.6 | +5.603 | +5.880 | 302 | N43 | 3 | 3003 | GRENAILLE-PEINT | E36-3 | PLAT | 1.50225 | 1.51992 | 0.00019137 | 0.000549999 | 29.9751 | 0.0450302 | 0.019362 | 70 | 276.6
PLAT | STEEL/E36-3 | 5741.5 | 42993.5 | 32563.4 | +5.603 | +5.880 | 302 | N43 | 3 | 3003 | GRENAILLE-PEINT | E36-3 | PLAT | 1.50225 | 1.51992 | 0.00019137 | 0.000549999 | 29.9751 | 0.0450302 | 0.019362 | 70 | 276.6
PLAT | STEEL/E36-3 | 5741.5 | 42850 | 32486.1 | +5.603 | +5.880 | 303 | N43 | 3 | 3003 | GRENAILLE-PEINT | E36-3 | PLAT | 2.01837 | 2.08889 | 0.000257117 | 0 | 29.7642 | 0.0600752 | 0.0266101 | 70 | 380.144
PLAT | STEEL/E36-3 | 5741.5 | 42850 | 32563.9 | +5.603 | +5.880 | 303 | N43 | 3 | 3003 | GRENAILLE-PEINT | E36-3 | PLAT | 2.01837 | 2.08889 | 0.000257117 | 0 | 29.7642 | 0.0600752 | 0.0266101 | 70 | 380.144
PLAT | STEEL/E36-3 | 5741.5 | 42706.5 | 32486.6 | +5.603 | +5.880 | 302 | N43 | 3 | 3003 | GRENAILLE-PEINT | E36-3 | PLAT | 1.50225 | 1.51992 | 0.00019137 | 0.000549999 | 29.9751 | 0.0450302 | 0.019362 | 70 | 276.6
PLAT | STEEL/E36-3 | 5741.5 | 42706.5 | 32563.4 | +5.603 | +5.880 | 302 | N43 | 3 | 3003 | GRENAILLE-PEINT | E36-3 | PLAT | 1.50225 | 1.51992 | 0.00019137 | 0.000549999 | 29.9751 | 0.0450302 | 0.019362 | 70 | 276.6
PLAT | STEEL/E36-3 | 4088.5 | 42850 | 32563.9 | +3.950 | +4.227 | 303 | N43 | 3 | 3003 | GRENAILLE-PEINT | E36-3 | PLAT | 2.01837 | 2.08889 | 0.000257117 | 0 | 29.7642 | 0.0600752 | 0.0266101 | 70 | 380.144
PLAT | STEEL/E36-3 | 4088.5 | 42706.5 | 32563.4 | +3.950 | +4.227 | 302 | N43 | 3 | 3003 | GRENAILLE-PEINT | E36-3 | PLAT | 1.50225 | 1.51992 | 0.00019137 | 0.000549999 | 29.9751 | 0.0450302 | 0.019362 | 70 | 276.6
PLAT | STEEL/E36-3 | 4088.5 | 42706.5 | 32486.6 | +3.950 | +4.227 | 302 | N43 | 3 | 3003 | GRENAILLE-PEINT | E36-3 | PLAT | 1.50225 | 1.51992 | 0.00019137 | 0.000549999 | 29.9751 | 0.0450302 | 0.019362 | 70 | 276.6
PLAT | STEEL/E36-3 | 4088.5 | 42850 | 32486.1 | +3.950 | +4.227 | 303 | N43 | 3 | 3003 | GRENAILLE-PEINT | E36-3 | PLAT | 2.01837 | 2.08889 | 0.000257117 | 0 | 29.7642 | 0.0600752 | 0.0266101 | 70 | 380.144
PLAT | STEEL/E36-3 | 4088.5 | 42993.5 | 32563.4 | +3.950 | +4.227 | 302 | N43 | 3 | 3003 | GRENAILLE-PEINT | E36-3 | PLAT | 1.50225 | 1.51992 | 0.00019137 | 0.000549999 | 29.9751 | 0.0450302 | 0.019362 | 70 | 276.6
PLAT | STEEL/E36-3 | 4088.5 | 42993.5 | 32486.6 | +3.950 | +4.227 | 302 | N43 | 3 | 3003 | GRENAILLE-PEINT | E36-3 | PLAT | 1.50225 | 1.51992 | 0.00019137 | 0.000549999 | 29.9751 | 0.0450302 | 0.019362 | 70 | 276.6
PLAT | STEEL/E36-3 | 4088.5 | 45593.5 | 32486.6 | +3.950 | +4.227 | 302 | N43 | 3 | 3003 | GRENAILLE-PEINT | E36-3 | PLAT | 1.50225 | 1.51992 | 0.00019137 | 0.000549999 | 29.9751 | 0.0450302 | 0.019362 | 70 | 276.6
PLAT | STEEL/E36-3 | 4088.5 | 45593.5 | 32563.4 | +3.950 | +4.227 | 302 | N43 | 3 | 3003 | GRENAILLE-PEINT | E36-3 | PLAT | 1.50225 | 1.51992 | 0.00019137 | 0.000549999 | 29.9751 | 0.0450302 | 0.019362 | 70 | 276.6
PLAT | STEEL/E36-3 | 4088.5 | 45450 | 32486.1 | +3.950 | +4.227 | 303 | N43 | 3 | 3003 | GRENAILLE-PEINT | E36-3 | PLAT | 2.01837 | 2.08889 | 0.000257117 | 0 | 29.7642 | 0.0600752 | 0.0266101 | 70 | 380.144
PLAT | STEEL/E36-3 | 4088.5 | 45306.5 | 32486.6 | +3.950 | +4.227 | 302 | N43 | 3 | 3003 | GRENAILLE-PEINT | E36-3 | PLAT | 1.50225 | 1.51992 | 0.00019137 | 0.000549999 | 29.9751 | 0.0450302 | 0.019362 | 70 | 276.6
PLAT | STEEL/E36-3 | 4088.5 | 45306.5 | 32563.4 | +3.950 | +4.227 | 302 | N43 | 3 | 3003 | GRENAILLE-PEINT | E36-3 | PLAT | 1.50225 | 1.51992 | 0.00019137 | 0.000549999 | 29.9751 | 0.0450302 | 0.019362 | 70 | 276.6
PLAT | STEEL/E36-3 | 4088.5 | 45450 | 32563.9 | +3.950 | +4.227 | 303 | N43 | 3 | 3003 | GRENAILLE-PEINT | E36-3 | PLAT | 2.01837 | 2.08889 | 0.000257117 | 0 | 29.7642 | 0.0600752 | 0.0266101 | 70 | 380.144
PLAT | STEEL/E36-3 | 5741.5 | 45306.5 | 32563.4 | +5.603 | +5.880 | 302 | N43 | 3 | 3003 | GRENAILLE-PEINT | E36-3 | PLAT | 1.50225 | 1.51992 | 0.00019137 | 0.000549999 | 29.9751 | 0.0450302 | 0.019362 | 70 | 276.6
PLAT | STEEL/E36-3 | 5741.5 | 45306.5 | 32486.6 | +5.603 | +5.880 | 302 | N43 | 3 | 3003 | GRENAILLE-PEINT | E36-3 | PLAT | 1.50225 | 1.51992 | 0.00019137 | 0.000549999 | 29.9751 | 0.0450302 | 0.019362 | 70 | 276.6
PLAT | STEEL/E36-3 | 5741.5 | 45450 | 32563.9 | +5.603 | +5.880 | 303 | N43 | 3 | 3003 | GRENAILLE-PEINT | E36-3 | PLAT | 2.01837 | 2.08889 | 0.000257117 | 0 | 29.7642 | 0.0600752 | 0.0266101 | 70 | 380.144
PLAT | STEEL/E36-3 | 5741.5 | 45450 | 32486.1 | +5.603 | +5.880 | 303 | N43 | 3 | 3003 | GRENAILLE-PEINT | E36-3 | PLAT | 2.01837 | 2.08889 | 0.000257117 | 0 | 29.7642 | 0.0600752 | 0.0266101 | 70 | 380.144
PLAT | STEEL/E36-3 | 5741.5 | 45593.5 | 32563.4 | +5.603 | +5.880 | 302 | N43 | 3 | 3003 | GRENAILLE-PEINT | E36-3 | PLAT | 1.50225 | 1.51992 | 0.00019137 | 0.000549999 | 29.9751 | 0.0450302 | 0.019362 | 70 | 276.6
PLAT | STEEL/E36-3 | 5741.5 | 45593.5 | 32486.6 | +5.603 | +5.880 | 302 | N43 | 3 | 3003 | GRENAILLE-PEINT | E36-3 | PLAT | 1.50225 | 1.51992 | 0.00019137 | 0.000549999 | 29.9751 | 0.0450302 | 0.019362 | 70 | 276.6
PLAT | STEEL/E36-3 | 4088.5 | 47906.5 | 32563.4 | +3.950 | +4.227 | 302 | N43 | 3 | 3003 | GRENAILLE-PEINT | E36-3 | PLAT | 1.50225 | 1.51992 | 0.00019137 | 0.000549999 | 29.9751 | 0.0450302 | 0.019362 | 70 | 276.6
PLAT | STEEL/E36-3 | 4088.5 | 47906.5 | 32486.6 | +3.950 | +4.227 | 302 | N43 | 3 | 3003 | GRENAILLE-PEINT | E36-3 | PLAT | 1.50225 | 1.51992 | 0.00019137 | 0.000549999 | 29.9751 | 0.0450302 | 0.019362 | 70 | 276.6
PLAT | STEEL/E36-3 | 4088.5 | 48193.5 | 32563.4 | +3.950 | +4.227 | 302 | N43 | 3 | 3003 | GRENAILLE-PEINT | E36-3 | PLAT | 1.50225 | 1.51992 | 0.00019137 | 0.000549999 | 29.9751 | 0.0450302 | 0.019362 | 70 | 276.6
PLAT | STEEL/E36-3 | 4088.5 | 48193.5 | 32486.6 | +3.950 | +4.227 | 302 | N43 | 3 | 3003 | GRENAILLE-PEINT | E36-3 | PLAT | 1.50225 | 1.51992 | 0.00019137 | 0.000549999 | 29.9751 | 0.0450302 | 0.019362 | 70 | 276.6
PLAT | STEEL/E36-3 | 5741.5 | 47906.5 | 32486.6 | +5.603 | +5.880 | 302 | N43 | 3 | 3003 | GRENAILLE-PEINT | E36-3 | PLAT | 1.50225 | 1.51992 | 0.00019137 | 0.000549999 | 29.9751 | 0.0450302 | 0.019362 | 70 | 276.6
PLAT | STEEL/E36-3 | 5741.5 | 47906.5 | 32563.4 | +5.603 | +5.880 | 302 | N43 | 3 | 3003 | GRENAILLE-PEINT | E36-3 | PLAT | 1.50225 | 1.51992 | 0.00019137 | 0.000549999 | 29.9751 | 0.0450302 | 0.019362 | 70 | 276.6
PLAT | STEEL/E36-3 | 5741.5 | 48193.5 | 32486.6 | +5.603 | +5.880 | 302 | N43 | 3 | 3003 | GRENAILLE-PEINT | E36-3 | PLAT | 1.50225 | 1.51992 | 0.00019137 | 0.000549999 | 29.9751 | 0.0450302 | 0.019362 | 70 | 276.6
PLAT | STEEL/E36-3 | 5741.5 | 48193.5 | 32563.4 | +5.603 | +5.880 | 302 | N43 | 3 | 3003 | GRENAILLE-PEINT | E36-3 | PLAT | 1.50225 | 1.51992 | 0.00019137 | 0.000549999 | 29.9751 | 0.0450302 | 0.019362 | 70 | 276.6
PLAT | STEEL/E36-3 | 5741.5 | 21906.5 | 20888.4 | +5.603 | +5.880 | 221 | N45 | 2 | 2006 | GRENAILLE-PEINT | E36-3 | PLAT | 1.50225 | 1.51992 | 0.00019137 | 0.000549999 | 29.9751 | 0.0450302 | 0.019362 | 70 | 276.6
PLAT | STEEL/E36-3 | 5741.5 | 21906.5 | 20811.6 | +5.603 | +5.880 | 221 | N45 | 2 | 2006 | GRENAILLE-PEINT | E36-3 | PLAT | 1.50225 | 1.51992 | 0.00019137 | 0.000549999 | 29.9751 | 0.0450302 | 0.019362 | 70 | 276.6
PLAT | STEEL/E36-3 | 5741.5 | 22050 | 20888.9 | +5.603 | +5.880 | 222 | N45 | 2 | 2006 | GRENAILLE-PEINT | E36-3 | PLAT | 2.01837 | 2.08889 | 0.000257117 | 0 | 29.7642 | 0.0600752 | 0.0266101 | 70 | 380.144
PLAT | STEEL/E36-3 | 5741.5 | 22050 | 20811.1 | +5.603 | +5.880 | 222 | N45 | 2 | 2006 | GRENAILLE-PEINT | E36-3 | PLAT | 2.01837 | 2.08889 | 0.000257117 | 0 | 29.7642 | 0.0600752 | 0.0266101 | 70 | 380.144
PLAT | STEEL/E36-3 | 5741.5 | 22193.5 | 20888.4 | +5.603 | +5.880 | 221 | N45 | 2 | 2006 | GRENAILLE-PEINT | E36-3 | PLAT | 1.50225 | 1.51992 | 0.00019137 | 0.000549999 | 29.9751 | 0.0450302 | 0.019362 | 70 | 276.6
PLAT | STEEL/E36-3 | 5741.5 | 22193.5 | 20811.6 | +5.603 | +5.880 | 221 | N45 | 2 | 2006 | GRENAILLE-PEINT | E36-3 | PLAT | 1.50225 | 1.51992 | 0.00019137 | 0.000549999 | 29.9751 | 0.0450302 | 0.019362 | 70 | 276.6
