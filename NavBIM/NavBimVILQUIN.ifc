Properties of the parts of a building model (IFC2X3), part 4 of 32

# IfcBeam: L50*5 (452)
Name | Center of gravity Z (mm) | Center of gravity Y (mm) | Center of gravity X (mm) | Bottom elevation | Top elevation | Part mark | Assembly mark | Phase | Class | Name | Net weight (kg) = NetWeight (kg) | Gross weight (kg) = Weight (kg) | Net volume (m3) = NetVolume (m3) | Gross volume (m3) | Net surface area (m2) | Gross area (m2) = OuterSurfaceArea (m2) | Tekla Quantity, Length (mm) = BaseQuantities, Length (mm)
CSV | 4961.71 | 57160.2 | 60259.9 | +4.761 | +5.143 | C25 | C25 | 1 | 1004 | CSV | 13.4424 | 13.5688 | 0.00171241 | 0.00172851 | 0.721964 | 0.698608 | 3601.07
CSV | 5323.58 | 44163 | 57297.1 | +5.122 | +5.506 | C28 | C28 | 1 | 1004 | CSV | 13.7034 | 13.8326 | 0.00174566 | 0.00176211 | 0.735964 | 0.712188 | 3671.07
CSV | 4961.71 | 36360.2 | 60259.9 | +4.761 | +5.143 | C25 | C25 | 1 | 1004 | CSV | 13.4424 | 13.5688 | 0.00171241 | 0.00172851 | 0.721964 | 0.698608 | 3601.07
CSV | 5323.58 | 25937 | 57297.1 | +5.122 | +5.506 | C28 | C28 | 1 | 1004 | CSV | 13.7034 | 13.8326 | 0.00174566 | 0.00176211 | 0.735964 | 0.712188 | 3671.07
CSV | 5323.58 | 23363 | 57297.1 | +5.122 | +5.506 | C28 | C28 | 1 | 1004 | CSV | 13.7034 | 13.8326 | 0.00174566 | 0.00176211 | 0.735964 | 0.712188 | 3671.07
CSV | 4961.18 | 20719.9 | 60264.2 | +4.760 | +5.143 | C29 | C29 | 1 | 1004 | CSV | 13.6661 | 13.7949 | 0.00174091 | 0.00175731 | 0.733964 | 0.710248 | 3661.07
CSV | 4958.46 | 18281.3 | 60286.5 | +4.756 | +5.141 | C24 | C24 | 1 | 1004 | CSV | 13.0521 | 13.1744 | 0.00166268 | 0.00167826 | 0.701027 | 0.678298 | 3496.38
CSV | 5321.58 | 15877.4 | 57313.5 | +5.120 | +5.504 | C24 | C24 | 1 | 1004 | CSV | 13.0521 | 13.1744 | 0.00166268 | 0.00167826 | 0.701027 | 0.678298 | 3496.38
CSV | 5321.58 | 13582.6 | 57313.5 | +5.120 | +5.504 | C24 | C24 | 1 | 1004 | CSV | 13.0521 | 13.1744 | 0.00166268 | 0.00167826 | 0.701027 | 0.678298 | 3496.38
CSV | 4961.77 | 11200.7 | 60259.4 | +4.763 | +5.141 | C30 | C30 | 1 | 1004 | CSV | 12.791 | 12.9106 | 0.00162943 | 0.00164466 | 0.687027 | 0.664718 | 3426.38
CSV | 4961.77 | 8819.35 | 60259.4 | +4.763 | +5.141 | C30 | C30 | 1 | 1004 | CSV | 12.791 | 12.9106 | 0.00162943 | 0.00164466 | 0.687027 | 0.664718 | 3426.38
CSV | 5321.43 | 6341.75 | 57314.8 | +5.118 | +5.505 | C22 | C22 | 1 | 1004 | CSV | 13.5806 | 13.7085 | 0.00173001 | 0.0017463 | 0.729376 | 0.705798 | 3638.13
CSV | 5321.43 | 3858.25 | 57314.8 | +5.118 | +5.505 | C22 | C22 | 1 | 1004 | CSV | 13.5806 | 13.7085 | 0.00173001 | 0.0017463 | 0.729376 | 0.705798 | 3638.13
CSV | 4961.72 | 1285.32 | 60259.8 | +4.762 | +5.142 | C23 | C23 | 1 | 1004 | CSV | 13.3196 | 13.4447 | 0.00169676 | 0.0017127 | 0.715376 | 0.692218 | 3568.13
CSV | 4643.8 | 3814.68 | 63165.2 | +4.463 | +4.844 | C54 | C54 | 1 | 1004 | CSV | 13.3196 | 13.4447 | 0.00169676 | 0.0017127 | 0.715376 | 0.692218 | 3568.13
CSV | 4607.39 | 3814.68 | 63160.8 | +4.409 | +4.786 | C54 | C54 | 1 | 1004 | CSV | 13.3196 | 13.4447 | 0.00169676 | 0.0017127 | 0.715376 | 0.692218 | 3568.13
CSV | 4284.1 | 1241.75 | 66110.2 | +4.100 | +4.487 | C55 | C55 | 1 | 1004 | CSV | 13.5806 | 13.7085 | 0.00173001 | 0.0017463 | 0.729376 | 0.705798 | 3638.13
CSV | 4247.69 | 1241.75 | 66105.8 | +4.046 | +4.430 | C55 | C55 | 1 | 1004 | CSV | 13.5806 | 13.7085 | 0.00173001 | 0.0017463 | 0.729376 | 0.705798 | 3638.13
CSV | 4961.72 | 3814.68 | 60259.8 | +4.762 | +5.142 | C54 | C54 | 1 | 1004 | CSV | 13.3196 | 13.4447 | 0.00169676 | 0.0017127 | 0.715376 | 0.692218 | 3568.13
CSV | 4998.13 | 3814.68 | 60264.2 | +4.819 | +5.196 | C54 | C54 | 1 | 1004 | CSV | 13.3196 | 13.4447 | 0.00169676 | 0.0017127 | 0.715376 | 0.692218 | 3568.13
CSV | 5321.43 | 1241.75 | 57314.8 | +5.118 | +5.505 | C55 | C55 | 1 | 1004 | CSV | 13.5806 | 13.7085 | 0.00173001 | 0.0017463 | 0.729376 | 0.705798 | 3638.13
CSV | 5357.84 | 1241.75 | 57319.2 | +5.176 | +5.559 | C55 | C55 | 1 | 1004 | CSV | 13.5806 | 13.7085 | 0.00173001 | 0.0017463 | 0.729376 | 0.705798 | 3638.13
CSV | 4961.71 | 33739.8 | 60259.9 | +4.761 | +5.143 | C25 | C25 | 1 | 1004 | CSV | 13.4424 | 13.5688 | 0.00171241 | 0.00172851 | 0.721964 | 0.698608 | 3601.07
CSV | 4961.71 | 54539.8 | 60259.9 | +4.761 | +5.143 | C25 | C25 | 1 | 1004 | CSV | 13.4424 | 13.5688 | 0.00171241 | 0.00172851 | 0.721964 | 0.698608 | 3601.07
CSV | 4961.71 | 49339.8 | 60259.9 | +4.761 | +5.143 | C25 | C25 | 1 | 1004 | CSV | 13.4424 | 13.5688 | 0.00171241 | 0.00172851 | 0.721964 | 0.698608 | 3601.07
CSV | 5321.58 | 15877.4 | 33963.5 | +5.120 | +5.504 | C24 | C24 | 3 | 3004 | CSV | 13.0521 | 13.1744 | 0.00166268 | 0.00167826 | 0.701027 | 0.678298 | 3496.38
CSV | 4961.77 | 13539.3 | 36909.4 | +4.763 | +5.141 | C30 | C30 | 3 | 3004 | CSV | 12.791 | 12.9106 | 0.00162943 | 0.00164466 | 0.687027 | 0.664718 | 3426.38
CSV | 5321.58 | 13582.6 | 33963.5 | +5.120 | +5.504 | C24 | C24 | 3 | 3004 | CSV | 13.0521 | 13.1744 | 0.00166268 | 0.00167826 | 0.701027 | 0.678298 | 3496.38
CSV | 4212.45 | 65083.7 | 42772.1 | +4.009 | +4.397 | C31 | C31 | 3 | 3004 | CSV | 13.9456 | 14.0773 | 0.00177651 | 0.00179329 | 0.748953 | 0.724787 | 3736.02
CSV | 4572.9 | 67809.5 | 39821 | +4.373 | +4.754 | C32 | C32 | 3 | 3004 | CSV | 13.6734 | 13.8022 | 0.00174183 | 0.00175825 | 0.734353 | 0.710625 | 3663.02
CSV | 4214.82 | 67835.4 | 42752.6 | +4.013 | +4.397 | C33 | C33 | 3 | 3004 | CSV | 13.9344 | 14.066 | 0.00177508 | 0.00179185 | 0.748353 | 0.724205 | 3733.02
CSV | 4574.43 | 65107.9 | 39808.5 | +4.376 | +4.753 | C34 | C34 | 3 | 3004 | CSV | 13.6547 | 13.7834 | 0.00173946 | 0.00175585 | 0.733353 | 0.709655 | 3658.02
CSV | 5266.97 | 65107.7 | 34138.5 | +5.075 | +5.439 | C43 | C43 | 3 | 3004 | CSV | 13.3483 | 13.4737 | 0.00170042 | 0.0017164 | 0.716915 | 0.69371 | 3575.83
CSV | 4922.33 | 65107.7 | 36960.1 | +4.729 | +5.097 | C43 | C43 | 3 | 3004 | CSV | 13.3483 | 13.4737 | 0.00170042 | 0.0017164 | 0.716915 | 0.693711 | 3575.83
CSV | 5265.43 | 67807.7 | 34151.1 | +5.072 | +5.440 | C42 | C42 | 3 | 3004 | CSV | 13.3592 | 13.4847 | 0.0017018 | 0.0017178 | 0.717499 | 0.694276 | 3578.74
CSV | 4961.71 | 31160.2 | 36909.9 | +4.761 | +5.143 | C25 | C25 | 3 | 3004 | CSV | 13.4424 | 13.5688 | 0.00171241 | 0.00172851 | 0.721964 | 0.698608 | 3601.07
CSV | 4961.71 | 33739.8 | 36909.9 | +4.761 | +5.143 | C25 | C25 | 3 | 3004 | CSV | 13.4424 | 13.5688 | 0.00171241 | 0.00172851 | 0.721964 | 0.698608 | 3601.07
CSV | 5320.4 | 18294.7 | 33973.2 | +5.120 | +5.502 | C35 | C35 | 3 | 3004 | CSV | 12.9588 | 13.0802 | 0.00165081 | 0.00166626 | 0.696027 | 0.673448 | 3471.38
CSV | 4958.46 | 18281.3 | 36936.5 | +4.756 | +5.141 | C24 | C24 | 3 | 3004 | CSV | 13.0521 | 13.1744 | 0.00166268 | 0.00167826 | 0.701027 | 0.678298 | 3496.38
CSV | 4961.72 | 1285.32 | 25234.8 | +4.762 | +5.142 | C23 | C23 | 3 | 3004 | CSV | 13.3196 | 13.4447 | 0.00169676 | 0.0017127 | 0.715376 | 0.692218 | 3568.13
CSV | 5356.47 | 1251.58 | 22305.5 | +5.176 | +5.557 | C56 | C56 | 3 | 3004 | CSV | 13.4687 | 13.5954 | 0.00171576 | 0.0017319 | 0.723376 | 0.699978 | 3608.13
CSV | 5320.05 | 1251.58 | 22301 | +5.118 | +5.503 | C56 | C56 | 3 | 3004 | CSV | 13.4687 | 13.5954 | 0.00171576 | 0.0017319 | 0.723376 | 0.699978 | 3608.13
CSV | 5321.43 | 3858.25 | 22289.8 | +5.118 | +5.505 | C22 | C22 | 3 | 3004 | CSV | 13.5806 | 13.7085 | 0.00173001 | 0.0017463 | 0.729376 | 0.705798 | 3638.13
CSV | 5142.83 | 41516.4 | 23752 | +4.761 | +5.504 | C48 | C48 | 3 | 3004 | CSV | 23.2299 | 23.4593 | 0.00295922 | 0.00298845 | 1.24694 | 1.20783 | 6225.94
CSV | 3472.12 | 30918.3 | 8144.06 | +3.420 | +3.545 | C51 | C51 | 2 | 2004 | CSV | 12.1542 | 12.267 | 0.0015483 | 0.00156268 | 0.652867 | 0.631583 | 3255.58
CSV | 3553.45 | 33587.1 | 5820.31 | +3.501 | +3.626 | C51 | C51 | 2 | 2004 | CSV | 12.1542 | 12.267 | 0.0015483 | 0.00156268 | 0.652867 | 0.631583 | 3255.58
CSV | 3553.46 | 30900.4 | 5820.31 | +3.501 | +3.626 | C51 | C51 | 2 | 2004 | CSV | 12.1542 | 12.267 | 0.0015483 | 0.00156268 | 0.652867 | 0.631583 | 3255.58
CSV | 3716.12 | 33587.1 | 1172.81 | +3.664 | +3.789 | C71 | C71 | 2 | 2004 | CSV | 12.1542 | 12.267 | 0.0015483 | 0.00156268 | 0.652867 | 0.631583 | 3255.58
CSV | 3679.46 | 33587.1 | 1171.53 | +3.606 | +3.732 | C71 | C71 | 2 | 2004 | CSV | 12.1542 | 12.267 | 0.0015483 | 0.00156268 | 0.652867 | 0.631583 | 3255.58
CSV | 3716.12 | 30900.4 | 1172.81 | +3.664 | +3.789 | C71 | C71 | 2 | 2004 | CSV | 12.1542 | 12.267 | 0.0015483 | 0.00156268 | 0.652867 | 0.631583 | 3255.58
CSV | 3679.46 | 30900.4 | 1171.53 | +3.606 | +3.732 | C71 | C71 | 2 | 2004 | CSV | 12.1542 | 12.267 | 0.0015483 | 0.00156268 | 0.652867 | 0.631583 | 3255.58
CSV | 3634.79 | 33569.2 | 3496.56 | +3.583 | +3.708 | C71 | C71 | 2 | 2004 | CSV | 12.1542 | 12.267 | 0.0015483 | 0.00156268 | 0.652867 | 0.631583 | 3255.58
CSV | 3598.13 | 33569.2 | 3495.28 | +3.525 | +3.651 | C71 | C71 | 2 | 2004 | CSV | 12.1542 | 12.267 | 0.0015483 | 0.00156268 | 0.652867 | 0.631583 | 3255.58
CSV | 3472.12 | 33569.2 | 8144.06 | +3.420 | +3.545 | C51 | C51 | 2 | 2004 | CSV | 12.1542 | 12.267 | 0.0015483 | 0.00156268 | 0.652867 | 0.631583 | 3255.58
CSV | 5344.36 | 30535.8 | 69104.6 | +5.267 | +5.441 | C86 | C86 | 1 | 1009 | CSV | 5.74931 | 5.79476 | 0.000732396 | 0.000738185 | 0.309327 | 0.29835 | 1537.89
CSV | 5434.32 | 31797.3 | 68065.5 | +5.340 | +5.510 | C87 | C87 | 1 | 1009 | CSV | 5.78276 | 5.82856 | 0.000736657 | 0.000742491 | 0.311121 | 0.30009 | 1546.86
CSV | 4908.7 | 33132.4 | 72368.9 | +4.771 | +5.027 | C93 | C93 | 1 | 1009 | CSV | 7.68438 | 7.7502 | 0.000978902 | 0.000987287 | 0.413119 | 0.399028 | 2056.85
CSV | 4945.11 | 33132.4 | 72373.3 | +4.825 | +5.085 | C93 | C93 | 1 | 1009 | CSV | 7.68438 | 7.7502 | 0.000978902 | 0.000987287 | 0.413119 | 0.399028 | 2056.85
CSV | 5202.76 | 26559.8 | 70263.9 | +5.132 | +5.292 | C88 | C88 | 1 | 1009 | CSV | 5.42452 | 5.46655 | 0.000691022 | 0.000696376 | 0.291907 | 0.281452 | 1450.78
CSV | 5337.16 | 27937.6 | 69163.6 | +5.258 | +5.436 | C91 | C91 | 1 | 1009 | CSV | 5.83792 | 5.8843 | 0.000743684 | 0.000749592 | 0.31408 | 0.30296 | 1561.65
CSV | 5299.46 | 25325.3 | 69169.6 | +5.204 | +5.376 | C89 | C89 | 1 | 1009 | CSV | 5.7167 | 5.7618 | 0.000728242 | 0.000733988 | 0.307578 | 0.296653 | 1529.14
CSV | 5335.87 | 25325.3 | 69174.1 | +5.258 | +5.433 | C89 | C89 | 1 | 1009 | CSV | 5.7167 | 5.7618 | 0.000728242 | 0.000733988 | 0.307578 | 0.296653 | 1529.14
CSV | 5368.75 | 28514.3 | 68602.3 | +5.209 | +5.509 | C65 | C65 | 1 | 1009 | CSV | 11.8677 | 11.9775 | 0.0015118 | 0.0015258 | 0.637499 | 0.616676 | 3178.74
CSV | 5431.87 | 29197.7 | 68085.6 | +5.335 | +5.510 | C92 | C92 | 1 | 1009 | CSV | 5.87514 | 5.92191 | 0.000748425 | 0.000754383 | 0.316076 | 0.304897 | 1571.63
CSV | 5054 | 25323.8 | 71179.3 | +4.967 | +5.123 | C88 | C88 | 1 | 1009 | CSV | 5.42452 | 5.46655 | 0.000691022 | 0.000696376 | 0.291907 | 0.281452 | 1450.78
CSV | 5188.08 | 62374.9 | 70384.1 | +4.834 | +5.562 | C95 | C95 | 1 | 1004 | CSV | 22.8613 | 23.0868 | 0.00291226 | 0.002941 | 1.22717 | 1.18865 | 6127.08
CSV | 5140.37 | 62412.4 | 70472.2 | +4.776 | +5.484 | C96 | C96 | 1 | 1004 | CSV | 22.1901 | 22.4086 | 0.00282676 | 0.00285459 | 1.19116 | 1.15373 | 5947.07
CSV | 5467 | 26585.4 | 68100.5 | +5.386 | +5.567 | C90 | C90 | 1 | 1009 | CSV | 5.99636 | 6.0444 | 0.000763867 | 0.000769988 | 0.322578 | 0.311203 | 1604.14
CSV | 5373.3 | 33714.1 | 68565.1 | +5.218 | +5.509 | C61 | C61 | 1 | 1009 | CSV | 11.6882 | 11.7962 | 0.00148895 | 0.0015027 | 0.627874 | 0.607341 | 3130.62
CSV | 4254.94 | 67779.6 | 77721.3 | +4.060 | +4.430 | C40 | C40 | 1 | 1009 | CSV | 13.3564 | 13.482 | 0.00170146 | 0.00171745 | 0.717353 | 0.694135 | 3578.02
CSV | 4607.43 | 67789.9 | 74835.5 | +4.409 | +4.787 | C27 | C27 | 1 | 1004 | CSV | 13.692 | 13.8211 | 0.00174421 | 0.00176065 | 0.735353 | 0.711595 | 3668.02
CSV | 3681.42 | 22936.9 | 73625.1 | +3.595 | +3.747 | C41 | C41 | 1 | 1009 | CSV | 14.2482 | 14.3831 | 0.00181505 | 0.00183224 | 0.765182 | 0.740529 | 3817.16
CSV | 3568.73 | 25020.2 | 77260.1 | +3.482 | +3.635 | C41 | C41 | 1 | 1009 | CSV | 14.2482 | 14.3831 | 0.00181505 | 0.00183224 | 0.765183 | 0.74053 | 3817.16
CSV | 3681.42 | 24996.5 | 73625.1 | +3.595 | +3.747 | C41 | C41 | 1 | 1009 | CSV | 14.2482 | 14.3831 | 0.00181505 | 0.00183224 | 0.765182 | 0.740529 | 3817.16
CSV | 3681.42 | 14603.5 | 73625.1 | +3.595 | +3.747 | C41 | C41 | 1 | 1009 | CSV | 14.2482 | 14.3831 | 0.00181505 | 0.00183224 | 0.765182 | 0.740529 | 3817.16
CSV | 3568.73 | 16686.8 | 77260.1 | +3.482 | +3.635 | C41 | C41 | 1 | 1009 | CSV | 14.2482 | 14.3831 | 0.00181505 | 0.00183224 | 0.765183 | 0.74053 | 3817.16
CSV | 5126.09 | 18298.3 | 68553.8 | +5.080 | +5.193 | C12 | C12 | 1 | 1009 | CSV | 11.094 | 11.1957 | 0.00141325 | 0.00142621 | 0.596003 | 0.576426 | 2971.27
CSV | 5089.42 | 18298.3 | 68552.7 | +5.023 | +5.135 | C12 | C12 | 1 | 1009 | CSV | 11.094 | 11.1957 | 0.00141325 | 0.00142621 | 0.596003 | 0.576426 | 2971.27
CSV | 5125.73 | 15894.8 | 68565.4 | +5.080 | +5.192 | C11 | C11 | 1 | 1009 | CSV | 10.9635 | 11.0638 | 0.00139663 | 0.00140941 | 0.589003 | 0.569635 | 2936.27
CSV | 5089.06 | 15894.8 | 68564.3 | +5.023 | +5.134 | C11 | C11 | 1 | 1009 | CSV | 10.9635 | 11.0638 | 0.00139663 | 0.00140941 | 0.589003 | 0.569635 | 2936.27
CSV | 5060.27 | 15904.7 | 70677 | +5.016 | +5.126 | C13 | C13 | 1 | 1009 | CSV | 10.6839 | 10.7813 | 0.001361 | 0.00137341 | 0.574003 | 0.555086 | 2861.27
CSV | 5023.6 | 15904.7 | 70675.9 | +4.959 | +5.068 | C13 | C13 | 1 | 1009 | CSV | 10.6839 | 10.7813 | 0.001361 | 0.00137341 | 0.574003 | 0.555086 | 2861.27
CSV | 5060.16 | 18279.1 | 70680.3 | +5.015 | +5.126 | C10 | C10 | 1 | 1009 | CSV | 10.7211 | 10.8189 | 0.00136575 | 0.00137821 | 0.576003 | 0.557026 | 2871.27
CSV | 5023.5 | 18279.1 | 70679.2 | +4.959 | +5.068 | C10 | C10 | 1 | 1009 | CSV | 10.7211 | 10.8189 | 0.00136575 | 0.00137821 | 0.576003 | 0.557026 | 2871.27
CSV | 5125.73 | 11174.8 | 68565.4 | +5.080 | +5.192 | C11 | C11 | 1 | 1009 | CSV | 10.9635 | 11.0638 | 0.00139663 | 0.00140941 | 0.589003 | 0.569636 | 2936.27
CSV | 5089.06 | 11174.8 | 68564.3 | +5.023 | +5.134 | C11 | C11 | 1 | 1009 | CSV | 10.9635 | 11.0638 | 0.00139663 | 0.00140941 | 0.589003 | 0.569636 | 2936.27
CSV | 5125.71 | 6358.55 | 68566 | +5.080 | +5.192 | C14 | C14 | 1 | 1009 | CSV | 11.5024 | 11.6084 | 0.00146527 | 0.00147878 | 0.617907 | 0.597672 | 3080.78
CSV | 5089.04 | 6358.55 | 68564.9 | +5.023 | +5.134 | C14 | C14 | 1 | 1009 | CSV | 11.5024 | 11.6084 | 0.00146527 | 0.00147878 | 0.617907 | 0.597672 | 3080.78
CSV | 5060.27 | 13555.3 | 70677 | +5.016 | +5.126 | C13 | C13 | 1 | 1009 | CSV | 10.6839 | 10.7813 | 0.001361 | 0.00137341 | 0.574003 | 0.555086 | 2861.27
CSV | 5023.6 | 13555.3 | 70675.9 | +4.959 | +5.068 | C13 | C13 | 1 | 1009 | CSV | 10.6839 | 10.7813 | 0.001361 | 0.00137341 | 0.574003 | 0.555086 | 2861.27
CSV | 5125.65 | 3837.6 | 68568 | +5.080 | +5.192 | C17 | C17 | 1 | 1009 | CSV | 11.5337 | 11.6401 | 0.00146927 | 0.00148281 | 0.619588 | 0.599303 | 3089.19
CSV | 5088.98 | 3837.6 | 68566.8 | +5.023 | +5.134 | C17 | C17 | 1 | 1009 | CSV | 11.5337 | 11.6401 | 0.00146927 | 0.00148281 | 0.619588 | 0.599303 | 3089.19
CSV | 5125.65 | 1262.4 | 68568 | +5.080 | +5.192 | C16 | C16 | 1 | 1009 | CSV | 11.5337 | 11.6401 | 0.00146927 | 0.00148281 | 0.619588 | 0.599303 | 3089.19
CSV | 5088.98 | 1262.4 | 68566.8 | +5.023 | +5.134 | C16 | C16 | 1 | 1009 | CSV | 11.5337 | 11.6401 | 0.00146927 | 0.00148281 | 0.619588 | 0.599303 | 3089.19
CSV | 5182.87 | 1266.34 | 70675.3 | +5.136 | +5.250 | C18 | C18 | 1 | 1009 | CSV | 11.9253 | 12.0357 | 0.00151914 | 0.00153321 | 0.640588 | 0.619673 | 3194.19
CSV | 5146.21 | 1266.34 | 70674.1 | +5.079 | +5.192 | C18 | C18 | 1 | 1009 | CSV | 11.9253 | 12.0357 | 0.00151914 | 0.00153321 | 0.640588 | 0.619673 | 3194.19
CSV | 5060.29 | 3833.65 | 70676.2 | +5.015 | +5.126 | C15 | C15 | 1 | 1009 | CSV | 11.3285 | 11.4327 | 0.00144313 | 0.0014564 | 0.608582 | 0.588627 | 3034.16
CSV | 5023.63 | 3833.65 | 70675 | +4.958 | +5.068 | C15 | C15 | 1 | 1009 | CSV | 11.3285 | 11.4327 | 0.00144313 | 0.0014564 | 0.608582 | 0.588627 | 3034.16
CSV | 5125.73 | 13565.2 | 68565.4 | +5.080 | +5.192 | C11 | C11 | 1 | 1009 | CSV | 10.9635 | 11.0639 | 0.00139663 | 0.00140941 | 0.589003 | 0.569636 | 2936.27
CSV | 5089.06 | 13565.2 | 68564.3 | +5.023 | +5.134 | C11 | C11 | 1 | 1009 | CSV | 10.9635 | 11.0639 | 0.00139663 | 0.00140941 | 0.589003 | 0.569636 | 2936.27
CSV | 5060.25 | 6366.33 | 70677.4 | +5.015 | +5.126 | C19 | C19 | 1 | 1009 | CSV | 11.2482 | 11.3515 | 0.00143289 | 0.00144605 | 0.604271 | 0.584445 | 3012.6
CSV | 5023.59 | 6366.33 | 70676.3 | +4.959 | +5.068 | C19 | C19 | 1 | 1009 | CSV | 11.2482 | 11.3515 | 0.00143289 | 0.00144605 | 0.604271 | 0.584445 | 3012.6
CSV | 5023.6 | 11184.7 | 70675.9 | +4.959 | +5.068 | C13 | C13 | 1 | 1009 | CSV | 10.6839 | 10.7813 | 0.001361 | 0.00137341 | 0.574003 | 0.555086 | 2861.27
CSV | 5060.27 | 11184.7 | 70677 | +5.016 | +5.126 | C13 | C13 | 1 | 1009 | CSV | 10.6839 | 10.7813 | 0.001361 | 0.00137341 | 0.574003 | 0.555086 | 2861.27
CSV | 5089.06 | 8845.24 | 68564.3 | +5.023 | +5.134 | C11 | C11 | 1 | 1009 | CSV | 10.9635 | 11.0639 | 0.00139663 | 0.00140941 | 0.589003 | 0.569636 | 2936.27
CSV | 5125.73 | 8845.24 | 68565.4 | +5.080 | +5.192 | C11 | C11 | 1 | 1009 | CSV | 10.9635 | 11.0639 | 0.00139663 | 0.00140941 | 0.589003 | 0.569636 | 2936.27
CSV | 4853.87 | 3796.83 | 77335.1 | +4.787 | +4.942 | C6 | C6 | 1 | 1009 | CSV | 15.2642 | 15.4098 | 0.00194449 | 0.00196303 | 0.819681 | 0.793393 | 4089.65
CSV | 4817.2 | 3796.83 | 77334 | +4.729 | +4.885 | C6 | C6 | 1 | 1009 | CSV | 15.2642 | 15.4098 | 0.00194449 | 0.00196303 | 0.819681 | 0.793393 | 4089.65
CSV | 4853.87 | 1303.16 | 77335.1 | +4.787 | +4.942 | C4 | C4 | 1 | 1009 | CSV | 15.2642 | 15.4098 | 0.00194448 | 0.00196303 | 0.819679 | 0.793391 | 4089.64
CSV | 4817.2 | 1303.16 | 77334 | +4.729 | +4.885 | C5 | C5 | 1 | 1009 | CSV | 15.2642 | 15.4098 | 0.00194448 | 0.00196303 | 0.819679 | 0.793391 | 4089.64
CSV | 4969.25 | 3836.28 | 73613.2 | +4.901 | +5.058 | C7 | C7 | 1 | 1009 | CSV | 15.4879 | 15.6359 | 0.00197298 | 0.00199183 | 0.831679 | 0.805031 | 4149.64
CSV | 4932.58 | 3836.28 | 73612 | +4.843 | +5.001 | C7 | C7 | 1 | 1009 | CSV | 15.4879 | 15.6359 | 0.00197298 | 0.00199183 | 0.831679 | 0.805031 | 4149.64
CSV | 4254.94 | 65120.4 | 77721.3 | +4.060 | +4.430 | C40 | C40 | 1 | 1009 | CSV | 13.3564 | 13.482 | 0.00170146 | 0.00171745 | 0.717353 | 0.694135 | 3578.02
CSV | 5300.74 | 27937.6 | 69159.1 | +5.204 | +5.378 | C91 | C91 | 1 | 1009 | CSV | 5.83792 | 5.8843 | 0.000743684 | 0.000749592 | 0.31408 | 0.30296 | 1561.65
CSV | 5307.94 | 30535.8 | 69100.2 | +5.214 | +5.383 | C86 | C86 | 1 | 1009 | CSV | 5.74931 | 5.79476 | 0.000732396 | 0.000738185 | 0.309327 | 0.29835 | 1537.89
CSV | 4961.71 | 28539.8 | 60259.9 | +4.761 | +5.143 | C25 | C25 | 1 | 1004 | CSV | 13.4424 | 13.5688 | 0.00171241 | 0.00172851 | 0.721964 | 0.698608 | 3601.07
CSV | 5323.58 | 28563 | 57297.1 | +5.122 | +5.506 | C28 | C28 | 1 | 1004 | CSV | 13.7034 | 13.8326 | 0.00174566 | 0.00176211 | 0.735964 | 0.712188 | 3671.07
CSV | 4961.77 | 15920.7 | 36909.4 | +4.763 | +5.141 | C30 | C30 | 3 | 3004 | CSV | 12.791 | 12.9106 | 0.00162943 | 0.00164466 | 0.687027 | 0.664718 | 3426.38
CSV | 5325.4 | 59776.2 | 57282.3 | +5.122 | +5.510 | C37 | C37 | 1 | 1004 | CSV | 13.8526 | 13.9833 | 0.00176466 | 0.00178131 | 0.743964 | 0.719948 | 3711.07
CSV | 5152.52 | 20758.6 | 70675.2 | +5.020 | +5.304 | C20 | C20 | 1 | 1009 | CSV | 11.47 | 11.5757 | 0.00146115 | 0.00147461 | 0.616172 | 0.59599 | 3072.11
CSV | 5116.11 | 20758.6 | 70670.8 | +4.963 | +5.251 | C20 | C20 | 1 | 1009 | CSV | 11.47 | 11.5757 | 0.00146115 | 0.00147461 | 0.616172 | 0.59599 | 3072.11
CSV | 5405.96 | 20741.4 | 68600.3 | +5.274 | +5.557 | C20 | C20 | 1 | 1009 | CSV | 11.4701 | 11.5757 | 0.00146115 | 0.00147461 | 0.616172 | 0.59599 | 3072.11
CSV | 5369.55 | 20741.4 | 68595.8 | +5.216 | +5.504 | C20 | C20 | 1 | 1009 | CSV | 11.4701 | 11.5757 | 0.00146115 | 0.00147461 | 0.616172 | 0.59599 | 3072.11
CSV | 5408.62 | 23385.8 | 68578.5 | +5.274 | +5.563 | C21 | C21 | 1 | 1009 | CSV | 11.7311 | 11.8395 | 0.0014944 | 0.00150821 | 0.630172 | 0.60957 | 3142.11
CSV | 5372.21 | 23385.8 | 68574 | +5.216 | +5.509 | C21 | C21 | 1 | 1009 | CSV | 11.7311 | 11.8395 | 0.0014944 | 0.00150821 | 0.630172 | 0.60957 | 3142.11
CSV | 5152.52 | 23341.4 | 70675.2 | +5.020 | +5.304 | C20 | C20 | 1 | 1009 | CSV | 11.47 | 11.5757 | 0.00146115 | 0.00147461 | 0.616172 | 0.59599 | 3072.11
CSV | 5116.11 | 23341.4 | 70670.8 | +4.963 | +5.251 | C20 | C20 | 1 | 1009 | CSV | 11.47 | 11.5757 | 0.00146115 | 0.00147461 | 0.616172 | 0.59599 | 3072.11
CSV | 4963.93 | 67810.1 | 71916.7 | +4.765 | +5.143 | C27 | C27 | 1 | 1004 | CSV | 13.692 | 13.8211 | 0.00174421 | 0.00176065 | 0.735353 | 0.711595 | 3668.02
CSV | 5323.55 | 67813.6 | 68972.4 | +5.122 | +5.506 | C26 | C26 | 1 | 1004 | CSV | 13.953 | 14.0848 | 0.00177746 | 0.00179425 | 0.749353 | 0.725175 | 3738.02
CSV | 4963.93 | 65089.9 | 71916.7 | +4.765 | +5.143 | C27 | C27 | 1 | 1004 | CSV | 13.692 | 13.8211 | 0.00174421 | 0.00176065 | 0.735353 | 0.711595 | 3668.02
CSV | 4607.43 | 65110.1 | 74835.5 | +4.409 | +4.787 | C27 | C27 | 1 | 1004 | CSV | 13.692 | 13.8211 | 0.00174421 | 0.00176065 | 0.735353 | 0.711595 | 3668.02
CSV | 5323.55 | 65086.4 | 68972.4 | +5.122 | +5.506 | C26 | C26 | 1 | 1004 | CSV | 13.953 | 14.0848 | 0.00177746 | 0.00179425 | 0.749353 | 0.725175 | 3738.02
CSV | 5314.03 | 33128.6 | 69050.3 | +5.224 | +5.385 | C84 | C84 | 1 | 1009 | CSV | 5.50852 | 5.55143 | 0.000701723 | 0.000707189 | 0.296412 | 0.285822 | 1473.31
CSV | 5350.45 | 33128.6 | 69054.8 | +5.277 | +5.443 | C84 | C84 | 1 | 1009 | CSV | 5.50852 | 5.55143 | 0.000701723 | 0.000707189 | 0.296412 | 0.285822 | 1473.31
CSV | 5325.4 | 59776.2 | 68957.3 | +5.122 | +5.510 | C59 | C59 | 1 | 1004 | CSV | 13.8526 | 13.9833 | 0.00176466 | 0.00178131 | 0.743964 | 0.719948 | 3711.07
CSV | 5323.58 | 57137 | 68972.1 | +5.122 | +5.506 | C57 | C57 | 1 | 1004 | CSV | 13.7034 | 13.8326 | 0.00174566 | 0.00176211 | 0.735964 | 0.712188 | 3671.07
CSV | 4961.71 | 57160.2 | 71934.9 | +4.761 | +5.143 | C58 | C58 | 1 | 1004 | CSV | 13.4424 | 13.5688 | 0.00171241 | 0.00172851 | 0.721964 | 0.698608 | 3601.07
CSV | 5124.82 | 34349.3 | 70599.4 | +4.986 | +5.244 | C94 | C94 | 1 | 1009 | CSV | 7.74032 | 7.80672 | 0.000986027 | 0.000994487 | 0.416119 | 0.401938 | 2071.85
CSV | 5161.24 | 34349.3 | 70603.9 | +5.041 | +5.302 | C94 | C94 | 1 | 1009 | CSV | 7.74032 | 7.80672 | 0.000986027 | 0.000994487 | 0.416119 | 0.401938 | 2071.85
CSV | 5435.48 | 34385.6 | 68056 | +5.342 | +5.510 | C85 | C85 | 1 | 1009 | CSV | 5.80682 | 5.85288 | 0.000739723 | 0.000745589 | 0.312412 | 0.301342 | 1553.31
CSV | 5471.9 | 34385.6 | 68060.4 | +5.395 | +5.567 | C85 | C85 | 1 | 1009 | CSV | 5.80682 | 5.85288 | 0.000739723 | 0.000745589 | 0.312412 | 0.301342 | 1553.31
CSV | 5470.73 | 31797.3 | 68070 | +5.393 | +5.567 | C87 | C87 | 1 | 1009 | CSV | 5.78276 | 5.82856 | 0.000736657 | 0.000742491 | 0.311121 | 0.30009 | 1546.86
CSV | 5405.16 | 28514.3 | 68606.8 | +5.267 | +5.563 | C66 | C66 | 1 | 1009 | CSV | 11.8677 | 11.9775 | 0.0015118 | 0.0015258 | 0.637499 | 0.616676 | 3178.74
CSV | 5373.68 | 31110.2 | 68562 | +5.219 | +5.509 | C63 | C63 | 1 | 1009 | CSV | 11.6509 | 11.7585 | 0.0014842 | 0.0014979 | 0.625874 | 0.605401 | 3120.62
CSV | 5410.09 | 31110.2 | 68566.4 | +5.276 | +5.563 | C64 | C64 | 1 | 1009 | CSV | 11.6509 | 11.7585 | 0.0014842 | 0.0014979 | 0.625874 | 0.605401 | 3120.62
CSV | 5409.72 | 33714.1 | 68569.5 | +5.276 | +5.563 | C62 | C62 | 1 | 1009 | CSV | 11.6882 | 11.7962 | 0.00148895 | 0.0015027 | 0.627874 | 0.607341 | 3130.62
CSV | 5013.77 | 33742.9 | 71508.7 | +4.766 | +5.242 | C82 | C82 | 1 | 1009 | CSV | 15.7603 | 15.9111 | 0.00200768 | 0.00202689 | 0.846289 | 0.819203 | 4222.69
CSV | 5050.18 | 33742.9 | 71513.1 | +4.823 | +5.297 | C83 | C83 | 1 | 1009 | CSV | 15.7603 | 15.9111 | 0.00200768 | 0.00202689 | 0.846289 | 0.819203 | 4222.69
CSV | 5468.28 | 29197.7 | 68090 | +5.389 | +5.567 | C92 | C92 | 1 | 1009 | CSV | 5.87514 | 5.92191 | 0.000748425 | 0.000754383 | 0.316076 | 0.304897 | 1571.63
CSV | 5107.52 | 25941.8 | 70741.1 | +4.962 | +5.234 | C69 | C69 | 1 | 1009 | CSV | 11.1846 | 11.2873 | 0.00142479 | 0.00143787 | 0.600863 | 0.58114 | 2995.57
CSV | 5143.94 | 25941.8 | 70745.5 | +5.019 | +5.288 | C69 | C69 | 1 | 1009 | CSV | 11.1846 | 11.2873 | 0.00142479 | 0.00143787 | 0.600863 | 0.58114 | 2995.57
CSV | 5363.99 | 25912.6 | 68641.3 | +5.200 | +5.509 | C67 | C67 | 1 | 1009 | CSV | 12.0486 | 12.1604 | 0.00153486 | 0.0015491 | 0.647206 | 0.626093 | 3227.28
CSV | 5400.4 | 25912.6 | 68645.8 | +5.257 | +5.563 | C68 | C68 | 1 | 1009 | CSV | 12.0486 | 12.1604 | 0.00153486 | 0.0015491 | 0.647206 | 0.626093 | 3227.28
STABILITE | 3403.34 | 12106.6 | 79207.2 | +2.176 | +4.647 | V3 | V3 | 1 | 1002 | STABILITE | 13.9428 | 14.0745 | 0.00177615 | 0.00179293 | 0.748803 | 0.724642 | 3735.27
STABILITE | 3403.34 | 12106.6 | 79242.8 | +2.176 | +4.647 | V3 | V3 | 1 | 1002 | STABILITE | 13.9428 | 14.0745 | 0.00177615 | 0.00179293 | 0.748803 | 0.724642 | 3735.27
STABILITE | 853.707 | 12070 | 79207.2 | -0.354 | +2.078 | V2 | V2 | 1 | 1002 | STABILITE | 13.7191 | 13.8484 | 0.00174765 | 0.00176413 | 0.736803 | 0.713002 | 3675.27
CSV | 3359.91 | 14108.1 | 13627.6 | +3.302 | +3.439 | C80 | C80 | 2 | 2004 | CSV | 12.8651 | 12.9854 | 0.00163886 | 0.00165419 | 0.690997 | 0.66857 | 3446.24
CSV | 3234.81 | 12038.6 | 10776.1 | +3.157 | +3.292 | C79 | C79 | 2 | 2004 | CSV | 12.5295 | 12.6463 | 0.00159611 | 0.00161099 | 0.672997 | 0.65111 | 3356.24
CSV | 3271.48 | 12038.6 | 10775 | +3.215 | +3.349 | C79 | C79 | 2 | 2004 | CSV | 12.5295 | 12.6463 | 0.00159611 | 0.00161099 | 0.672997 | 0.65111 | 3356.24
CSV | 3323.25 | 14108.1 | 13628.7 | +3.245 | +3.381 | C80 | C80 | 2 | 2004 | CSV | 12.8651 | 12.9854 | 0.00163886 | 0.00165419 | 0.690997 | 0.66857 | 3446.24
CSV | 3271.98 | 14103.4 | 10791.2 | +3.215 | +3.350 | C79 | C79 | 2 | 2004 | CSV | 12.5295 | 12.6463 | 0.00159611 | 0.00161099 | 0.672997 | 0.65111 | 3356.24
CSV | 3323.25 | 12011.9 | 13628.7 | +3.245 | +3.381 | C80 | C80 | 2 | 2004 | CSV | 12.8651 | 12.9854 | 0.00163886 | 0.00165419 | 0.690997 | 0.66857 | 3446.24
CSV | 3359.91 | 12011.9 | 13627.6 | +3.302 | +3.439 | C80 | C80 | 2 | 2004 | CSV | 12.8651 | 12.9854 | 0.00163886 | 0.00165419 | 0.690997 | 0.66857 | 3446.24
CSV | 3235.32 | 14103.4 | 10792.3 | +3.158 | +3.292 | C79 | C79 | 2 | 2004 | CSV | 12.5295 | 12.6463 | 0.00159611 | 0.00161099 | 0.672997 | 0.65111 | 3356.24
CSV | 3271.98 | 16276.6 | 10791.2 | +3.215 | +3.350 | C79 | C79 | 2 | 2004 | CSV | 12.5295 | 12.6463 | 0.00159611 | 0.00161099 | 0.672997 | 0.65111 | 3356.24
CSV | 3235.32 | 16276.6 | 10792.3 | +3.158 | +3.292 | C79 | C79 | 2 | 2004 | CSV | 12.5295 | 12.6463 | 0.00159611 | 0.00161099 | 0.672997 | 0.65111 | 3356.24
CSV | 3359.91 | 16271.9 | 13627.6 | +3.302 | +3.439 | C80 | C80 | 2 | 2004 | CSV | 12.8651 | 12.9854 | 0.00163886 | 0.00165419 | 0.690997 | 0.66857 | 3446.24
CSV | 3323.25 | 16271.9 | 13628.7 | +3.245 | +3.381 | C80 | C80 | 2 | 2004 | CSV | 12.8651 | 12.9854 | 0.00163886 | 0.00165419 | 0.690997 | 0.66857 | 3446.24
CSV | 3271.98 | 18363.4 | 10791.2 | +3.215 | +3.350 | C79 | C79 | 2 | 2004 | CSV | 12.5295 | 12.6463 | 0.00159611 | 0.00161099 | 0.672997 | 0.65111 | 3356.24
CSV | 3235.32 | 18363.4 | 10792.3 | +3.158 | +3.292 | C79 | C79 | 2 | 2004 | CSV | 12.5295 | 12.6463 | 0.00159611 | 0.00161099 | 0.672997 | 0.65111 | 3356.24
CSV | 3359.72 | 20739.1 | 13621.5 | +3.302 | +3.439 | C78 | C78 | 2 | 2004 | CSV | 13.8034 | 13.9337 | 0.0017584 | 0.00177499 | 0.741328 | 0.717391 | 3697.89
CSV | 3323.06 | 20739.1 | 13622.7 | +3.244 | +3.381 | C78 | C78 | 2 | 2004 | CSV | 13.8034 | 13.9337 | 0.0017584 | 0.00177499 | 0.741328 | 0.717391 | 3697.89
CSV | 3272.39 | 20754.8 | 10804.2 | +3.215 | +3.350 | C77 | C77 | 2 | 2004 | CSV | 13.3933 | 13.5192 | 0.00170615 | 0.00172219 | 0.719328 | 0.696051 | 3587.89
CSV | 3235.72 | 20754.8 | 10805.3 | +3.158 | +3.292 | C77 | C77 | 2 | 2004 | CSV | 13.3933 | 13.5192 | 0.00170615 | 0.00172219 | 0.719328 | 0.696051 | 3587.89
CSV | 3359.72 | 23223.4 | 13621.5 | +3.302 | +3.439 | C78 | C78 | 2 | 2004 | CSV | 13.8034 | 13.9337 | 0.0017584 | 0.00177499 | 0.741328 | 0.717391 | 3697.89
CSV | 3323.06 | 23223.4 | 13622.7 | +3.244 | +3.381 | C78 | C78 | 2 | 2004 | CSV | 13.8034 | 13.9337 | 0.0017584 | 0.00177499 | 0.741328 | 0.717391 | 3697.89
CSV | 3272.39 | 23207.7 | 10804.2 | +3.215 | +3.350 | C77 | C77 | 2 | 2004 | CSV | 13.3933 | 13.5192 | 0.00170615 | 0.00172219 | 0.719328 | 0.696051 | 3587.89
CSV | 3235.72 | 23207.7 | 10805.3 | +3.158 | +3.292 | C77 | C77 | 2 | 2004 | CSV | 13.3933 | 13.5192 | 0.00170615 | 0.00172219 | 0.719328 | 0.696051 | 3587.89
CSV | 3272.39 | 25817.3 | 10804.2 | +3.215 | +3.350 | C52 | C52 | 2 | 2004 | CSV | 13.3933 | 13.5192 | 0.00170615 | 0.00172219 | 0.719328 | 0.696051 | 3587.89
CSV | 3359.72 | 25801.6 | 13621.5 | +3.302 | +3.439 | C53 | C53 | 2 | 2004 | CSV | 13.8034 | 13.9337 | 0.0017584 | 0.00177499 | 0.741328 | 0.717391 | 3697.89
CSV | 3359.72 | 28285.9 | 13621.5 | +3.302 | +3.439 | C53 | C53 | 2 | 2004 | CSV | 13.8034 | 13.9337 | 0.0017584 | 0.00177499 | 0.741328 | 0.717391 | 3697.89
CSV | 3413.54 | 33574.6 | 16541.4 | +3.335 | +3.471 | C72 | C72 | 2 | 2004 | CSV | 14.1463 | 14.2801 | 0.00180208 | 0.00181912 | 0.759719 | 0.73523 | 3789.84
CSV | 3272.39 | 28270.2 | 10804.2 | +3.215 | +3.350 | C52 | C52 | 2 | 2004 | CSV | 13.3933 | 13.5192 | 0.00170615 | 0.00172219 | 0.719328 | 0.696051 | 3587.89
CSV | 3450.2 | 33574.6 | 16540.3 | +3.392 | +3.529 | C72 | C72 | 2 | 2004 | CSV | 14.1463 | 14.2801 | 0.00180208 | 0.00181912 | 0.759719 | 0.73523 | 3789.84
CSV | 3272.35 | 33537.3 | 10803.1 | +3.215 | +3.350 | C50 | C50 | 2 | 2004 | CSV | 13.7361 | 13.8656 | 0.00174983 | 0.00176632 | 0.737719 | 0.71389 | 3679.84
CSV | 3501.61 | 33537.6 | 19382.4 | +3.424 | +3.559 | C73 | C73 | 2 | 2004 | CSV | 13.9599 | 14.0917 | 0.00177833 | 0.00179512 | 0.749719 | 0.72553 | 3739.84
CSV | 3359.74 | 33554.5 | 13622.1 | +3.301 | +3.439 | C49 | C49 | 2 | 2004 | CSV | 14.1463 | 14.2801 | 0.00180208 | 0.00181912 | 0.759719 | 0.73523 | 3789.84
CSV | 3538.28 | 33537.6 | 19381.3 | +3.481 | +3.617 | C73 | C73 | 2 | 2004 | CSV | 13.9599 | 14.0917 | 0.00177833 | 0.00179512 | 0.749719 | 0.72553 | 3739.84
CSV | 3450.2 | 30912.9 | 16540.3 | +3.392 | +3.529 | C72 | C72 | 2 | 2004 | CSV | 14.1463 | 14.2801 | 0.00180208 | 0.00181912 | 0.759719 | 0.73523 | 3789.84
CSV | 3413.54 | 30912.9 | 16541.4 | +3.335 | +3.471 | C72 | C72 | 2 | 2004 | CSV | 14.1463 | 14.2801 | 0.00180208 | 0.00181912 | 0.759719 | 0.73523 | 3789.84
CSV | 3272.35 | 36287.7 | 10803.1 | +3.215 | +3.350 | C76 | C76 | 2 | 2004 | CSV | 13.7361 | 13.8656 | 0.00174983 | 0.00176632 | 0.737719 | 0.71389 | 3679.84
CSV | 3235.69 | 36287.7 | 10804.3 | +3.158 | +3.292 | C76 | C76 | 2 | 2004 | CSV | 13.7361 | 13.8656 | 0.00174983 | 0.00176632 | 0.737719 | 0.71389 | 3679.84
CSV | 3359.74 | 36270.5 | 13622.1 | +3.301 | +3.439 | C72 | C72 | 2 | 2004 | CSV | 14.1463 | 14.2801 | 0.00180208 | 0.00181912 | 0.759719 | 0.73523 | 3789.84
CSV | 3323.08 | 36270.5 | 13623.3 | +3.244 | +3.381 | C72 | C72 | 2 | 2004 | CSV | 14.1463 | 14.2801 | 0.00180208 | 0.00181912 | 0.759719 | 0.73523 | 3789.84
CSV | 3359.74 | 38892 | 13622.1 | +3.301 | +3.439 | C72 | C72 | 2 | 2004 | CSV | 14.1463 | 14.2801 | 0.00180208 | 0.00181912 | 0.759719 | 0.73523 | 3789.84
CSV | 3323.08 | 38892 | 13623.3 | +3.244 | +3.381 | C72 | C72 | 2 | 2004 | CSV | 14.1463 | 14.2801 | 0.00180208 | 0.00181912 | 0.759719 | 0.73523 | 3789.84
CSV | 3272.35 | 38874.8 | 10803.1 | +3.215 | +3.350 | C76 | C76 | 2 | 2004 | CSV | 13.7361 | 13.8656 | 0.00174983 | 0.00176632 | 0.737719 | 0.71389 | 3679.84
CSV | 3235.69 | 38874.8 | 10804.3 | +3.158 | +3.292 | C76 | C76 | 2 | 2004 | CSV | 13.7361 | 13.8656 | 0.00174983 | 0.00176632 | 0.737719 | 0.71389 | 3679.84
CSV | 3272.33 | 41671.1 | 10802.5 | +3.215 | +3.350 | C74 | C74 | 2 | 2004 | CSV | 13.9648 | 14.0967 | 0.00177895 | 0.00179576 | 0.749981 | 0.725785 | 3741.16
CSV | 3235.67 | 41671.1 | 10803.6 | +3.158 | +3.292 | C74 | C74 | 2 | 2004 | CSV | 13.9648 | 14.0967 | 0.00177895 | 0.00179576 | 0.749981 | 0.725785 | 3741.16
CSV | 3538.28 | 30949.9 | 19381.3 | +3.481 | +3.617 | C73 | C73 | 2 | 2004 | CSV | 13.9599 | 14.0917 | 0.00177833 | 0.00179512 | 0.749719 | 0.72553 | 3739.84
CSV | 3501.61 | 30949.9 | 19382.4 | +3.424 | +3.559 | C73 | C73 | 2 | 2004 | CSV | 13.9599 | 14.0917 | 0.00177833 | 0.00179512 | 0.749719 | 0.72553 | 3739.84
CSV | 3359.75 | 44363.8 | 13622.5 | +3.301 | +3.439 | C75 | C75 | 2 | 2004 | CSV | 14.3749 | 14.5112 | 0.0018312 | 0.00184856 | 0.771983 | 0.747126 | 3851.16
CSV | 3323.09 | 44363.8 | 13623.7 | +3.244 | +3.381 | C75 | C75 | 2 | 2004 | CSV | 14.3749 | 14.5112 | 0.0018312 | 0.00184856 | 0.771983 | 0.747126 | 3851.16
CSV | 3272.33 | 44345.6 | 10802.5 | +3.215 | +3.350 | C74 | C74 | 2 | 2004 | CSV | 13.9648 | 14.0967 | 0.00177895 | 0.00179576 | 0.749983 | 0.725786 | 3741.16
CSV | 3235.67 | 44345.6 | 10803.6 | +3.158 | +3.292 | C74 | C74 | 2 | 2004 | CSV | 13.9648 | 14.0967 | 0.00177895 | 0.00179576 | 0.749983 | 0.725786 | 3741.16
CSV | 3317.27 | 47128 | 12252.2 | +3.217 | +3.438 | C81 | C81 | 2 | 2004 | CSV | 22.6883 | 22.912 | 0.00289022 | 0.00291873 | 1.21789 | 1.17965 | 6080.68
CSV | 3280.61 | 47128 | 12253.3 | +3.160 | +3.380 | C81 | C81 | 2 | 2004 | CSV | 22.6883 | 22.912 | 0.00289022 | 0.00291873 | 1.21789 | 1.17965 | 6080.68
CSV | 3272.35 | 30950.2 | 10803.1 | +3.215 | +3.350 | C50 | C50 | 2 | 2004 | CSV | 13.7361 | 13.8656 | 0.00174983 | 0.00176632 | 0.737719 | 0.71389 | 3679.84
CSV | 3359.74 | 30933 | 13622.1 | +3.301 | +3.439 | C49 | C49 | 2 | 2004 | CSV | 14.1463 | 14.2801 | 0.00180208 | 0.00181912 | 0.759719 | 0.73523 | 3789.84
 | 3644.27 | 9952.84 | 3470.26 | +2.973 | +4.297 | 532 | L52 | 2 | 2003 |  | 9.67834 | 9.78021 | 0.00123291 | 0.00124589 | 0.52007 | 0.503546 | 2595.6
 | 3625.73 | 9952.84 | 5780.26 | +2.973 | +4.297 | 532 | L52 | 2 | 2003 |  | 9.67834 | 9.78021 | 0.00123291 | 0.00124589 | 0.52007 | 0.503546 | 2595.6
 | 3644.27 | 9952.84 | 1160.26 | +2.973 | +4.297 | 532 | L52 | 2 | 2003 |  | 9.67834 | 9.78021 | 0.00123291 | 0.00124589 | 0.52007 | 0.503546 | 2595.6
 | 3625.73 | 9952.84 | 8087.57 | +2.973 | +4.297 | 531 | L52 | 2 | 2003 |  | 9.66083 | 9.76252 | 0.00123068 | 0.00124363 | 0.51913 | 0.502635 | 2590.9
 | 3641.8 | 9952.84 | 9785.51 | +3.010 | +4.260 | 530 | L52 | 2 | 2003 |  | 5.89602 | 5.95809 | 0.000751086 | 0.000758992 | 0.317197 | 0.306759 | 1581.23
LISSE | 3052.08 | -535.507 | 44260.7 | +3.036 | +3.090 | 497 | K20 | 3 | 3003 | LISSE | 0.75177 | 0.759683 | 0.0000957669 | 0.000096775 | 0.0412729 | 0.0391132 | 201.614

# IfcBeam: L60*6 (913)
In: Undefined
Description: L60*6
Tekla Common - Profile: L60*6; sets with these values: 2
Tekla Quantity - Area per tons: 42.9545 m2; Height: 60 mm; Width: 60 mm; sets with these values: 2
Name | Material | Center of gravity Z (mm) | Center of gravity Y (mm) | Center of gravity X (mm) | Bottom elevation | Top elevation | Part mark | Assembly mark | Phase | Class | Finish | Grade | Name | Net weight (kg) = NetWeight (kg) | Gross weight (kg) = Weight (kg) | Net volume (m3) = NetVolume (m3) | Gross volume (m3) | Gross footprint area (m2) | Net surface area (m2) | Gross area (m2) = OuterSurfaceArea (m2) | Tekla Quantity, Length (mm) = BaseQuantities, Length (mm)
ATTACHE | STEEL/E24-2 | 132.789 | 19620 | 75012.8 | +0.090 | +0.150 | H16 | H16 | 7 | 7001 | GRENAILLE-PEINT | E24-2 | ATTACHE | 0.80541 | 0.813653 | 0.0001026 | 0.00010365 | 0.009 | 0.037368 | 0.03495 | 150
ATTACHE | STEEL/E24-2 | 1672.79 | 19620 | 75012.8 | +1.630 | +1.690 | H16 | H16 | 7 | 7001 | GRENAILLE-PEINT | E24-2 | ATTACHE | 0.80541 | 0.813653 | 0.0001026 | 0.00010365 | 0.009 | 0.037368 | 0.03495 | 150
ATTACHE | STEEL/E24-2 | 3193.19 | 20670 | 79267.8 | +3.176 | +3.236 | 399 | P53 | 7 | 7001 | GRENAILLE-PEINT | E24-2 | ATTACHE | 0.26847 | 0.271218 | 0.0000342 | 0.00003455 | 0.0003 | 0.013368 | 0.01165 | 50
ATTACHE | STEEL/E24-2 | 2177.21 | 20670 | 79267.8 | +2.160 | +2.220 | 399 | P53 | 7 | 7001 | GRENAILLE-PEINT | E24-2 | ATTACHE | 0.26847 | 0.271218 | 0.0000342 | 0.00003455 | 0.0003 | 0.013368 | 0.01165 | 50
ATTACHE | STEEL/E24-2 | 3515.75 | 20670 | 78402.2 | +3.473 | +3.533 | 399 | P52 | 7 | 7001 | GRENAILLE-PEINT | E24-2 | ATTACHE | 0.26847 | 0.271218 | 0.0000342 | 0.00003455 | 0.003 | 0.013368 | 0.01165 | 50
ATTACHE | STEEL/E24-2 | 3098.77 | 20670 | 78402.2 | +3.056 | +3.116 | 399 | P52 | 7 | 7001 | GRENAILLE-PEINT | E24-2 | ATTACHE | 0.26847 | 0.271218 | 0.0000342 | 0.00003455 | 0.003 | 0.013368 | 0.01165 | 50
ATTACHE | STEEL/E24-2 | 3098.77 | 20670 | 78307.8 | +3.056 | +3.116 | 399 | P52 | 7 | 7001 | GRENAILLE-PEINT | E24-2 | ATTACHE | 0.26847 | 0.271218 | 0.0000342 | 0.00003455 | 0.003 | 0.013368 | 0.01165 | 50
ATTACHE | STEEL/E24-2 | 82.7895 | 20670 | 78307.8 | +0.040 | +0.100 | 399 | P52 | 7 | 7001 | GRENAILLE-PEINT | E24-2 | ATTACHE | 0.26847 | 0.271218 | 0.0000342 | 0.00003455 | 0.003 | 0.013368 | 0.01165 | 50
ATTACHE | STEEL/E24-2 | 2177.21 | 20670 | 78402.2 | +2.160 | +2.220 | 399 | P52 | 7 | 7001 | GRENAILLE-PEINT | E24-2 | ATTACHE | 0.26847 | 0.271218 | 0.0000342 | 0.00003455 | 0.0003 | 0.013368 | 0.01165 | 50
ATTACHE | STEEL/E24-2 | 1732.79 | 20670 | 78307.8 | +1.690 | +1.750 | 399 | P52 | 7 | 7001 | GRENAILLE-PEINT | E24-2 | ATTACHE | 0.26847 | 0.271218 | 0.0000342 | 0.00003455 | 0.003 | 0.013368 | 0.01165 | 50
LIEN | STEEL/E24-2 | 3207.79 | 24455.3 | 1942.5 | +3.165 | +3.225 | L17 | L17 | 6 | 6001 | GRENAILLE-PEINT | E24-2 | LIEN | 14.1484 | 14.2932 | 0.00180234 | 0.00182078 | 0.1581 | 0.633768 | 0.613955 | 2635
BRACON | STEEL/E24-2 | 3451.32 | 15222.2 | 934.41 | +3.231 | +3.690 | W1 | W1 | 6 | 6001 | GRENAILLE-PEINT | E24-2 | BRACON | 3.15957 | 3.1919 | 0.000402492 | 0.000406612 | 0 | 0.142593 | 0.137106 | 588.439
LIEN | STEEL/E24-2 | 3207.79 | 15132.8 | 2045 | +3.165 | +3.225 | L13 | L13 | 6 | 6001 | GRENAILLE-PEINT | E24-2 | LIEN | 15.2491 | 15.4052 | 0.00194256 | 0.00196244 | 0.1704 | 0.682968 | 0.66172 | 2840
BRACON | STEEL/E24-2 | 3451.32 | 10962.2 | 934.41 | +3.231 | +3.690 | W1 | W1 | 6 | 6001 | GRENAILLE-PEINT | E24-2 | BRACON | 3.15957 | 3.1919 | 0.000402492 | 0.000406612 | 0 | 0.142593 | 0.137106 | 588.439
LIEN | STEEL/E24-2 | 3207.79 | 10872.8 | 2045 | +3.165 | +3.225 | L13 | L13 | 6 | 6001 | GRENAILLE-PEINT | E24-2 | LIEN | 15.2491 | 15.4052 | 0.00194256 | 0.00196244 | 0.1704 | 0.682968 | 0.66172 | 2840
LIEN | STEEL/E24-2 | 3207.79 | 10872.8 | 4910 | +3.165 | +3.225 | L15 | L15 | 6 | 6001 | GRENAILLE-PEINT | E24-2 | LIEN | 15.4639 | 15.6221 | 0.00196992 | 0.00199008 | 0.1728 | 0.692568 | 0.67104 | 2880
LIEN | STEEL/E24-2 | 3207.79 | 13002.8 | 4910 | +3.165 | +3.225 | L15 | L15 | 6 | 6001 | GRENAILLE-PEINT | E24-2 | LIEN | 15.4639 | 15.6221 | 0.00196992 | 0.00199008 | 0.1728 | 0.692568 | 0.67104 | 2880
LIEN | STEEL/E24-2 | 3207.79 | 13002.8 | 2045 | +3.165 | +3.225 | L13 | L13 | 6 | 6001 | GRENAILLE-PEINT | E24-2 | LIEN | 15.2491 | 15.4052 | 0.00194256 | 0.00196244 | 0.1704 | 0.682968 | 0.66172 | 2840
BRACON | STEEL/E24-2 | 3451.32 | 13092.2 | 934.41 | +3.231 | +3.690 | W1 | W1 | 6 | 6001 | GRENAILLE-PEINT | E24-2 | BRACON | 3.15957 | 3.1919 | 0.000402492 | 0.000406612 | 0 | 0.142593 | 0.137106 | 588.439
ATTACHE | STEEL/E24-2 | 5230.5 | 24037.2 | 58352.8 | +5.148 | +5.313 | 401 | L18 | 4 | 4001 | GRENAILLE-PEINT | E24-2 | ATTACHE | 0.885949 | 0.895015 | 0.00011286 | 0.000114015 | 0.000684 | 0.0409679 | 0.0384449 | 165
ATTACHE | STEEL/E24-2 | 3922.79 | 27862.8 | 55850 | +3.880 | +3.940 | H15 | H15 | 4 | 4001 | GRENAILLE-PEINT | E24-2 | ATTACHE | 1.7719 | 1.79004 | 0.00022572 | 0.00022803 | 0.0198 | 0.080568 | 0.07689 | 330
ATTACHE | STEEL/E24-2 | 4254.21 | 27862.8 | 55850 | +4.237 | +4.297 | H14 | H14 | 4 | 4001 | GRENAILLE-PEINT | E24-2 | ATTACHE | 1.7719 | 1.79004 | 0.00022572 | 0.00022803 | 0.00198 | 0.080568 | 0.07689 | 330
ATTACHE | STEEL/E24-2 | 3535 | 27862.8 | 54462.2 | +3.505 | +3.565 | 400 | L19 | 4 | 4001 | GRENAILLE-PEINT | E24-2 | ATTACHE | 0.322164 | 0.325461 | 0.00004104 | 0.00004146 | 0.000684 | 0.015768 | 0.01398 | 60.0001
ATTACHE | STEEL/E24-2 | 3535 | 24037.2 | 58287.8 | +3.505 | +3.565 | 400 | L18 | 4 | 4001 | GRENAILLE-PEINT | E24-2 | ATTACHE | 0.322164 | 0.325461 | 0.00004104 | 0.00004146 | 0.000684 | 0.015768 | 0.01398 | 60
MONTANT | STEEL/E24-2 | 3687.21 | 64015.5 | 44047.8 | +3.670 | +3.730 | M9 | M9 | 4 | 4001 | GRENAILLE-PEINT | E24-2 | MONTANT | 0.730236 | 0.737709 | 0.0000930237 | 0.0000939757 | 0.000815998 | 0.0340079 | 0.0316879 | 136
MONTANT | STEEL/E24-2 | 3687.21 | 59083.4 | 44047.8 | +3.670 | +3.730 | M9 | M9 | 4 | 4001 | GRENAILLE-PEINT | E24-2 | MONTANT | 0.730236 | 0.737709 | 0.0000930237 | 0.0000939757 | 0.000815998 | 0.0340079 | 0.0316879 | 136
MONTANT | STEEL/E24-2 | 3687.21 | 53515.5 | 44047.8 | +3.670 | +3.730 | M9 | M9 | 4 | 4001 | GRENAILLE-PEINT | E24-2 | MONTANT | 0.730236 | 0.73771 | 0.0000930237 | 0.0000939757 | 0.000815998 | 0.0340079 | 0.0316879 | 136
MONTANT | STEEL/E24-2 | 3687.21 | 48315.5 | 44047.8 | +3.670 | +3.730 | M9 | M9 | 4 | 4001 | GRENAILLE-PEINT | E24-2 | MONTANT | 0.730236 | 0.73771 | 0.0000930237 | 0.0000939757 | 0.000815998 | 0.0340079 | 0.0316879 | 136
MONTANT | STEEL/E24-2 | 3687.21 | 43115.5 | 44047.8 | +3.670 | +3.730 | M9 | M9 | 4 | 4001 | GRENAILLE-PEINT | E24-2 | MONTANT | 0.730237 | 0.73771 | 0.0000930238 | 0.0000939758 | 0.000815998 | 0.0340079 | 0.0316879 | 136
MONTANT | STEEL/E24-2 | 3687.21 | 38283.4 | 44047.8 | +3.670 | +3.730 | M9 | M9 | 4 | 4001 | GRENAILLE-PEINT | E24-2 | MONTANT | 0.730237 | 0.73771 | 0.0000930238 | 0.0000939758 | 0.000815998 | 0.0340079 | 0.0316879 | 136
MONTANT | STEEL/E24-2 | 3687.21 | 32715.5 | 44047.8 | +3.670 | +3.730 | M9 | M9 | 4 | 4001 | GRENAILLE-PEINT | E24-2 | MONTANT | 0.730237 | 0.73771 | 0.0000930238 | 0.0000939758 | 0.000815998 | 0.0340079 | 0.0316879 | 136
MONTANT | STEEL/E24-2 | 3687.21 | 27515.5 | 44047.8 | +3.670 | +3.730 | M9 | M9 | 4 | 4001 | GRENAILLE-PEINT | E24-2 | MONTANT | 0.730237 | 0.73771 | 0.0000930238 | 0.0000939758 | 0.000815998 | 0.0340079 | 0.0316879 | 136
MONTANT | STEEL/E24-2 | 3687.21 | 22315.5 | 44047.8 | +3.670 | +3.730 | M9 | M9 | 4 | 4001 | GRENAILLE-PEINT | E24-2 | MONTANT | 0.730237 | 0.73771 | 0.0000930238 | 0.0000939758 | 0.000815998 | 0.0340079 | 0.0316879 | 136
MONTANT | STEEL/E24-2 | 3687.21 | 17355.5 | 44047.8 | +3.670 | +3.730 | M9 | M9 | 4 | 4001 | GRENAILLE-PEINT | E24-2 | MONTANT | 0.730237 | 0.73771 | 0.0000930238 | 0.0000939758 | 0.000815998 | 0.0340079 | 0.0316879 | 136
MONTANT | STEEL/E24-2 | 3687.21 | 12635.5 | 44047.8 | +3.670 | +3.730 | M9 | M9 | 4 | 4001 | GRENAILLE-PEINT | E24-2 | MONTANT | 0.730237 | 0.73771 | 0.0000930238 | 0.0000939758 | 0.000815998 | 0.0340079 | 0.0316879 | 136
MONTANT | STEEL/E24-2 | 3958.5 | 59108.7 | 44082.2 | +3.605 | +4.312 | M10 | M10 | 4 | 4001 | GRENAILLE-PEINT | E24-2 | MONTANT | 3.79616 | 3.83501 | 0.000483588 | 0.000488537 | 0.000684 | 0.171048 | 0.164731 | 707
ATTACHE | STEEL/E24-2 | 3922.79 | 59074.2 | 44202.5 | +3.880 | +3.940 | H18 | H18 | 4 | 4001 | GRENAILLE-PEINT | E24-2 | ATTACHE | 1.42289 | 1.43745 | 0.00018126 | 0.000183115 | 0.0159 | 0.064968 | 0.061745 | 265
ATTACHE | STEEL/E24-2 | 4254.21 | 59074.2 | 44202.5 | +4.237 | +4.297 | H17 | H17 | 4 | 4001 | GRENAILLE-PEINT | E24-2 | ATTACHE | 1.42289 | 1.43745 | 0.00018126 | 0.000183115 | 0.00159 | 0.064968 | 0.061745 | 265
MONTANT | STEEL/E24-2 | 3958.5 | 60882.2 | 44082.2 | +3.605 | +4.312 | M8 | M8 | 4 | 4001 | GRENAILLE-PEINT | E24-2 | MONTANT | 3.79616 | 3.83501 | 0.000483588 | 0.000488537 | 0.000684 | 0.171048 | 0.164731 | 707
ATTACHE | STEEL/E24-2 | 4254.21 | 60847.8 | 44202.5 | +4.237 | +4.297 | H17 | H17 | 4 | 4001 | GRENAILLE-PEINT | E24-2 | ATTACHE | 1.42289 | 1.43745 | 0.00018126 | 0.000183115 | 0.00159 | 0.064968 | 0.061745 | 265
ATTACHE | STEEL/E24-2 | 3922.79 | 60847.8 | 44202.5 | +3.880 | +3.940 | H18 | H18 | 4 | 4001 | GRENAILLE-PEINT | E24-2 | ATTACHE | 1.42289 | 1.43745 | 0.00018126 | 0.000183115 | 0.0159 | 0.064968 | 0.061745 | 265
ATTACHE | STEEL/E24-2 | 4254.21 | 43106.3 | 44202.5 | +4.237 | +4.297 | H17 | H17 | 4 | 4001 | GRENAILLE-PEINT | E24-2 | ATTACHE | 1.42289 | 1.43745 | 0.00018126 | 0.000183115 | 0.00159 | 0.064968 | 0.061745 | 265
ATTACHE | STEEL/E24-2 | 3922.79 | 43106.3 | 44202.5 | +3.880 | +3.940 | H18 | H18 | 4 | 4001 | GRENAILLE-PEINT | E24-2 | ATTACHE | 1.42289 | 1.43745 | 0.00018126 | 0.000183115 | 0.0159 | 0.064968 | 0.061745 | 265
MONTANT | STEEL/E24-2 | 3993.5 | 43140.7 | 44082.2 | +3.605 | +4.382 | M11 | M11 | 4 | 4001 | GRENAILLE-PEINT | E24-2 | MONTANT | 4.17202 | 4.21472 | 0.000531468 | 0.000536907 | 0.000684 | 0.187848 | 0.181041 | 777
MONTANT | STEEL/E24-2 | 3958.5 | 42285.8 | 44082.2 | +3.605 | +4.312 | M8 | M8 | 4 | 4001 | GRENAILLE-PEINT | E24-2 | MONTANT | 3.79617 | 3.83502 | 0.000483588 | 0.000488537 | 0.000684 | 0.171048 | 0.164731 | 707
ATTACHE | STEEL/E24-2 | 4254.21 | 42251.3 | 44202.5 | +4.237 | +4.297 | H17 | H17 | 4 | 4001 | GRENAILLE-PEINT | E24-2 | ATTACHE | 1.42289 | 1.43745 | 0.00018126 | 0.000183115 | 0.00159 | 0.064968 | 0.061745 | 265
ATTACHE | STEEL/E24-2 | 3922.79 | 42251.3 | 44202.5 | +3.880 | +3.940 | H18 | H18 | 4 | 4001 | GRENAILLE-PEINT | E24-2 | ATTACHE | 1.42289 | 1.43745 | 0.00018126 | 0.000183115 | 0.0159 | 0.064968 | 0.061745 | 265
MONTANT | STEEL/E24-2 | 3958.5 | 40492.2 | 44082.2 | +3.605 | +4.312 | M8 | M8 | 4 | 4001 | GRENAILLE-PEINT | E24-2 | MONTANT | 3.79617 | 3.83502 | 0.000483588 | 0.000488537 | 0.000684 | 0.171048 | 0.164731 | 707
ATTACHE | STEEL/E24-2 | 4254.21 | 40457.8 | 44202.5 | +4.237 | +4.297 | H17 | H17 | 4 | 4001 | GRENAILLE-PEINT | E24-2 | ATTACHE | 1.42289 | 1.43745 | 0.00018126 | 0.000183115 | 0.00159 | 0.064968 | 0.061745 | 265
ATTACHE | STEEL/E24-2 | 3922.79 | 40457.8 | 44202.5 | +3.880 | +3.940 | H18 | H18 | 4 | 4001 | GRENAILLE-PEINT | E24-2 | ATTACHE | 1.42289 | 1.43745 | 0.00018126 | 0.000183115 | 0.0159 | 0.064968 | 0.061745 | 265
MONTANT | STEEL/E24-2 | 3958.5 | 19692.2 | 44082.2 | +3.605 | +4.312 | M8 | M8 | 4 | 4001 | GRENAILLE-PEINT | E24-2 | MONTANT | 3.79617 | 3.83502 | 0.000483588 | 0.000488537 | 0.000684 | 0.171048 | 0.164731 | 707
ATTACHE | STEEL/E24-2 | 4254.21 | 19657.8 | 44202.5 | +4.237 | +4.297 | H17 | H17 | 4 | 4001 | GRENAILLE-PEINT | E24-2 | ATTACHE | 1.42289 | 1.43745 | 0.00018126 | 0.000183115 | 0.00159 | 0.064968 | 0.061745 | 265
ATTACHE | STEEL/E24-2 | 3922.79 | 19657.8 | 44202.5 | +3.880 | +3.940 | H18 | H18 | 4 | 4001 | GRENAILLE-PEINT | E24-2 | ATTACHE | 1.42289 | 1.43745 | 0.00018126 | 0.000183115 | 0.0159 | 0.064968 | 0.061745 | 265
MONTANT | STEEL/E24-2 | 3958.5 | 21485.8 | 44082.2 | +3.605 | +4.312 | M8 | M8 | 4 | 4001 | GRENAILLE-PEINT | E24-2 | MONTANT | 3.79617 | 3.83502 | 0.000483588 | 0.000488537 | 0.000684 | 0.171048 | 0.164731 | 707
ATTACHE | STEEL/E24-2 | 4254.21 | 21451.3 | 44202.5 | +4.237 | +4.297 | H17 | H17 | 4 | 4001 | GRENAILLE-PEINT | E24-2 | ATTACHE | 1.42289 | 1.43745 | 0.00018126 | 0.000183115 | 0.00159 | 0.064968 | 0.061745 | 265
ATTACHE | STEEL/E24-2 | 3922.79 | 21451.3 | 44202.5 | +3.880 | +3.940 | H18 | H18 | 4 | 4001 | GRENAILLE-PEINT | E24-2 | ATTACHE | 1.42289 | 1.43745 | 0.00018126 | 0.000183115 | 0.0159 | 0.064968 | 0.061745 | 265
MONTANT | STEEL/E24-2 | 3993.5 | 19287.2 | 44082.2 | +3.605 | +4.382 | M7 | M7 | 4 | 4001 | GRENAILLE-PEINT | E24-2 | MONTANT | 4.17202 | 4.21472 | 0.000531468 | 0.000536907 | 0.000684 | 0.187848 | 0.181041 | 777
ATTACHE | STEEL/E24-2 | 4254.21 | 19252.8 | 44202.5 | +4.237 | +4.297 | H17 | H17 | 4 | 4001 | GRENAILLE-PEINT | E24-2 | ATTACHE | 1.42289 | 1.43745 | 0.00018126 | 0.000183115 | 0.00159 | 0.064968 | 0.061745 | 265
ATTACHE | STEEL/E24-2 | 3922.79 | 19252.8 | 44202.5 | +3.880 | +3.940 | H18 | H18 | 4 | 4001 | GRENAILLE-PEINT | E24-2 | ATTACHE | 1.42289 | 1.43745 | 0.00018126 | 0.000183115 | 0.0159 | 0.064968 | 0.061745 | 265
ATTACHE | STEEL/E24-2 | 4254.21 | 38274.2 | 44202.5 | +4.237 | +4.297 | H17 | H17 | 4 | 4001 | GRENAILLE-PEINT | E24-2 | ATTACHE | 1.42289 | 1.43745 | 0.00018126 | 0.000183115 | 0.00159 | 0.064968 | 0.061745 | 265
MONTANT | STEEL/E24-2 | 3993.5 | 38308.7 | 44082.2 | +3.605 | +4.382 | M11 | M11 | 4 | 4001 | GRENAILLE-PEINT | E24-2 | MONTANT | 4.17202 | 4.21472 | 0.000531468 | 0.000536907 | 0.000684 | 0.187848 | 0.181041 | 777
ATTACHE | STEEL/E24-2 | 3922.79 | 38274.2 | 44202.5 | +3.880 | +3.940 | H18 | H18 | 4 | 4001 | GRENAILLE-PEINT | E24-2 | ATTACHE | 1.42289 | 1.43745 | 0.00018126 | 0.000183115 | 0.0159 | 0.064968 | 0.061745 | 265
ATTACHE | STEEL/E24-2 | 4254.21 | 40052.8 | 44202.5 | +4.237 | +4.297 | H17 | H17 | 4 | 4001 | GRENAILLE-PEINT | E24-2 | ATTACHE | 1.42289 | 1.43745 | 0.00018126 | 0.000183115 | 0.00159 | 0.064968 | 0.061745 | 265
MONTANT | STEEL/E24-2 | 3993.5 | 40087.2 | 44082.2 | +3.605 | +4.382 | M7 | M7 | 4 | 4001 | GRENAILLE-PEINT | E24-2 | MONTANT | 4.17202 | 4.21472 | 0.000531468 | 0.000536907 | 0.000684 | 0.187848 | 0.181041 | 777
ATTACHE | STEEL/E24-2 | 3922.79 | 40052.8 | 44202.5 | +3.880 | +3.940 | H18 | H18 | 4 | 4001 | GRENAILLE-PEINT | E24-2 | ATTACHE | 1.42289 | 1.43745 | 0.00018126 | 0.000183115 | 0.0159 | 0.064968 | 0.061745 | 265
ATTACHE | STEEL/E24-2 | 4254.21 | 37419.3 | 44202.5 | +4.237 | +4.297 | H17 | H17 | 4 | 4001 | GRENAILLE-PEINT | E24-2 | ATTACHE | 1.42289 | 1.43745 | 0.00018126 | 0.000183115 | 0.00159 | 0.064968 | 0.061745 | 265
MONTANT | STEEL/E24-2 | 3993.5 | 37453.7 | 44082.2 | +3.605 | +4.382 | M7 | M7 | 4 | 4001 | GRENAILLE-PEINT | E24-2 | MONTANT | 4.17202 | 4.21472 | 0.000531468 | 0.000536907 | 0.000684 | 0.187848 | 0.181041 | 777
ATTACHE | STEEL/E24-2 | 3922.79 | 37419.3 | 44202.5 | +3.880 | +3.940 | H18 | H18 | 4 | 4001 | GRENAILLE-PEINT | E24-2 | ATTACHE | 1.42289 | 1.43745 | 0.00018126 | 0.000183115 | 0.0159 | 0.064968 | 0.061745 | 265
MONTANT | STEEL/E24-2 | 3993.5 | 58253.7 | 44082.2 | +3.605 | +4.382 | M7 | M7 | 4 | 4001 | GRENAILLE-PEINT | E24-2 | MONTANT | 4.17202 | 4.21472 | 0.000531468 | 0.000536907 | 0.000684 | 0.187848 | 0.181041 | 777
ATTACHE | STEEL/E24-2 | 4254.21 | 58219.3 | 44202.5 | +4.237 | +4.297 | H17 | H17 | 4 | 4001 | GRENAILLE-PEINT | E24-2 | ATTACHE | 1.42289 | 1.43745 | 0.00018126 | 0.000183115 | 0.00159 | 0.064968 | 0.061745 | 265
ATTACHE | STEEL/E24-2 | 3922.79 | 58219.3 | 44202.5 | +3.880 | +3.940 | H18 | H18 | 4 | 4001 | GRENAILLE-PEINT | E24-2 | ATTACHE | 1.42289 | 1.43745 | 0.00018126 | 0.000183115 | 0.0159 | 0.064968 | 0.061745 | 265
ATTACHE | STEEL/E24-2 | 4254.21 | 61366.3 | 44202.5 | +4.237 | +4.297 | H17 | H17 | 4 | 4001 | GRENAILLE-PEINT | E24-2 | ATTACHE | 1.42289 | 1.43745 | 0.00018126 | 0.000183115 | 0.00159 | 0.064968 | 0.061745 | 265
MONTANT | STEEL/E24-2 | 3993.5 | 61400.7 | 44082.2 | +3.605 | +4.382 | M7 | M7 | 4 | 4001 | GRENAILLE-PEINT | E24-2 | MONTANT | 4.17202 | 4.21472 | 0.000531468 | 0.000536907 | 0.000684 | 0.187848 | 0.181041 | 777
ATTACHE | STEEL/E24-2 | 3922.79 | 61366.3 | 44202.5 | +3.880 | +3.940 | H18 | H18 | 4 | 4001 | GRENAILLE-PEINT | E24-2 | ATTACHE | 1.42289 | 1.43745 | 0.00018126 | 0.000183115 | 0.0159 | 0.064968 | 0.061745 | 265
ATTACHE | STEEL/E24-2 | 4254.21 | 68772.8 | 44202.5 | +4.237 | +4.297 | H17 | H17 | 4 | 4001 | GRENAILLE-PEINT | E24-2 | ATTACHE | 1.42289 | 1.43745 | 0.00018126 | 0.000183115 | 0.00159 | 0.064968 | 0.061745 | 265
ATTACHE | STEEL/E24-2 | 3922.79 | 68772.8 | 44202.5 | +3.880 | +3.940 | H18 | H18 | 4 | 4001 | GRENAILLE-PEINT | E24-2 | ATTACHE | 1.42289 | 1.43745 | 0.00018126 | 0.000183115 | 0.0159 | 0.064968 | 0.061745 | 265
MONTANT | STEEL/E24-2 | 3993.5 | 68807.2 | 44082.2 | +3.605 | +4.382 | M7 | M7 | 4 | 4001 | GRENAILLE-PEINT | E24-2 | MONTANT | 4.17202 | 4.21472 | 0.000531468 | 0.000536907 | 0.000684 | 0.187848 | 0.181041 | 777
MONTANT | STEEL/E24-2 | 3993.5 | 66740.7 | 44082.2 | +3.605 | +4.382 | M7 | M7 | 4 | 4001 | GRENAILLE-PEINT | E24-2 | MONTANT | 4.17202 | 4.21472 | 0.000531468 | 0.000536907 | 0.000684 | 0.187848 | 0.181041 | 777
ATTACHE | STEEL/E24-2 | 3922.79 | 66706.3 | 44202.5 | +3.880 | +3.940 | H18 | H18 | 4 | 4001 | GRENAILLE-PEINT | E24-2 | ATTACHE | 1.42289 | 1.43745 | 0.00018126 | 0.000183115 | 0.0159 | 0.064968 | 0.061745 | 265
ATTACHE | STEEL/E24-2 | 3922.79 | 66219.3 | 44202.5 | +3.880 | +3.940 | H18 | H18 | 4 | 4001 | GRENAILLE-PEINT | E24-2 | ATTACHE | 1.42289 | 1.43745 | 0.00018126 | 0.000183115 | 0.0159 | 0.064968 | 0.061745 | 265
MONTANT | STEEL/E24-2 | 3993.5 | 66253.7 | 44082.2 | +3.605 | +4.382 | M7 | M7 | 4 | 4001 | GRENAILLE-PEINT | E24-2 | MONTANT | 4.17202 | 4.21472 | 0.000531468 | 0.000536907 | 0.000684 | 0.187848 | 0.181041 | 777
ATTACHE | STEEL/E24-2 | 4254.21 | 66219.3 | 44202.5 | +4.237 | +4.297 | H17 | H17 | 4 | 4001 | GRENAILLE-PEINT | E24-2 | ATTACHE | 1.42289 | 1.43745 | 0.00018126 | 0.000183115 | 0.00159 | 0.064968 | 0.061745 | 265
ATTACHE | STEEL/E24-2 | 4254.21 | 66706.3 | 44202.5 | +4.237 | +4.297 | H17 | H17 | 4 | 4001 | GRENAILLE-PEINT | E24-2 | ATTACHE | 1.42289 | 1.43745 | 0.00018126 | 0.000183115 | 0.00159 | 0.064968 | 0.061745 | 265
MONTANT | STEEL/E24-2 | 3993.5 | 64040.7 | 44082.2 | +3.605 | +4.382 | M11 | M11 | 4 | 4001 | GRENAILLE-PEINT | E24-2 | MONTANT | 4.17202 | 4.21472 | 0.000531468 | 0.000536907 | 0.000684 | 0.187848 | 0.181041 | 777
ATTACHE | STEEL/E24-2 | 3922.79 | 64006.3 | 44202.5 | +3.880 | +3.940 | H18 | H18 | 4 | 4001 | GRENAILLE-PEINT | E24-2 | ATTACHE | 1.42289 | 1.43745 | 0.00018126 | 0.000183115 | 0.0159 | 0.064968 | 0.061745 | 265
ATTACHE | STEEL/E24-2 | 3922.79 | 63519.3 | 44202.5 | +3.880 | +3.940 | H18 | H18 | 4 | 4001 | GRENAILLE-PEINT | E24-2 | ATTACHE | 1.42289 | 1.43745 | 0.00018126 | 0.000183115 | 0.0159 | 0.064968 | 0.061745 | 265
MONTANT | STEEL/E24-2 | 3993.5 | 63553.7 | 44082.2 | +3.605 | +4.382 | M7 | M7 | 4 | 4001 | GRENAILLE-PEINT | E24-2 | MONTANT | 4.17202 | 4.21472 | 0.000531468 | 0.000536907 | 0.000684 | 0.187848 | 0.181041 | 777
ATTACHE | STEEL/E24-2 | 4254.21 | 63519.3 | 44202.5 | +4.237 | +4.297 | H17 | H17 | 4 | 4001 | GRENAILLE-PEINT | E24-2 | ATTACHE | 1.42289 | 1.43745 | 0.00018126 | 0.000183115 | 0.00159 | 0.064968 | 0.061745 | 265
ATTACHE | STEEL/E24-2 | 4254.21 | 64006.3 | 44202.5 | +4.237 | +4.297 | H17 | H17 | 4 | 4001 | GRENAILLE-PEINT | E24-2 | ATTACHE | 1.42289 | 1.43745 | 0.00018126 | 0.000183115 | 0.00159 | 0.064968 | 0.061745 | 265
MONTANT | STEEL/E24-2 | 3993.5 | 56140.7 | 44082.2 | +3.605 | +4.382 | M7 | M7 | 4 | 4001 | GRENAILLE-PEINT | E24-2 | MONTANT | 4.17202 | 4.21472 | 0.000531468 | 0.000536907 | 0.000684 | 0.187848 | 0.181041 | 777
ATTACHE | STEEL/E24-2 | 3922.79 | 56106.3 | 44202.5 | +3.880 | +3.940 | H18 | H18 | 4 | 4001 | GRENAILLE-PEINT | E24-2 | ATTACHE | 1.42289 | 1.43745 | 0.00018126 | 0.000183115 | 0.0159 | 0.064968 | 0.061745 | 265
ATTACHE | STEEL/E24-2 | 3922.79 | 55619.3 | 44202.5 | +3.880 | +3.940 | H18 | H18 | 4 | 4001 | GRENAILLE-PEINT | E24-2 | ATTACHE | 1.42289 | 1.43745 | 0.00018126 | 0.000183115 | 0.0159 | 0.064968 | 0.061745 | 265
MONTANT | STEEL/E24-2 | 3993.5 | 55653.7 | 44082.2 | +3.605 | +4.382 | M7 | M7 | 4 | 4001 | GRENAILLE-PEINT | E24-2 | MONTANT | 4.17202 | 4.21472 | 0.000531468 | 0.000536907 | 0.000684 | 0.187848 | 0.181041 | 777
ATTACHE | STEEL/E24-2 | 4254.21 | 55619.3 | 44202.5 | +4.237 | +4.297 | H17 | H17 | 4 | 4001 | GRENAILLE-PEINT | E24-2 | ATTACHE | 1.42289 | 1.43745 | 0.00018126 | 0.000183115 | 0.00159 | 0.064968 | 0.061745 | 265
ATTACHE | STEEL/E24-2 | 4254.21 | 56106.3 | 44202.5 | +4.237 | +4.297 | H17 | H17 | 4 | 4001 | GRENAILLE-PEINT | E24-2 | ATTACHE | 1.42289 | 1.43745 | 0.00018126 | 0.000183115 | 0.00159 | 0.064968 | 0.061745 | 265
MONTANT | STEEL/E24-2 | 3993.5 | 53540.7 | 44082.2 | +3.605 | +4.382 | M11 | M11 | 4 | 4001 | GRENAILLE-PEINT | E24-2 | MONTANT | 4.17202 | 4.21472 | 0.000531468 | 0.000536907 | 0.000684 | 0.187848 | 0.181041 | 777
ATTACHE | STEEL/E24-2 | 3922.79 | 53506.3 | 44202.5 | +3.880 | +3.940 | H18 | H18 | 4 | 4001 | GRENAILLE-PEINT | E24-2 | ATTACHE | 1.42289 | 1.43745 | 0.00018126 | 0.000183115 | 0.0159 | 0.064968 | 0.061745 | 265
ATTACHE | STEEL/E24-2 | 3922.79 | 53019.3 | 44202.5 | +3.880 | +3.940 | H18 | H18 | 4 | 4001 | GRENAILLE-PEINT | E24-2 | ATTACHE | 1.42289 | 1.43745 | 0.00018126 | 0.000183115 | 0.0159 | 0.064968 | 0.061745 | 265
MONTANT | STEEL/E24-2 | 3993.5 | 53053.7 | 44082.2 | +3.605 | +4.382 | M7 | M7 | 4 | 4001 | GRENAILLE-PEINT | E24-2 | MONTANT | 4.17202 | 4.21472 | 0.000531468 | 0.000536907 | 0.000684 | 0.187848 | 0.181041 | 777
ATTACHE | STEEL/E24-2 | 4254.21 | 53019.3 | 44202.5 | +4.237 | +4.297 | H17 | H17 | 4 | 4001 | GRENAILLE-PEINT | E24-2 | ATTACHE | 1.42289 | 1.43745 | 0.00018126 | 0.000183115 | 0.00159 | 0.064968 | 0.061745 | 265
ATTACHE | STEEL/E24-2 | 4254.21 | 53506.3 | 44202.5 | +4.237 | +4.297 | H17 | H17 | 4 | 4001 | GRENAILLE-PEINT | E24-2 | ATTACHE | 1.42289 | 1.43745 | 0.00018126 | 0.000183115 | 0.00159 | 0.064968 | 0.061745 | 265
MONTANT | STEEL/E24-2 | 3993.5 | 50940.7 | 44082.2 | +3.605 | +4.382 | M7 | M7 | 4 | 4001 | GRENAILLE-PEINT | E24-2 | MONTANT | 4.17202 | 4.21472 | 0.000531468 | 0.000536907 | 0.000684 | 0.187848 | 0.181041 | 777
ATTACHE | STEEL/E24-2 | 3922.79 | 50906.3 | 44202.5 | +3.880 | +3.940 | H18 | H18 | 4 | 4001 | GRENAILLE-PEINT | E24-2 | ATTACHE | 1.42289 | 1.43745 | 0.00018126 | 0.000183115 | 0.0159 | 0.064968 | 0.061745 | 265
ATTACHE | STEEL/E24-2 | 3922.79 | 50419.3 | 44202.5 | +3.880 | +3.940 | H18 | H18 | 4 | 4001 | GRENAILLE-PEINT | E24-2 | ATTACHE | 1.42289 | 1.43745 | 0.00018126 | 0.000183115 | 0.0159 | 0.064968 | 0.061745 | 265
MONTANT | STEEL/E24-2 | 3993.5 | 50453.7 | 44082.2 | +3.605 | +4.382 | M7 | M7 | 4 | 4001 | GRENAILLE-PEINT | E24-2 | MONTANT | 4.17202 | 4.21472 | 0.000531468 | 0.000536907 | 0.000684 | 0.187848 | 0.181041 | 777
ATTACHE | STEEL/E24-2 | 4254.21 | 50419.3 | 44202.5 | +4.237 | +4.297 | H17 | H17 | 4 | 4001 | GRENAILLE-PEINT | E24-2 | ATTACHE | 1.42289 | 1.43745 | 0.00018126 | 0.000183115 | 0.00159 | 0.064968 | 0.061745 | 265
ATTACHE | STEEL/E24-2 | 4254.21 | 50906.3 | 44202.5 | +4.237 | +4.297 | H17 | H17 | 4 | 4001 | GRENAILLE-PEINT | E24-2 | ATTACHE | 1.42289 | 1.43745 | 0.00018126 | 0.000183115 | 0.00159 | 0.064968 | 0.061745 | 265
MONTANT | STEEL/E24-2 | 3993.5 | 48340.7 | 44082.2 | +3.605 | +4.382 | M11 | M11 | 4 | 4001 | GRENAILLE-PEINT | E24-2 | MONTANT | 4.17202 | 4.21472 | 0.000531468 | 0.000536907 | 0.000684 | 0.187848 | 0.181041 | 777
ATTACHE | STEEL/E24-2 | 3922.79 | 48306.3 | 44202.5 | +3.880 | +3.940 | H18 | H18 | 4 | 4001 | GRENAILLE-PEINT | E24-2 | ATTACHE | 1.42289 | 1.43745 | 0.00018126 | 0.000183115 | 0.0159 | 0.064968 | 0.061745 | 265
ATTACHE | STEEL/E24-2 | 4254.21 | 48306.3 | 44202.5 | +4.237 | +4.297 | H17 | H17 | 4 | 4001 | GRENAILLE-PEINT | E24-2 | ATTACHE | 1.42289 | 1.43745 | 0.00018126 | 0.000183115 | 0.00159 | 0.064968 | 0.061745 | 265
ATTACHE | STEEL/E24-2 | 4254.21 | 47819.3 | 44202.5 | +4.237 | +4.297 | H17 | H17 | 4 | 4001 | GRENAILLE-PEINT | E24-2 | ATTACHE | 1.42289 | 1.43745 | 0.00018126 | 0.000183115 | 0.00159 | 0.064968 | 0.061745 | 265
MONTANT | STEEL/E24-2 | 3993.5 | 47853.7 | 44082.2 | +3.605 | +4.382 | M7 | M7 | 4 | 4001 | GRENAILLE-PEINT | E24-2 | MONTANT | 4.17202 | 4.21472 | 0.000531468 | 0.000536907 | 0.000684 | 0.187848 | 0.181041 | 777
ATTACHE | STEEL/E24-2 | 3922.79 | 47819.3 | 44202.5 | +3.880 | +3.940 | H18 | H18 | 4 | 4001 | GRENAILLE-PEINT | E24-2 | ATTACHE | 1.42289 | 1.43745 | 0.00018126 | 0.000183115 | 0.0159 | 0.064968 | 0.061745 | 265
MONTANT | STEEL/E24-2 | 3993.5 | 45740.7 | 44082.2 | +3.605 | +4.382 | M7 | M7 | 4 | 4001 | GRENAILLE-PEINT | E24-2 | MONTANT | 4.17202 | 4.21472 | 0.000531468 | 0.000536907 | 0.000684 | 0.187848 | 0.181041 | 777
ATTACHE | STEEL/E24-2 | 3922.79 | 45706.3 | 44202.5 | +3.880 | +3.940 | H18 | H18 | 4 | 4001 | GRENAILLE-PEINT | E24-2 | ATTACHE | 1.42289 | 1.43745 | 0.00018126 | 0.000183115 | 0.0159 | 0.064968 | 0.061745 | 265
ATTACHE | STEEL/E24-2 | 4254.21 | 45706.3 | 44202.5 | +4.237 | +4.297 | H17 | H17 | 4 | 4001 | GRENAILLE-PEINT | E24-2 | ATTACHE | 1.42289 | 1.43745 | 0.00018126 | 0.000183115 | 0.00159 | 0.064968 | 0.061745 | 265
