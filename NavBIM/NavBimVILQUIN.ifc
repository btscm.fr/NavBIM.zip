Properties of the parts of a building model (IFC2X3), part 29 of 32

# IfcPlate: PL10*70 (973)
Name | Material | Center of gravity Z (mm) | Center of gravity Y (mm) | Center of gravity X (mm) | Bottom elevation | Top elevation | Part mark | Assembly mark | Phase | Class | Finish | Grade | Name | Net weight (kg) = Weight (kg) | Gross weight (kg) | Net volume (m3) = Gross volume (m3) | Gross footprint area (m2) | Area per tons (m2) | Net surface area (m2) | Gross area (m2) | Height (mm) | Length (mm)
PLAT | STEEL/E36-3 | 5741.5 | 42993.5 | 44161.6 | +5.603 | +5.880 | 221 | N41 | 1 | 1006 | GRENAILLE-PEINT | E36-3 | PLAT | 1.50225 | 1.51992 | 0.00019137 | 0.000549999 | 29.9751 | 0.0450302 | 0.019362 | 70 | 276.6
PLAT | STEEL/E36-3 | 5741.5 | 42993.5 | 44238.4 | +5.603 | +5.880 | 221 | N41 | 1 | 1006 | GRENAILLE-PEINT | E36-3 | PLAT | 1.50225 | 1.51992 | 0.00019137 | 0.000549999 | 29.9751 | 0.0450302 | 0.019362 | 70 | 276.6
PLAT | STEEL/E36-3 | 5741.5 | 42850 | 44161.1 | +5.603 | +5.880 | 222 | N41 | 1 | 1006 | GRENAILLE-PEINT | E36-3 | PLAT | 2.01837 | 2.08889 | 0.000257117 | 0 | 29.7642 | 0.0600752 | 0.0266101 | 70 | 380.144
PLAT | STEEL/E36-3 | 5741.5 | 42850 | 44238.9 | +5.603 | +5.880 | 222 | N41 | 1 | 1006 | GRENAILLE-PEINT | E36-3 | PLAT | 2.01837 | 2.08889 | 0.000257117 | 0 | 29.7642 | 0.0600752 | 0.0266101 | 70 | 380.144
PLAT | STEEL/E36-3 | 5741.5 | 42706.5 | 44161.6 | +5.603 | +5.880 | 221 | N41 | 1 | 1006 | GRENAILLE-PEINT | E36-3 | PLAT | 1.50225 | 1.51992 | 0.00019137 | 0.000549999 | 29.9751 | 0.0450302 | 0.019362 | 70 | 276.6
PLAT | STEEL/E36-3 | 5741.5 | 42706.5 | 44238.4 | +5.603 | +5.880 | 221 | N41 | 1 | 1006 | GRENAILLE-PEINT | E36-3 | PLAT | 1.50225 | 1.51992 | 0.00019137 | 0.000549999 | 29.9751 | 0.0450302 | 0.019362 | 70 | 276.6
PLAT | STEEL/E36-3 | 4088.5 | 42850 | 44238.9 | +3.950 | +4.227 | 222 | N41 | 1 | 1006 | GRENAILLE-PEINT | E36-3 | PLAT | 2.01837 | 2.08889 | 0.000257117 | 0 | 29.7642 | 0.0600752 | 0.0266101 | 70 | 380.144
PLAT | STEEL/E36-3 | 4088.5 | 42706.5 | 44238.4 | +3.950 | +4.227 | 221 | N41 | 1 | 1006 | GRENAILLE-PEINT | E36-3 | PLAT | 1.50225 | 1.51992 | 0.00019137 | 0.000549999 | 29.9751 | 0.0450302 | 0.019362 | 70 | 276.6
PLAT | STEEL/E36-3 | 4088.5 | 42706.5 | 44161.6 | +3.950 | +4.227 | 221 | N41 | 1 | 1006 | GRENAILLE-PEINT | E36-3 | PLAT | 1.50225 | 1.51992 | 0.00019137 | 0.000549999 | 29.9751 | 0.0450302 | 0.019362 | 70 | 276.6
PLAT | STEEL/E36-3 | 4088.5 | 42850 | 44161.1 | +3.950 | +4.227 | 222 | N41 | 1 | 1006 | GRENAILLE-PEINT | E36-3 | PLAT | 2.01837 | 2.08889 | 0.000257117 | 0 | 29.7642 | 0.0600752 | 0.0266101 | 70 | 380.144
PLAT | STEEL/E36-3 | 4088.5 | 42993.5 | 44238.4 | +3.950 | +4.227 | 221 | N41 | 1 | 1006 | GRENAILLE-PEINT | E36-3 | PLAT | 1.50225 | 1.51992 | 0.00019137 | 0.000549999 | 29.9751 | 0.0450302 | 0.019362 | 70 | 276.6
PLAT | STEEL/E36-3 | 4088.5 | 42993.5 | 44161.6 | +3.950 | +4.227 | 221 | N41 | 1 | 1006 | GRENAILLE-PEINT | E36-3 | PLAT | 1.50225 | 1.51992 | 0.00019137 | 0.000549999 | 29.9751 | 0.0450302 | 0.019362 | 70 | 276.6
PLAT | STEEL/E36-3 | 4088.5 | 45593.5 | 44161.6 | +3.950 | +4.227 | 221 | N41 | 1 | 1006 | GRENAILLE-PEINT | E36-3 | PLAT | 1.50225 | 1.51992 | 0.00019137 | 0.000549999 | 29.9751 | 0.0450302 | 0.019362 | 70 | 276.6
PLAT | STEEL/E36-3 | 4088.5 | 45593.5 | 44238.4 | +3.950 | +4.227 | 221 | N41 | 1 | 1006 | GRENAILLE-PEINT | E36-3 | PLAT | 1.50225 | 1.51992 | 0.00019137 | 0.000549999 | 29.9751 | 0.0450302 | 0.019362 | 70 | 276.6
PLAT | STEEL/E36-3 | 4088.5 | 45450 | 44161.1 | +3.950 | +4.227 | 222 | N41 | 1 | 1006 | GRENAILLE-PEINT | E36-3 | PLAT | 2.01837 | 2.08889 | 0.000257117 | 0 | 29.7642 | 0.0600752 | 0.0266101 | 70 | 380.144
PLAT | STEEL/E36-3 | 4088.5 | 45306.5 | 44161.6 | +3.950 | +4.227 | 221 | N41 | 1 | 1006 | GRENAILLE-PEINT | E36-3 | PLAT | 1.50225 | 1.51992 | 0.00019137 | 0.000549999 | 29.9751 | 0.0450302 | 0.019362 | 70 | 276.6
PLAT | STEEL/E36-3 | 4088.5 | 45306.5 | 44238.4 | +3.950 | +4.227 | 221 | N41 | 1 | 1006 | GRENAILLE-PEINT | E36-3 | PLAT | 1.50225 | 1.51992 | 0.00019137 | 0.000549999 | 29.9751 | 0.0450302 | 0.019362 | 70 | 276.6
PLAT | STEEL/E36-3 | 4088.5 | 45450 | 44238.9 | +3.950 | +4.227 | 222 | N41 | 1 | 1006 | GRENAILLE-PEINT | E36-3 | PLAT | 2.01837 | 2.08889 | 0.000257117 | 0 | 29.7642 | 0.0600752 | 0.0266101 | 70 | 380.144
PLAT | STEEL/E36-3 | 5741.5 | 45306.5 | 44238.4 | +5.603 | +5.880 | 221 | N41 | 1 | 1006 | GRENAILLE-PEINT | E36-3 | PLAT | 1.50225 | 1.51992 | 0.00019137 | 0.000549999 | 29.9751 | 0.0450302 | 0.019362 | 70 | 276.6
PLAT | STEEL/E36-3 | 5741.5 | 45306.5 | 44161.6 | +5.603 | +5.880 | 221 | N41 | 1 | 1006 | GRENAILLE-PEINT | E36-3 | PLAT | 1.50225 | 1.51992 | 0.00019137 | 0.000549999 | 29.9751 | 0.0450302 | 0.019362 | 70 | 276.6
PLAT | STEEL/E36-3 | 5741.5 | 45450 | 44238.9 | +5.603 | +5.880 | 222 | N41 | 1 | 1006 | GRENAILLE-PEINT | E36-3 | PLAT | 2.01837 | 2.08889 | 0.000257117 | 0 | 29.7642 | 0.0600752 | 0.0266101 | 70 | 380.144
PLAT | STEEL/E36-3 | 5741.5 | 45450 | 44161.1 | +5.603 | +5.880 | 222 | N41 | 1 | 1006 | GRENAILLE-PEINT | E36-3 | PLAT | 2.01837 | 2.08889 | 0.000257117 | 0 | 29.7642 | 0.0600752 | 0.0266101 | 70 | 380.144
PLAT | STEEL/E36-3 | 5741.5 | 45593.5 | 44238.4 | +5.603 | +5.880 | 221 | N41 | 1 | 1006 | GRENAILLE-PEINT | E36-3 | PLAT | 1.50225 | 1.51992 | 0.00019137 | 0.000549999 | 29.9751 | 0.0450302 | 0.019362 | 70 | 276.6
PLAT | STEEL/E36-3 | 5741.5 | 45593.5 | 44161.6 | +5.603 | +5.880 | 221 | N41 | 1 | 1006 | GRENAILLE-PEINT | E36-3 | PLAT | 1.50225 | 1.51992 | 0.00019137 | 0.000549999 | 29.9751 | 0.0450302 | 0.019362 | 70 | 276.6
PLAT | STEEL/E36-3 | 4088.5 | 58593.5 | 44161.6 | +3.950 | +4.227 | 221 | N42 | 1 | 1006 | GRENAILLE-PEINT | E36-3 | PLAT | 1.50225 | 1.51992 | 0.00019137 | 0.000549999 | 29.9751 | 0.0450302 | 0.019362 | 70 | 276.6
PLAT | STEEL/E36-3 | 4088.5 | 58593.5 | 44238.4 | +3.950 | +4.227 | 221 | N42 | 1 | 1006 | GRENAILLE-PEINT | E36-3 | PLAT | 1.50225 | 1.51992 | 0.00019137 | 0.000549999 | 29.9751 | 0.0450302 | 0.019362 | 70 | 276.6
PLAT | STEEL/E36-3 | 4088.5 | 58306.5 | 44161.6 | +3.950 | +4.227 | 221 | N42 | 1 | 1006 | GRENAILLE-PEINT | E36-3 | PLAT | 1.50225 | 1.51992 | 0.00019137 | 0.000549999 | 29.9751 | 0.0450302 | 0.019362 | 70 | 276.6
PLAT | STEEL/E36-3 | 4088.5 | 58306.5 | 44238.4 | +3.950 | +4.227 | 221 | N42 | 1 | 1006 | GRENAILLE-PEINT | E36-3 | PLAT | 1.50225 | 1.51992 | 0.00019137 | 0.000549999 | 29.9751 | 0.0450302 | 0.019362 | 70 | 276.6
PLAT | STEEL/E36-3 | 4088.5 | 58450 | 44238.9 | +3.950 | +4.227 | 222 | N42 | 1 | 1006 | GRENAILLE-PEINT | E36-3 | PLAT | 2.01837 | 2.08889 | 0.000257117 | 0 | 29.7642 | 0.0600752 | 0.0266101 | 70 | 380.144
PLAT | STEEL/E36-3 | 4088.5 | 58450 | 44161.1 | +3.950 | +4.227 | 222 | N42 | 1 | 1006 | GRENAILLE-PEINT | E36-3 | PLAT | 2.01837 | 2.08889 | 0.000257117 | 0 | 29.7642 | 0.0600752 | 0.0266101 | 70 | 380.144
PLAT | STEEL/E36-3 | 5741.5 | 58593.5 | 44238.4 | +5.603 | +5.880 | 221 | N42 | 1 | 1006 | GRENAILLE-PEINT | E36-3 | PLAT | 1.50225 | 1.51992 | 0.00019137 | 0.000549999 | 29.9751 | 0.0450302 | 0.019362 | 70 | 276.6
PLAT | STEEL/E36-3 | 5741.5 | 58593.5 | 44161.6 | +5.603 | +5.880 | 221 | N42 | 1 | 1006 | GRENAILLE-PEINT | E36-3 | PLAT | 1.50225 | 1.51992 | 0.00019137 | 0.000549999 | 29.9751 | 0.0450302 | 0.019362 | 70 | 276.6
PLAT | STEEL/E36-3 | 5741.5 | 58306.5 | 44238.4 | +5.603 | +5.880 | 221 | N42 | 1 | 1006 | GRENAILLE-PEINT | E36-3 | PLAT | 1.50225 | 1.51992 | 0.00019137 | 0.000549999 | 29.9751 | 0.0450302 | 0.019362 | 70 | 276.6
PLAT | STEEL/E36-3 | 5741.5 | 58306.5 | 44161.6 | +5.603 | +5.880 | 221 | N42 | 1 | 1006 | GRENAILLE-PEINT | E36-3 | PLAT | 1.50225 | 1.51992 | 0.00019137 | 0.000549999 | 29.9751 | 0.0450302 | 0.019362 | 70 | 276.6
PLAT | STEEL/E36-3 | 5741.5 | 58450 | 44161.1 | +5.603 | +5.880 | 222 | N42 | 1 | 1006 | GRENAILLE-PEINT | E36-3 | PLAT | 2.01837 | 2.08889 | 0.000257117 | 0 | 29.7642 | 0.0600752 | 0.0266101 | 70 | 380.144
PLAT | STEEL/E36-3 | 5741.5 | 58450 | 44238.9 | +5.603 | +5.880 | 222 | N42 | 1 | 1006 | GRENAILLE-PEINT | E36-3 | PLAT | 2.01837 | 2.08889 | 0.000257117 | 0 | 29.7642 | 0.0600752 | 0.0266101 | 70 | 380.144
PLAT | STEEL/E36-3 | 4088.5 | 55850 | 44161.1 | +3.950 | +4.227 | 222 | N42 | 1 | 1006 | GRENAILLE-PEINT | E36-3 | PLAT | 2.01837 | 2.08889 | 0.000257117 | 0 | 29.7642 | 0.0600752 | 0.0266101 | 70 | 380.144
PLAT | STEEL/E36-3 | 4088.5 | 55850 | 44238.9 | +3.950 | +4.227 | 222 | N42 | 1 | 1006 | GRENAILLE-PEINT | E36-3 | PLAT | 2.01837 | 2.08889 | 0.000257117 | 0 | 29.7642 | 0.0600752 | 0.0266101 | 70 | 380.144
PLAT | STEEL/E36-3 | 4088.5 | 55706.5 | 44238.4 | +3.950 | +4.227 | 221 | N42 | 1 | 1006 | GRENAILLE-PEINT | E36-3 | PLAT | 1.50225 | 1.51992 | 0.00019137 | 0.000549999 | 29.9751 | 0.0450302 | 0.019362 | 70 | 276.6
PLAT | STEEL/E36-3 | 4088.5 | 55706.5 | 44161.6 | +3.950 | +4.227 | 221 | N42 | 1 | 1006 | GRENAILLE-PEINT | E36-3 | PLAT | 1.50225 | 1.51992 | 0.00019137 | 0.000549999 | 29.9751 | 0.0450302 | 0.019362 | 70 | 276.6
PLAT | STEEL/E36-3 | 4088.5 | 55993.5 | 44238.4 | +3.950 | +4.227 | 221 | N42 | 1 | 1006 | GRENAILLE-PEINT | E36-3 | PLAT | 1.50225 | 1.51992 | 0.00019137 | 0.000549999 | 29.9751 | 0.0450302 | 0.019362 | 70 | 276.6
PLAT | STEEL/E36-3 | 4088.5 | 55993.5 | 44161.6 | +3.950 | +4.227 | 221 | N42 | 1 | 1006 | GRENAILLE-PEINT | E36-3 | PLAT | 1.50225 | 1.51992 | 0.00019137 | 0.000549999 | 29.9751 | 0.0450302 | 0.019362 | 70 | 276.6
PLAT | STEEL/E36-3 | 5741.5 | 55850 | 44238.9 | +5.603 | +5.880 | 222 | N42 | 1 | 1006 | GRENAILLE-PEINT | E36-3 | PLAT | 2.01837 | 2.08889 | 0.000257117 | 0 | 29.7642 | 0.0600752 | 0.0266101 | 70 | 380.144
PLAT | STEEL/E36-3 | 5741.5 | 55850 | 44161.1 | +5.603 | +5.880 | 222 | N42 | 1 | 1006 | GRENAILLE-PEINT | E36-3 | PLAT | 2.01837 | 2.08889 | 0.000257117 | 0 | 29.7642 | 0.0600752 | 0.0266101 | 70 | 380.144
PLAT | STEEL/E36-3 | 5741.5 | 55706.5 | 44161.6 | +5.603 | +5.880 | 221 | N42 | 1 | 1006 | GRENAILLE-PEINT | E36-3 | PLAT | 1.50225 | 1.51992 | 0.00019137 | 0.000549999 | 29.9751 | 0.0450302 | 0.019362 | 70 | 276.6
PLAT | STEEL/E36-3 | 5741.5 | 55706.5 | 44238.4 | +5.603 | +5.880 | 221 | N42 | 1 | 1006 | GRENAILLE-PEINT | E36-3 | PLAT | 1.50225 | 1.51992 | 0.00019137 | 0.000549999 | 29.9751 | 0.0450302 | 0.019362 | 70 | 276.6
PLAT | STEEL/E36-3 | 5741.5 | 55993.5 | 44161.6 | +5.603 | +5.880 | 221 | N42 | 1 | 1006 | GRENAILLE-PEINT | E36-3 | PLAT | 1.50225 | 1.51992 | 0.00019137 | 0.000549999 | 29.9751 | 0.0450302 | 0.019362 | 70 | 276.6
PLAT | STEEL/E36-3 | 5741.5 | 55993.5 | 44238.4 | +5.603 | +5.880 | 221 | N42 | 1 | 1006 | GRENAILLE-PEINT | E36-3 | PLAT | 1.50225 | 1.51992 | 0.00019137 | 0.000549999 | 29.9751 | 0.0450302 | 0.019362 | 70 | 276.6
TOLE | STEEL/S235JR | 5397.87 | 27211.3 | 69773.1 | +5.260 | +5.536 | 215 | K49 | 1 | 1010 |  | S235JR | TOLE | 1.48574 | 1.51909 | 0.000189266 | 0.000493893 | 29.9788 | 0.0445408 | 0.0193514 | 70 | 276.449

# IfcPlate: PL10*75, TOLE
In: Undefined
Description: PL10*75; Material: STEEL/S235JR
Tekla Common - Center of gravity Z: 5394.05 mm; Center of gravity Y: 29858 mm; Center of gravity X: 69724.1 mm; Bottom elevation: +5.259; Top elevation: +5.529; Part mark: 282; Assembly mark: N36; Phase: 1; Class: 1011; Finish: GRENAILLE-PEINT; Grade: S235JR; Profile: PL10*75; Name: TOLE; sets with these values: 2
Tekla Quantity - Net weight: 1.56666 kg; Gross weight: 1.58433 kg; Weight: 1.56666 kg; Net volume: 0.000199575 m3; Gross volume: 0.000199575 m3; Gross footprint area: 0.0006 m2; Area per tons: 29.7583 m2; Net surface area: 0.0466213 m2; Gross area: 0.0201825 m2; Height: 75 mm; Width: 10 mm; Length: 269.1 mm; sets with these values: 2

# IfcPlate: PL10*80 (11)
In: Undefined
Description: PL10*80
Tekla Common - Profile: PL10*80; Name: TOLE; sets with these values: 2
Tekla Quantity - Height: 80 mm; Width: 10 mm; sets with these values: 2
Name | Material | Center of gravity Z (mm) | Center of gravity Y (mm) | Center of gravity X (mm) | Bottom elevation | Top elevation | Part mark | Assembly mark | Phase | Class | Finish | Grade | Net weight (kg) = Weight (kg) | Gross weight (kg) | Net volume (m3) = Gross volume (m3) | Gross footprint area (m2) | Area per tons (m2) | Net surface area (m2) | Gross area (m2) | Length (mm)
TOLE | STEEL/E24-2 | 3323 | 48568.7 | 0 | +3.318 | +3.328 | 197 | P127 | 2 | 2001 | GRENAILLE-PEINT | E24-2 | 0.930617 | 0.94828 | 0.00011855 | 0.011855 | 30.2533 | 0.0281543 | 0.01208 | 151
TOLE | STEEL/E24-2 | 3323 | 48478.3 | 0 | +3.318 | +3.328 | 197 | P127 | 2 | 2001 | GRENAILLE-PEINT | E24-2 | 0.930617 | 0.94828 | 0.00011855 | 0.011855 | 30.2533 | 0.0281543 | 0.01208 | 151
TOLE | STEEL/E24-2 | 3323 | 40206.3 | 0 | +3.318 | +3.328 | 197 | P126 | 2 | 2001 | GRENAILLE-PEINT | E24-2 | 0.930617 | 0.94828 | 0.00011855 | 0.011855 | 30.2533 | 0.0281543 | 0.01208 | 151
TOLE | STEEL/E24-2 | 3323 | 40293.7 | 0 | +3.318 | +3.328 | 197 | P126 | 2 | 2001 | GRENAILLE-PEINT | E24-2 | 0.930617 | 0.94828 | 0.00011855 | 0.011855 | 30.2533 | 0.0281543 | 0.01208 | 151
TOLE | STEEL/S235JR | 5391.48 | 32494.6 | 69773.1 | +5.249 | +5.534 | 216 | K99 | 1 | 1010 |  | S235JR | 1.75767 | 1.79102 | 0.000223907 | 0.000593893 | 29.4958 | 0.0518438 | 0.0228155 | 285.194
TOLE | STEEL/S235JR | 5366.14 | 32405.5 | 69773.1 | +5.198 | +5.534 | 218 | K99 | 1 | 1010 |  | S235JR | 2.0759 | 2.10924 | 0.000264445 | 0.000593893 | 29.368 | 0.060965 | 0.0268694 | 335.867
TOLE | STEEL/S235JR | 5390.8 | 31736.7 | 69808.4 | +5.253 | +5.529 | 281 | N36 | 1 | 1011 | GRENAILLE-PEINT | S235JR | 1.71311 | 1.73077 | 0.00021823 | 0.00065 | 29.5266 | 0.0505823 | 0.022048 | 275.6
TOLE | STEEL/S235JR | 5390.8 | 30536.7 | 69808.4 | +5.253 | +5.529 | 281 | N36 | 1 | 1011 | GRENAILLE-PEINT | S235JR | 1.71311 | 1.73077 | 0.00021823 | 0.00065 | 29.5266 | 0.0505823 | 0.022048 | 275.6
TOLE | STEEL/S235JR | 5390.8 | 27736.7 | 69808.4 | +5.253 | +5.529 | 281 | N36 | 1 | 1011 | GRENAILLE-PEINT | S235JR | 1.71311 | 1.73077 | 0.00021823 | 0.00065 | 29.5266 | 0.0505823 | 0.022048 | 275.6
TOLE | STEEL/S235JR | 5390.8 | 29136.7 | 69808.4 | +5.253 | +5.529 | 281 | N36 | 1 | 1011 | GRENAILLE-PEINT | S235JR | 1.71311 | 1.73077 | 0.00021823 | 0.00065 | 29.5266 | 0.0505823 | 0.022048 | 275.6
TOLE | STEEL/S235JR | 5397.87 | 27293.7 | 69773.1 | +5.260 | +5.536 | 217 | K49 | 1 | 1010 |  | S235JR | 1.70275 | 1.7361 | 0.000216911 | 0.000593893 | 29.5226 | 0.0502698 | 0.0221159 | 276.449

# IfcPlate: PL10*86 (2)
In: Undefined
Description: PL10*86; Material: STEEL/E24-2
Tekla Common - Center of gravity Z: 3840 mm; Center of gravity X: -47.8402 mm; Bottom elevation: +3.654; Top elevation: +4.026; Part mark: 295; Phase: 2; Class: 2006; Finish: GRENAILLE-PEINT; Grade: E24-2; Profile: PL10*86; Name: TOLE; sets with these values: 2
Tekla Quantity - Net weight: 2.45355 kg; Gross weight: 2.50261 kg; Weight: 2.45355 kg; Net volume: 0.000312554 m3; Gross volume: 0.000312554 m3; Gross footprint area: 0.000607 m2; Area per tons: 29.0893 m2; Net surface area: 0.0713719 m2; Gross area: 0.0318804 m2; Height: 85.7 mm; Width: 10 mm; Length: 372 mm; sets with these values: 2
Name | Center of gravity Y (mm) | Assembly mark
TOLE | 48525 | N22
TOLE | 10930 | N20

# IfcPlate: PL10*89 (9)
In: Undefined
Description: PL10*89
Tekla Common - Finish: GRENAILLE-PEINT; Profile: PL10*89; sets with these values: 2
Tekla Quantity - Width: 10 mm; sets with these values: 2
Name | Material | Center of gravity Z (mm) | Center of gravity Y (mm) | Center of gravity X (mm) | Bottom elevation | Top elevation | Part mark | Assembly mark | Phase | Class | Grade | Name | Net weight (kg) = Weight (kg) | Gross weight (kg) | Net volume (m3) = Gross volume (m3) | Gross footprint area (m2) | Area per tons (m2) | Net surface area (m2) | Gross area (m2) | Height (mm) | Length (mm)
TOLE | STEEL/S235JR | 5485.07 | 27360 | 69838 | +5.441 | +5.530 | 214 | N36 | 1 | 1011 | S235JR | TOLE | 0.96347 | 0.972301 | 0.000122735 | 0.0012367 | 30.1192 | 0.0290189 | 0.012386 | 89.32 | 138.67
PLATINE | STEEL/E24-2 | 3947.32 | 19450 | 55552.7 | +3.867 | +4.016 | 205 | K21 | 1 | 1005 | E24-2 | PLATINE | 1.8061 | 3.40066 | 0.000230077 | 0 | 31.2692 | 0.0564755 | 0.0433205 | 88.8324 | 487.666
PLATINE | STEEL/E24-2 | 3947.32 | 40250 | 55552.7 | +3.867 | +4.016 | 205 | K22 | 1 | 1005 | E24-2 | PLATINE | 1.80595 | 3.40066 | 0.000230057 | 0 | 31.2697 | 0.0564714 | 0.0433206 | 88.8319 | 487.669
PLATINE | STEEL/E24-2 | 3947.32 | 40250 | 67227.7 | +3.867 | +4.016 | 205 | K24 | 1 | 1005 | E24-2 | PLATINE | 1.80595 | 3.40066 | 0.000230057 | 0 | 31.2697 | 0.0564714 | 0.0433206 | 88.8319 | 487.669
PLATINE | STEEL/E24-2 | 3947.32 | 40250 | 43877.7 | +3.867 | +4.016 | 205 | K22 | 3 | 3005 | E24-2 | PLATINE | 1.80595 | 3.40066 | 0.000230057 | 0 | 31.2697 | 0.0564714 | 0.0433206 | 88.8319 | 487.669
PLATINE | STEEL/E24-2 | 3947.32 | 40250 | 32202.7 | +3.867 | +4.016 | 205 | K23 | 3 | 3005 | E24-2 | PLATINE | 1.80595 | 3.40066 | 0.000230057 | 0 | 31.2697 | 0.0564714 | 0.0433206 | 88.8319 | 487.669
PLATINE | STEEL/E24-2 | 3947.32 | 19450 | 32202.7 | +3.867 | +4.016 | 205 | K21 | 3 | 3005 | E24-2 | PLATINE | 1.8061 | 3.40066 | 0.000230077 | 0 | 31.2692 | 0.0564755 | 0.0433205 | 88.8324 | 487.666
PLATINE | STEEL/E24-2 | 3947.32 | 19450 | 43877.7 | +3.867 | +4.016 | 205 | K21 | 3 | 3005 | E24-2 | PLATINE | 1.8061 | 3.40066 | 0.000230077 | 0 | 31.2692 | 0.0564755 | 0.0433205 | 88.8324 | 487.666
PLATINE | STEEL/E24-2 | 3947.32 | 19450 | 67227.7 | +3.867 | +4.016 | 205 | K21 | 1 | 1005 | E24-2 | PLATINE | 1.8061 | 3.40066 | 0.000230077 | 0 | 31.2692 | 0.0564755 | 0.0433205 | 88.8324 | 487.666

# IfcPlate: PL10*90 (53)
In: Undefined
Description: PL10*90
Tekla Common - Finish: GRENAILLE-PEINT; Profile: PL10*90; sets with these values: 2
Tekla Quantity - Width: 10 mm; sets with these values: 2
Name | Material | Center of gravity Z (mm) | Center of gravity Y (mm) | Center of gravity X (mm) | Bottom elevation | Top elevation | Part mark | Assembly mark | Phase | Class | Grade | Name | Net weight (kg) = Weight (kg) | Gross weight (kg) | Net volume (m3) = Gross volume (m3) | Gross footprint area (m2) | Area per tons (m2) | Net surface area (m2) | Gross area (m2) | Height (mm) | Length (mm)
PLAT | STEEL/E24-2 | 3641.84 | 32242.6 | 2456.34 | +3.635 | +3.648 | 271 | H82 | 2 | 2003 | E24-2 | PLAT | 1.00538 | 1.00543 | 0.000128074 | 0 | 30.0967 | 0.0302587 | 0.012808 | 90.1929 | 142.007
 | STEEL/E24-2 | 3710.12 | 13591.6 | 75518.3 | +3.700 | +3.720 | 247 | K57 | 1 | 1010 | E24-2 |  | 1.4836 | 2.11947 | 0.000188993 | 0 | 30.0245 | 0.0445442 | 0.0269996 | 89.9981 | 300.002
 | STEEL/E24-2 | 5099.33 | 13397.9 | 75521.7 | +5.090 | +5.109 | 247 | K56 | 1 | 1010 | E24-2 |  | 1.4836 | 2.11947 | 0.000188993 | 0 | 30.0245 | 0.0445442 | 0.0269996 | 89.9981 | 300.002
 | STEEL/E24-2 | 3820.06 | 15591.7 | 75521.7 | +3.810 | +3.830 | 247 | K58 | 1 | 1010 | E24-2 |  | 1.4836 | 2.11947 | 0.000188993 | 0 | 30.0245 | 0.0445442 | 0.0269996 | 89.9981 | 300.002
 | STEEL/E24-2 | 4989.39 | 12411.6 | 75518.3 | +4.980 | +4.999 | 247 | K45 | 1 | 1010 | E24-2 |  | 1.4836 | 2.11947 | 0.000188993 | 0 | 30.0245 | 0.0445442 | 0.0269996 | 89.9981 | 300.002
PLATINE | STEEL/E36-3 | 3027.35 | 25 | 44149.3 | +3.022 | +3.032 | 171 | P22 | 1 | 1001 | E36-3 | PLATINE | 3.25029 | 3.29936 | 0.00041405 | 0.041405 | 28.815 | 0.0936571 | 0.04203 | 90 | 467
PLATINE | STEEL/E36-3 | 3027.35 | 25 | 44250.7 | +3.022 | +3.032 | 171 | P22 | 1 | 1001 | E36-3 | PLATINE | 3.25029 | 3.29936 | 0.00041405 | 0.041405 | 28.815 | 0.0936571 | 0.04203 | 90 | 467
PLATINE | STEEL/E36-3 | 3314.35 | 25 | 44149.3 | +3.309 | +3.319 | 171 | P22 | 1 | 1001 | E36-3 | PLATINE | 3.25029 | 3.29936 | 0.00041405 | 0.041405 | 28.815 | 0.0936571 | 0.04203 | 90 | 467
PLATINE | STEEL/E36-3 | 3314.35 | 25 | 44250.7 | +3.309 | +3.319 | 171 | P22 | 1 | 1001 | E36-3 | PLATINE | 3.25029 | 3.29936 | 0.00041405 | 0.041405 | 28.815 | 0.0936571 | 0.04203 | 90 | 467
TOLE | STEEL/S235JR | 3881.76 | 15625.3 | 71865.8 | +3.784 | +3.982 | 213 | N5 | 1 | 1011 | S235JR | TOLE | 1.3761 | 1.40064 | 0.0001753 | 0.00065 | 29.5606 | 0.0406786 | 0.0178425 | 90 | 198.25
TOLE | STEEL/S235JR | 3881.76 | 19791.9 | 71865.8 | +3.784 | +3.982 | 213 | N5 | 1 | 1011 | S235JR | TOLE | 1.3761 | 1.40064 | 0.0001753 | 0.00065 | 29.5606 | 0.0406786 | 0.0178425 | 90 | 198.25
TOLE | STEEL/S235JR | 3881.76 | 23958.6 | 71865.8 | +3.784 | +3.982 | 213 | N5 | 1 | 1011 | S235JR | TOLE | 1.3761 | 1.40064 | 0.0001753 | 0.00065 | 29.5606 | 0.0406786 | 0.0178425 | 90 | 198.25
PLATINE | STEEL/E24-2 | 5273.42 | 5108.05 | 67598.2 | +5.140 | +5.405 | 181 | N14 | 1 | 1006 | E24-2 | PLATINE | 1.85825 | 1.87207 | 0.00023672 | 0.000900016 | 29.2531 | 0.0543595 | 0.023848 | 90.0016 | 264.973
PLATINE | STEEL/E24-2 | 5273.42 | 10018 | 67598.2 | +5.140 | +5.405 | 181 | N12 | 1 | 1006 | E24-2 | PLATINE | 1.85825 | 1.87207 | 0.00023672 | 0.000900016 | 29.2531 | 0.0543595 | 0.023848 | 90.0016 | 264.973
PLATINE | STEEL/E24-2 | 5273.35 | -8.05 | 67600.3 | +5.140 | +5.405 | 180 | P24 | 1 | 1001 | E24-2 | PLATINE | 1.85825 | 1.87207 | 0.00023672 | 0.000900016 | 29.2531 | 0.0543595 | 0.023848 | 90.0016 | 264.973
TOLE | STEEL/E36-3 | 5597.6 | 25 | 67499.3 | +5.593 | +5.603 | 182 | P24 | 1 | 1001 | E36-3 | TOLE | 3.23616 | 3.28523 | 0.00041225 | 0.041225 | 28.8172 | 0.0932571 | 0.04185 | 90 | 465
TOLE | STEEL/E36-3 | 5597.6 | 25 | 67600.7 | +5.593 | +5.603 | 182 | P24 | 1 | 1001 | E36-3 | TOLE | 3.23616 | 3.28523 | 0.00041225 | 0.041225 | 28.8172 | 0.0932571 | 0.04185 | 90 | 465
TOLE | STEEL/E36-3 | 4232.4 | 25 | 67499.3 | +4.227 | +4.237 | 182 | P24 | 1 | 1001 | E36-3 | TOLE | 3.23616 | 3.28523 | 0.00041225 | 0.041225 | 28.8172 | 0.0932571 | 0.04185 | 90 | 465
TOLE | STEEL/E36-3 | 4232.4 | 25 | 67600.7 | +4.227 | +4.237 | 182 | P24 | 1 | 1001 | E36-3 | TOLE | 3.23616 | 3.28523 | 0.00041225 | 0.041225 | 28.8172 | 0.0932571 | 0.04185 | 90 | 465
TOLE | STEEL/E36-3 | 3945 | 25 | 67499.3 | +3.940 | +3.950 | 182 | P24 | 1 | 1001 | E36-3 | TOLE | 3.23616 | 3.28523 | 0.00041225 | 0.041225 | 28.8172 | 0.0932571 | 0.04185 | 90 | 465
TOLE | STEEL/E36-3 | 3945 | 25 | 67600.7 | +3.940 | +3.950 | 182 | P24 | 1 | 1001 | E36-3 | TOLE | 3.23616 | 3.28523 | 0.00041225 | 0.041225 | 28.8172 | 0.0932571 | 0.04185 | 90 | 465
TOLE | STEEL/E36-3 | 5597.6 | 69125 | 67499.3 | +5.593 | +5.603 | 182 | P23 | 1 | 1001 | E36-3 | TOLE | 3.23616 | 3.28523 | 0.00041225 | 0.041225 | 28.8172 | 0.0932571 | 0.04185 | 90 | 465
TOLE | STEEL/E36-3 | 5597.6 | 69125 | 67600.7 | +5.593 | +5.603 | 182 | P23 | 1 | 1001 | E36-3 | TOLE | 3.23616 | 3.28523 | 0.00041225 | 0.041225 | 28.8172 | 0.0932571 | 0.04185 | 90 | 465
TOLE | STEEL/E36-3 | 4232.4 | 69125 | 67499.3 | +4.227 | +4.237 | 182 | P23 | 1 | 1001 | E36-3 | TOLE | 3.23616 | 3.28523 | 0.00041225 | 0.041225 | 28.8172 | 0.0932571 | 0.04185 | 90 | 465
TOLE | STEEL/E36-3 | 4232.4 | 69125 | 67600.7 | +4.227 | +4.237 | 182 | P23 | 1 | 1001 | E36-3 | TOLE | 3.23616 | 3.28523 | 0.00041225 | 0.041225 | 28.8172 | 0.0932571 | 0.04185 | 90 | 465
TOLE | STEEL/E36-3 | 3945 | 69125 | 67499.3 | +3.940 | +3.950 | 182 | P23 | 1 | 1001 | E36-3 | TOLE | 3.23616 | 3.28523 | 0.00041225 | 0.041225 | 28.8172 | 0.0932571 | 0.04185 | 90 | 465
TOLE | STEEL/E36-3 | 3945 | 69125 | 67600.7 | +3.940 | +3.950 | 182 | P23 | 1 | 1001 | E36-3 | TOLE | 3.23616 | 3.28523 | 0.00041225 | 0.041225 | 28.8172 | 0.0932571 | 0.04185 | 90 | 465
TOLE | STEEL/E36-3 | 5597.6 | 25 | 55824.3 | +5.593 | +5.603 | 182 | P25 | 1 | 1001 | E36-3 | TOLE | 3.23616 | 3.28523 | 0.00041225 | 0.041225 | 28.8172 | 0.0932571 | 0.04185 | 90 | 465
TOLE | STEEL/E36-3 | 5597.6 | 25 | 55925.7 | +5.593 | +5.603 | 182 | P25 | 1 | 1001 | E36-3 | TOLE | 3.23616 | 3.28523 | 0.00041225 | 0.041225 | 28.8172 | 0.0932571 | 0.04185 | 90 | 465
TOLE | STEEL/E36-3 | 3945 | 25 | 55824.3 | +3.940 | +3.950 | 182 | P25 | 1 | 1001 | E36-3 | TOLE | 3.23616 | 3.28523 | 0.00041225 | 0.041225 | 28.8172 | 0.0932571 | 0.04185 | 90 | 465
TOLE | STEEL/E36-3 | 3945 | 25 | 55925.7 | +3.940 | +3.950 | 182 | P25 | 1 | 1001 | E36-3 | TOLE | 3.23616 | 3.28523 | 0.00041225 | 0.041225 | 28.8172 | 0.0932571 | 0.04185 | 90 | 465
TOLE | STEEL/E36-3 | 4232.4 | 25 | 55824.3 | +4.227 | +4.237 | 182 | P25 | 1 | 1001 | E36-3 | TOLE | 3.23616 | 3.28523 | 0.00041225 | 0.041225 | 28.8172 | 0.0932571 | 0.04185 | 90 | 465
TOLE | STEEL/E36-3 | 4232.4 | 25 | 55925.7 | +4.227 | +4.237 | 182 | P25 | 1 | 1001 | E36-3 | TOLE | 3.23616 | 3.28523 | 0.00041225 | 0.041225 | 28.8172 | 0.0932571 | 0.04185 | 90 | 465
TOLE | STEEL/E36-3 | 3945 | 69125 | 55824.3 | +3.940 | +3.950 | 182 | P27 | 1 | 1001 | E36-3 | TOLE | 3.23616 | 3.28523 | 0.00041225 | 0.041225 | 28.8172 | 0.0932571 | 0.04185 | 90 | 465
TOLE | STEEL/E36-3 | 3945 | 69125 | 55925.7 | +3.940 | +3.950 | 182 | P27 | 1 | 1001 | E36-3 | TOLE | 3.23616 | 3.28523 | 0.00041225 | 0.041225 | 28.8172 | 0.0932571 | 0.04185 | 90 | 465
TOLE | STEEL/E36-3 | 5597.6 | 69125 | 55824.3 | +5.593 | +5.603 | 182 | P27 | 1 | 1001 | E36-3 | TOLE | 3.23616 | 3.28523 | 0.00041225 | 0.041225 | 28.8172 | 0.0932571 | 0.04185 | 90 | 465
TOLE | STEEL/E36-3 | 5597.6 | 69125 | 55925.7 | +5.593 | +5.603 | 182 | P27 | 1 | 1001 | E36-3 | TOLE | 3.23616 | 3.28523 | 0.00041225 | 0.041225 | 28.8172 | 0.0932571 | 0.04185 | 90 | 465
TOLE | STEEL/E36-3 | 4232.4 | 69125 | 55824.3 | +4.227 | +4.237 | 182 | P27 | 1 | 1001 | E36-3 | TOLE | 3.23616 | 3.28523 | 0.00041225 | 0.041225 | 28.8172 | 0.0932571 | 0.04185 | 90 | 465
TOLE | STEEL/E36-3 | 4232.4 | 69125 | 55925.7 | +4.227 | +4.237 | 182 | P27 | 1 | 1001 | E36-3 | TOLE | 3.23616 | 3.28523 | 0.00041225 | 0.041225 | 28.8172 | 0.0932571 | 0.04185 | 90 | 465
PLATINE | STEEL/E36-3 | 4232 | 25 | 44250.7 | +4.227 | +4.237 | 171 | P22 | 1 | 1001 | E36-3 | PLATINE | 3.25029 | 3.29936 | 0.00041405 | 0.041405 | 28.815 | 0.0936571 | 0.04203 | 90 | 467
PLATINE | STEEL/E36-3 | 4232 | 25 | 44149.3 | +4.227 | +4.237 | 171 | P22 | 1 | 1001 | E36-3 | PLATINE | 3.25029 | 3.29936 | 0.00041405 | 0.041405 | 28.815 | 0.0936571 | 0.04203 | 90 | 467
PLATINE | STEEL/E36-3 | 3945 | 25 | 44250.7 | +3.940 | +3.950 | 171 | P22 | 1 | 1001 | E36-3 | PLATINE | 3.25029 | 3.29936 | 0.00041405 | 0.041405 | 28.815 | 0.0936571 | 0.04203 | 90 | 467
PLATINE | STEEL/E36-3 | 3945 | 25 | 44149.3 | +3.940 | +3.950 | 171 | P22 | 1 | 1001 | E36-3 | PLATINE | 3.25029 | 3.29936 | 0.00041405 | 0.041405 | 28.815 | 0.0936571 | 0.04203 | 90 | 467
PLATINE | STEEL/E36-3 | 5598 | 25 | 44250.7 | +5.593 | +5.603 | 171 | P22 | 1 | 1001 | E36-3 | PLATINE | 3.25029 | 3.29936 | 0.00041405 | 0.041405 | 28.815 | 0.0936571 | 0.04203 | 90 | 467
PLATINE | STEEL/E36-3 | 5598 | 25 | 44149.3 | +5.593 | +5.603 | 171 | P22 | 1 | 1001 | E36-3 | PLATINE | 3.25029 | 3.29936 | 0.00041405 | 0.041405 | 28.815 | 0.0936571 | 0.04203 | 90 | 467
PLATINE | STEEL/E36-3 | 4232 | 69125 | 44250.7 | +4.227 | +4.237 | 171 | P26 | 1 | 1001 | E36-3 | PLATINE | 3.25029 | 3.29936 | 0.00041405 | 0.041405 | 28.815 | 0.0936571 | 0.04203 | 90 | 467
PLATINE | STEEL/E36-3 | 4232 | 69125 | 44149.3 | +4.227 | +4.237 | 171 | P26 | 1 | 1001 | E36-3 | PLATINE | 3.25029 | 3.29936 | 0.00041405 | 0.041405 | 28.815 | 0.0936571 | 0.04203 | 90 | 467
PLATINE | STEEL/E36-3 | 3945 | 69125 | 44250.7 | +3.940 | +3.950 | 171 | P26 | 1 | 1001 | E36-3 | PLATINE | 3.25029 | 3.29936 | 0.00041405 | 0.041405 | 28.815 | 0.0936571 | 0.04203 | 90 | 467
PLATINE | STEEL/E36-3 | 3945 | 69125 | 44149.3 | +3.940 | +3.950 | 171 | P26 | 1 | 1001 | E36-3 | PLATINE | 3.25029 | 3.29936 | 0.00041405 | 0.041405 | 28.815 | 0.0936571 | 0.04203 | 90 | 467
PLATINE | STEEL/E36-3 | 5598 | 69125 | 44250.7 | +5.593 | +5.603 | 171 | P26 | 1 | 1001 | E36-3 | PLATINE | 3.25029 | 3.29936 | 0.00041405 | 0.041405 | 28.815 | 0.0936571 | 0.04203 | 90 | 467
PLATINE | STEEL/E36-3 | 5598 | 69125 | 44149.3 | +5.593 | +5.603 | 171 | P26 | 1 | 1001 | E36-3 | PLATINE | 3.25029 | 3.29936 | 0.00041405 | 0.041405 | 28.815 | 0.0936571 | 0.04203 | 90 | 467
PLATINE | STEEL/E24-2 | 5273.42 | 14738 | 67598.2 | +5.140 | +5.405 | 181 | N12 | 1 | 1006 | E24-2 | PLATINE | 1.85825 | 1.87207 | 0.00023672 | 0.000900016 | 29.2531 | 0.0543595 | 0.023848 | 90.0016 | 264.973
TOLE | STEEL/S235JR | 3864.52 | 13541.9 | 71865.3 | +3.757 | +3.970 | 251 | P123 | 1 | 1011 | S235JR | TOLE | 1.49389 | 1.50852 | 0.000190304 | 0.0008999 | 29.4826 | 0.0440436 | 0.0192168 | 90.0955 | 213.293

# IfcPlate: PL10*97 (2)
In: Undefined
Description: PL10*97; Material: STEEL/E24-2
Tekla Common - Center of gravity Z: 4088.7 mm; Center of gravity Y: 69150 mm; Bottom elevation: +3.950; Top elevation: +4.227; Part mark: 239; Phase: 1; Class: 1001; Finish: GRENAILLE-PEINT; Grade: E24-2; Profile: PL10*97; sets with these values: 2
Tekla Quantity - Net weight: 2.10919 kg; Gross weight: 2.11704 kg; Weight: 2.10919 kg; Net volume: 0.000268687 m3; Gross volume: 0.000268687 m3; Gross footprint area: 0.000872196 m2; Area per tons: 28.9744 m2; Net surface area: 0.0611127 m2; Gross area: 0.0269687 m2; Height: 97.2196 mm; Width: 10 mm; Length: 277.4 mm; sets with these values: 2
Name | Center of gravity X (mm) | Assembly mark
 | 55928.9 | P27
 | 67603.9 | P23

# IfcPlate: PL12*100 (4)
In: Undefined
Description: PL12*100; Material: STEEL/E24-2
Tekla Common - Center of gravity Y: 27250 mm; Part mark: 1264; Assembly mark: N5; Phase: 1; Class: 1011; Finish: GRENAILLE-PEINT; Grade: E24-2; Profile: PL12*100; Name: TOLE; sets with these values: 2
Tekla Quantity - Net weight: 1.70502 kg; Gross weight: 1.7427 kg; Weight: 1.70502 kg; Net volume: 0.0002172 m3; Gross volume: 0.0002172 m3; Gross footprint area: 0.0181 m2; Area per tons: 25.0782 m2; Net surface area: 0.0427588 m2; Gross area: 0.0185 m2; Height: 100 mm; Width: 12 mm; Length: 185 mm; sets with these values: 2
Name | Center of gravity Z (mm) | Center of gravity X (mm) | Bottom elevation | Top elevation
TOLE | 3994 | 71760.5 | +3.988 | +4.000
TOLE | 3506 | 71869.5 | +3.500 | +3.512
TOLE | 3994 | 71869.5 | +3.988 | +4.000
TOLE | 3506 | 71760.5 | +3.500 | +3.512

# IfcPlate: PL12*215 (2)
In: Undefined
Description: PL12*215; Material: STEEL/E24-2
Tekla Common - Center of gravity Z: -299.294 mm; Center of gravity X: 20261.3 mm; Bottom elevation: -0.380; Top elevation: -0.165; Part mark: 1266; Assembly mark: H78; Phase: 2; Class: 2002; Finish: GRENAILLE-PEINT; Grade: E24-2; Profile: PL12*215; Name: ATTACHE; sets with these values: 2
Tekla Quantity - Net weight: 7.00118 kg; Gross weight: 10.0273 kg; Weight: 7.00118 kg; Net volume: 0.00089187 m3; Gross volume: 0.00089187 m3; Gross footprint area: 0 m2; Area per tons: 23.4155 m2; Net surface area: 0.163936 m2; Gross area: 0.106447 m2; Height: 214.611 mm; Width: 12 mm; Length: 496 mm; sets with these values: 2
Name | Center of gravity Y (mm)
ATTACHE | 10930
ATTACHE | 48525

# IfcPlate: PL12*235 (2)
In: Undefined
Description: PL12*235; Material: STEEL/E24-2
Tekla Common - Center of gravity Z: 3001.2 mm; Center of gravity X: 9921.61 mm; Bottom elevation: +2.859; Top elevation: +3.083; Part mark: 1269; Phase: 2; Class: 2005; Finish: GRENAILLE-PEINT; Grade: E24-2; Profile: PL12*235; Name: ATTACHE; sets with these values: 2
Tekla Quantity - Net weight: 7.32085 kg; Gross weight: 14.6417 kg; Weight: 7.32085 kg; Net volume: 0.000932592 m3; Gross volume: 0.000932592 m3; Gross footprint area: 0 m2; Area per tons: 23.8503 m2; Net surface area: 0.174604 m2; Gross area: 0.155432 m2; Height: 235.152 mm; Width: 12 mm; Length: 660.986 mm; sets with these values: 2
Name | Center of gravity Y (mm) | Assembly mark
ATTACHE | 48525 | K101
ATTACHE | 10930 | K102

# IfcPlate: PL12*70 (8)
In: Undefined
Description: PL12*70; Material: STEEL/S235JR
Tekla Common - Center of gravity X: -581 mm; Part mark: 1259; Assembly mark: E3; Phase: 4; Class: 4000; Finish: GALVANISE; Grade: S235JR; Profile: PL12*70; Name: SUPPORT; sets with these values: 2
Tekla Quantity - Net weight: 0.855807 kg; Gross weight: 0.877002 kg; Weight: 0.855807 kg; Net volume: 0.00010902 m3; Gross volume: 0.00010902 m3; Gross footprint area: 0.009085 m2; Area per tons: 26.6779 m2; Net surface area: 0.0228311 m2; Gross area: 0.00931 m2; Height: 70 mm; Width: 12 mm; Length: 133 mm; sets with these values: 2
Name | Center of gravity Z (mm) | Center of gravity Y (mm) | Bottom elevation | Top elevation
SUPPORT | 3634 | 40288.7 | +3.628 | +3.640
SUPPORT | 3634 | 40211.3 | +3.628 | +3.640
SUPPORT | 3316 | 40211.3 | +3.310 | +3.322
SUPPORT | 3316 | 40288.7 | +3.310 | +3.322
SUPPORT | 3316 | 48563.7 | +3.310 | +3.322
SUPPORT | 3316 | 48486.3 | +3.310 | +3.322
SUPPORT | 3634 | 48486.3 | +3.628 | +3.640
SUPPORT | 3634 | 48563.7 | +3.628 | +3.640

# IfcPlate: PL12*90 (4)
In: Undefined
Description: PL12*90; Material: STEEL/E24-2
Tekla Common - Center of gravity Z: 3750 mm; Part mark: 1263; Assembly mark: N5; Phase: 1; Class: 1011; Finish: GRENAILLE-PEINT; Grade: E24-2; Profile: PL12*90; Name: TOLE; sets with these values: 2
Tekla Quantity - Net weight: 3.8834 kg; Gross weight: 3.94227 kg; Weight: 3.8834 kg; Net volume: 0.0004947 m3; Gross volume: 0.0004947 m3; Gross footprint area: 0.00078 m2; Area per tons: 24.5709 m2; Net surface area: 0.0954185 m2; Gross area: 0.04185 m2; Height: 90 mm; Width: 12 mm; Length: 465 mm; sets with these values: 2
Name | Center of gravity Y (mm) | Center of gravity X (mm) | Bottom elevation | Top elevation
TOLE | 26175 | 71764.3 | +3.517 | +3.982
TOLE | 26175 | 71865.7 | +3.518 | +3.983
TOLE | 25925 | 71865.7 | +3.518 | +3.983
TOLE | 25925 | 71764.3 | +3.518 | +3.983

# IfcPlate: PL1385*941, CONDENSEUR
In: Undefined
Description: PL1385*941; Material: STEEL/S235JR
Tekla Common - Center of gravity Z: 5172.5 mm; Center of gravity Y: 20273.5 mm; Center of gravity X: 77474.5 mm; Bottom elevation: +4.480; Top elevation: +5.865; Part mark: Z64; Assembly mark: Z64; Phase: 10; Class: 77; Grade: S235JR; Profile: PL1385*941; Name: CONDENSEUR; sets with these values: 2
Tekla Quantity - Net weight: 41874.6 kg; Gross weight: 41874.6 kg; Weight: 41874.6 kg; Net volume: 5.33435 m3; Gross volume: 5.33435 m3; Gross footprint area: 3.85151 m2; Area per tons: 0.516953 m2; Net surface area: 21.6472 m2; Gross area: 3.85151 m2; Height: 941 mm; Width: 1385 mm; Length: 4093 mm; sets with these values: 2

# IfcPlate: PL15*151 (2)
In: Undefined
Description: PL15*151; Material: STEEL/E24-2
Tekla Common - Center of gravity Z: 4089.79 mm; Bottom elevation: +3.950; Top elevation: +4.227; Part mark: 145; Phase: 1; Class: 1001; Finish: GRENAILLE-PEINT; Grade: E24-2; Profile: PL15*151; sets with these values: 2
Tekla Quantity - Net weight: 3.88123 kg; Gross weight: 4.92908 kg; Weight: 3.88123 kg; Net volume: 0.000494424 m3; Gross volume: 0.000494424 m3; Gross footprint area: 0.00086925 m2; Area per tons: 19.8382 m2; Net surface area: 0.0769966 m2; Gross area: 0.0418606 m2; Height: 151.121 mm; Width: 15 mm; Length: 277 mm; sets with these values: 2
Name | Center of gravity Y (mm) | Center of gravity X (mm) | Assembly mark
 | 2.67565e-16 | 55942 | P25
 | -8.13038e-17 | 67617 | P24

# IfcPlate: PL15*153 (2)
In: Undefined
Description: PL15*153; Material: STEEL/E24-2
Tekla Common - Center of gravity Z: 4089.76 mm; Bottom elevation: +3.950; Top elevation: +4.227; Part mark: 149; Finish: GRENAILLE-PEINT; Grade: E24-2; Profile: PL15*153; sets with these values: 2
Tekla Quantity - Net weight: 3.94809 kg; Gross weight: 4.99594 kg; Weight: 3.94809 kg; Net volume: 0.000502942 m3; Gross volume: 0.000502942 m3; Gross footprint area: 0.0009 m2; Area per tons: 19.8054 m2; Net surface area: 0.0781938 m2; Gross area: 0.0424284 m2; Height: 153.171 mm; Width: 15 mm; Length: 277 mm; sets with these values: 2
Name | Center of gravity Y (mm) | Center of gravity X (mm) | Assembly mark | Phase | Class
 | -4.74953e-17 | 20915.9 | P119 | 2 | 2001
 | 1.8728e-17 | 32590.9 | P113 | 3 | 3001

# IfcPlate: PL15*159
In: Undefined
Description: PL15*159; Material: STEEL/E24-2
Tekla Common - Center of gravity Z: 4088.64 mm; Center of gravity Y: -4.30519e-17 mm; Center of gravity X: 44271 mm; Bottom elevation: +3.950; Top elevation: +4.227; Part mark: 144; Assembly mark: P22; Phase: 1; Class: 1001; Finish: GRENAILLE-PEINT; Grade: E24-2; Profile: PL15*159; sets with these values: 2
Tekla Quantity - Net weight: 4.19468 kg; Gross weight: 5.19138 kg; Weight: 4.19468 kg; Net volume: 0.000534354 m3; Gross volume: 0.000534354 m3; Gross footprint area: 0.0012 m2; Area per tons: 19.7232 m2; Net surface area: 0.0827323 m2; Gross area: 0.0440882 m2; Height: 159.163 mm; Width: 15 mm; Length: 277 mm; sets with these values: 2

# IfcPlate: PL15*217 (3)
In: Undefined
Description: PL15*217; Material: STEEL/E24-2
Tekla Common - Bottom elevation: +4.909; Top elevation: +5.118; Finish: GRENAILLE-PEINT; Grade: E24-2; Profile: PL15*217; sets with these values: 2
Tekla Quantity - Gross footprint area: 0 m2; Height: 216.684 mm; Width: 15 mm; sets with these values: 2
Name | Center of gravity Z (mm) | Center of gravity Y (mm) | Center of gravity X (mm) | Part mark | Assembly mark | Phase | Class | Net weight (kg) = Weight (kg) | Gross weight (kg) | Net volume (m3) = Gross volume (m3) | Area per tons (m2) | Net surface area (m2) | Gross area (m2) | Length (mm)
 | 5024.26 | -3.4879e-17 | 24341.8 | 146 | K25 | 3 | 3005 | 6.63656 | 11.4875 | 0.000845421 | 19.6499 | 0.130408 | 0.0975582 | 450.233
 | 5024.75 | -3.20056e-16 | 36024.8 | 147 | K27 | 3 | 3005 | 6.81276 | 13.0244 | 0.000867867 | 19.8207 | 0.135034 | 0.110611 | 510.472
 | 5024.75 | -3.04779e-16 | 59374.8 | 147 | K26 | 1 | 1005 | 6.81276 | 13.0244 | 0.000867867 | 19.8207 | 0.135034 | 0.110611 | 510.472

# IfcPlate: PL15*221
In: Undefined
Description: PL15*221; Material: STEEL/E24-2
Tekla Common - Center of gravity Z: 4968.39 mm; Center of gravity Y: 8.40003e-16 mm; Center of gravity X: 70892 mm; Bottom elevation: +4.834; Top elevation: +5.048; Part mark: 148; Assembly mark: K28; Phase: 1; Class: 1010; Finish: GRENAILLE-PEINT; Grade: E24-2; Profile: PL15*221; sets with these values: 2
Tekla Quantity - Net weight: 9.44149 kg; Gross weight: 17.633 kg; Weight: 9.44149 kg; Net volume: 0.00120274 m3; Gross volume: 0.00120274 m3; Gross footprint area: 0 m2; Area per tons: 19.5627 m2; Net surface area: 0.184701 m2; Gross area: 0.14975 m2; Height: 220.97 mm; Width: 15 mm; Length: 677.692 mm; sets with these values: 2

# IfcPlate: PL15*86 (16)
In: Undefined
Description: PL15*86; Material: STEEL/E24-2
Tekla Common - Finish: GRENAILLE-PEINT; Grade: E24-2; Profile: PL15*86; sets with these values: 2
Tekla Quantity - Net weight: 3.43896 kg; Gross weight: 3.56218 kg; Weight: 3.43896 kg; Net volume: 0.000438084 m3; Gross volume: 0.000438084 m3; Gross footprint area: 0 m2; Area per tons: 20.6953 m2; Net surface area: 0.0711701 m2; Gross area: 0.0302521 m2; Height: 85.7 mm; Width: 15 mm; Length: 353 mm; sets with these values: 2
Name | Center of gravity Z (mm) | Center of gravity Y (mm) | Center of gravity X (mm) | Bottom elevation | Top elevation | Part mark | Assembly mark | Phase | Class | Name
PLATINE | 116.599 | 61001.9 | 67703.9 | -0.035 | +0.278 | 158 | P37 | 1 | 1001 | PLATINE
PLATINE | 116.599 | 61098.1 | 67703.9 | -0.035 | +0.278 | 158 | P37 | 1 | 1001 | PLATINE
PLATINE | -223.401 | 61001.9 | 56028.9 | -0.375 | -0.062 | 158 | P2 | 1 | 1001 | PLATINE
PLATINE | -223.401 | 61098.1 | 56028.9 | -0.375 | -0.062 | 158 | P2 | 1 | 1001 | PLATINE
PLATINE | -223.401 | 61001.9 | 44353.9 | -0.375 | -0.062 | 158 | P1 | 1 | 1001 | PLATINE
PLATINE | -223.401 | 61098.1 | 44353.9 | -0.375 | -0.062 | 158 | P1 | 1 | 1001 | PLATINE
PLAT | -223.401 | 7601.86 | 67703.9 | -0.375 | -0.062 | 163 | P38 | 1 | 1001 | PLAT
PLAT | -223.401 | 7698.14 | 67703.9 | -0.375 | -0.062 | 163 | P38 | 1 | 1001 | PLAT
PLATINE | -423.401 | 7601.86 | 44353.9 | -0.575 | -0.262 | 158 | P3 | 1 | 1001 | PLATINE
PLATINE | -423.401 | 7698.14 | 44353.9 | -0.575 | -0.262 | 158 | P3 | 1 | 1001 | PLATINE
PLATINE | -223.401 | 7601.86 | 32678.9 | -0.375 | -0.062 | 159 | P5 | 3 | 3001 | PLATINE
PLATINE | -223.401 | 7698.14 | 32678.9 | -0.375 | -0.062 | 159 | P5 | 3 | 3001 | PLATINE
PLATINE | -223.401 | 7601.86 | 21003.9 | -0.375 | -0.062 | 159 | P39 | 2 | 2001 | PLATINE
PLATINE | -223.401 | 7698.14 | 21003.9 | -0.375 | -0.062 | 159 | P39 | 2 | 2001 | PLATINE
PLAT | -223.401 | 7601.86 | 56028.9 | -0.375 | -0.062 | 163 | P4 | 1 | 1001 | PLAT
PLAT | -223.401 | 7698.14 | 56028.9 | -0.375 | -0.062 | 163 | P4 | 1 | 1001 | PLAT

# IfcPlate: PL15*90 (48)
In: Undefined
Description: PL15*90; Material: STEEL/E24-2
Tekla Common - Finish: GRENAILLE-PEINT; Grade: E24-2; Profile: PL15*90; Name: PLATINE; sets with these values: 2
Tekla Quantity - Net weight: 4.9077 kg; Gross weight: 4.95963 kg; Weight: 4.9077 kg; Net volume: 0.000625185 m3; Gross volume: 0.000625185 m3; Gross footprint area: 0.041679 m2; Area per tons: 20.3209 m2; Net surface area: 0.099729 m2; Gross area: 0.04212 m2; Height: 90 mm; Width: 15 mm; Length: 468 mm; sets with these values: 2
Name | Center of gravity Z (mm) | Center of gravity Y (mm) | Center of gravity X (mm) | Bottom elevation | Top elevation | Part mark | Assembly mark | Phase | Class
PLATINE | 4402.19 | 40300.5 | 67665 | +4.395 | +4.410 | 154 | P33 | 1 | 1001
PLATINE | 4402.19 | 40199.5 | 67665 | +4.395 | +4.410 | 154 | P33 | 1 | 1001
PLATINE | 3848.02 | 40300.5 | 67665 | +3.841 | +3.856 | 154 | P33 | 1 | 1001
PLATINE | 3848.02 | 40199.5 | 67665 | +3.841 | +3.856 | 154 | P33 | 1 | 1001
PLATINE | 4402.19 | 40300.5 | 55990 | +4.395 | +4.410 | 154 | P35 | 1 | 1001
PLATINE | 4402.19 | 40199.5 | 55990 | +4.395 | +4.410 | 154 | P35 | 1 | 1001
PLATINE | 3848.02 | 40300.5 | 55990 | +3.841 | +3.856 | 154 | P35 | 1 | 1001
PLATINE | 3848.02 | 40199.5 | 55990 | +3.841 | +3.856 | 154 | P35 | 1 | 1001
PLATINE | 4997.8 | 40199.5 | 55990 | +4.990 | +5.005 | 154 | P35 | 1 | 1001
PLATINE | 4997.8 | 40300.5 | 55990 | +4.990 | +5.005 | 154 | P35 | 1 | 1001
PLATINE | 4997.8 | 40199.5 | 44315 | +4.990 | +5.005 | 154 | P35 | 1 | 1001
PLATINE | 4997.8 | 40300.5 | 44315 | +4.990 | +5.005 | 154 | P35 | 1 | 1001
PLATINE | 4402.19 | 40300.5 | 44315 | +4.395 | +4.410 | 154 | P35 | 1 | 1001
PLATINE | 4402.19 | 40199.5 | 44315 | +4.395 | +4.410 | 154 | P35 | 1 | 1001
PLATINE | 3848.02 | 40300.5 | 44315 | +3.841 | +3.856 | 154 | P35 | 1 | 1001
PLATINE | 3848.02 | 40199.5 | 44315 | +3.841 | +3.856 | 154 | P35 | 1 | 1001
PLATINE | 4997.8 | 40199.5 | 32640 | +4.990 | +5.005 | 161 | P31 | 3 | 3001
PLATINE | 4997.8 | 40300.5 | 32640 | +4.990 | +5.005 | 161 | P31 | 3 | 3001
PLATINE | 4402.19 | 40300.5 | 32640 | +4.395 | +4.410 | 161 | P31 | 3 | 3001
PLATINE | 4402.19 | 40199.5 | 32640 | +4.395 | +4.410 | 161 | P31 | 3 | 3001
PLATINE | 3848.02 | 40300.5 | 32640 | +3.841 | +3.856 | 161 | P31 | 3 | 3001
PLATINE | 3848.02 | 40199.5 | 32640 | +3.841 | +3.856 | 161 | P31 | 3 | 3001
PLATINE | 4997.8 | 40199.5 | 20965 | +4.990 | +5.005 | 161 | P30 | 2 | 2001
PLATINE | 4997.8 | 40300.5 | 20965 | +4.990 | +5.005 | 161 | P30 | 2 | 2001
PLATINE | 4402.19 | 19399.5 | 32640 | +4.395 | +4.410 | 161 | P32 | 3 | 3001
PLATINE | 3848.02 | 19399.5 | 32640 | +3.841 | +3.856 | 161 | P32 | 3 | 3001
PLATINE | 3848.02 | 19500.5 | 32640 | +3.841 | +3.856 | 161 | P32 | 3 | 3001
PLATINE | 4997.8 | 19399.5 | 20965 | +4.990 | +5.005 | 161 | P29 | 2 | 2001
PLATINE | 4997.8 | 19500.5 | 20965 | +4.990 | +5.005 | 161 | P29 | 2 | 2001
PLATINE | 4402.19 | 19500.5 | 32640 | +4.395 | +4.410 | 161 | P32 | 3 | 3001
PLATINE | 4997.8 | 19399.5 | 44315 | +4.990 | +5.005 | 154 | P36 | 1 | 1001
PLATINE | 4997.8 | 19500.5 | 44315 | +4.990 | +5.005 | 154 | P36 | 1 | 1001
PLATINE | 4402.19 | 19500.5 | 44315 | +4.395 | +4.410 | 154 | P36 | 1 | 1001
PLATINE | 4402.19 | 19399.5 | 44315 | +4.395 | +4.410 | 154 | P36 | 1 | 1001
PLATINE | 3848.02 | 19500.5 | 44315 | +3.841 | +3.856 | 154 | P36 | 1 | 1001
PLATINE | 3848.02 | 19399.5 | 44315 | +3.841 | +3.856 | 154 | P36 | 1 | 1001
PLATINE | 4997.8 | 19399.5 | 55990 | +4.990 | +5.005 | 154 | P36 | 1 | 1001
PLATINE | 4997.8 | 19500.5 | 55990 | +4.990 | +5.005 | 154 | P36 | 1 | 1001
PLATINE | 3848.02 | 19399.5 | 55990 | +3.841 | +3.856 | 154 | P36 | 1 | 1001
PLATINE | 4997.8 | 19500.5 | 32640 | +4.990 | +5.005 | 161 | P32 | 3 | 3001
PLATINE | 4997.8 | 19399.5 | 32640 | +4.990 | +5.005 | 161 | P32 | 3 | 3001
PLATINE | 3848.02 | 19500.5 | 55990 | +3.841 | +3.856 | 154 | P36 | 1 | 1001
PLATINE | 4402.19 | 19399.5 | 55990 | +4.395 | +4.410 | 154 | P36 | 1 | 1001
PLATINE | 4402.19 | 19500.5 | 55990 | +4.395 | +4.410 | 154 | P36 | 1 | 1001
PLATINE | 3848.02 | 19399.5 | 67665 | +3.841 | +3.856 | 154 | P28 | 1 | 1001
PLATINE | 3848.02 | 19500.5 | 67665 | +3.841 | +3.856 | 154 | P28 | 1 | 1001
PLATINE | 4402.19 | 19399.5 | 67665 | +4.395 | +4.410 | 154 | P28 | 1 | 1001
PLATINE | 4402.19 | 19500.5 | 67665 | +4.395 | +4.410 | 154 | P28 | 1 | 1001

# IfcPlate: PL15*95 (44)
In: Undefined
Description: PL15*95; Material: STEEL/E24-2
Tekla Common - Finish: GRENAILLE-PEINT; Grade: E24-2; Profile: PL15*95; Name: PLATINE; sets with these values: 2
Tekla Quantity - Gross footprint area: 0 m2; Height: 94.9 mm; Width: 15 mm; sets with these values: 2
Name | Center of gravity Z (mm) | Center of gravity Y (mm) | Center of gravity X (mm) | Bottom elevation | Top elevation | Part mark | Assembly mark | Phase | Class | Net weight (kg) = Weight (kg) | Gross weight (kg) | Net volume (m3) = Gross volume (m3) | Area per tons (m2) | Net surface area (m2) | Gross area (m2) | Length (mm)
PLATINE | -160.194 | 40196.7 | 67765.4 | -0.375 | +0.064 | 155 | P33 | 1 | 1001 | 5.44166 | 5.56489 | 0.000693205 | 20.1799 | 0.109812 | 0.0472602 | 498
PLATINE | -160.194 | 40303.3 | 67765.4 | -0.375 | +0.064 | 155 | P33 | 1 | 1001 | 5.44166 | 5.56489 | 0.000693205 | 20.1799 | 0.109812 | 0.0472602 | 498
PLATINE | -160.194 | 40196.7 | 56090.4 | -0.375 | +0.064 | 155 | P35 | 1 | 1001 | 5.44166 | 5.56489 | 0.000693205 | 20.1799 | 0.109812 | 0.0472602 | 498
PLATINE | -160.194 | 40303.3 | 56090.4 | -0.375 | +0.064 | 155 | P35 | 1 | 1001 | 5.44166 | 5.56489 | 0.000693205 | 20.1799 | 0.109812 | 0.0472602 | 498
PLATINE | -160.194 | 40196.7 | 44415.4 | -0.375 | +0.064 | 155 | P35 | 1 | 1001 | 5.44166 | 5.56489 | 0.000693205 | 20.1799 | 0.109812 | 0.0472602 | 498
PLATINE | -160.194 | 40303.3 | 44415.4 | -0.375 | +0.064 | 155 | P35 | 1 | 1001 | 5.44166 | 5.56489 | 0.000693205 | 20.1799 | 0.109812 | 0.0472602 | 498
PLATINE | -160.194 | 40196.7 | 32740.4 | -0.375 | +0.064 | 160 | P31 | 3 | 3001 | 5.44166 | 5.56489 | 0.000693205 | 20.1799 | 0.109812 | 0.0472602 | 498
PLATINE | -160.194 | 40303.3 | 32740.4 | -0.375 | +0.064 | 160 | P31 | 3 | 3001 | 5.44166 | 5.56489 | 0.000693205 | 20.1799 | 0.109812 | 0.0472602 | 498
PLATINE | -160.194 | 19396.7 | 21065.4 | -0.375 | +0.064 | 160 | P29 | 2 | 2001 | 5.44166 | 5.56489 | 0.000693205 | 20.1799 | 0.109812 | 0.0472602 | 498
PLATINE | -160.194 | 19503.3 | 21065.4 | -0.375 | +0.064 | 160 | P29 | 2 | 2001 | 5.44166 | 5.56489 | 0.000693205 | 20.1799 | 0.109812 | 0.0472602 | 498
PLATINE | -160.194 | 40303.3 | 21065.4 | -0.375 | +0.064 | 160 | P30 | 2 | 2001 | 5.44166 | 5.56489 | 0.000693205 | 20.1799 | 0.109812 | 0.0472602 | 498
PLATINE | -160.194 | 19396.7 | 56090.4 | -0.375 | +0.064 | 155 | P36 | 1 | 1001 | 5.44166 | 5.56489 | 0.000693205 | 20.1799 | 0.109812 | 0.0472602 | 498
PLATINE | 84.7007 | 68969.6 | 67603.9 | -0.035 | +0.213 | 157 | P23 | 1 | 1001 | 2.98328 | 3.1065 | 0.000380035 | 20.6003 | 0.0614563 | 0.0263822 | 278
PLATINE | 84.7007 | 68969.6 | 67496.1 | -0.035 | +0.213 | 157 | P23 | 1 | 1001 | 2.98328 | 3.1065 | 0.000380035 | 20.6003 | 0.0614563 | 0.0263822 | 278
PLATINE | 41.608 | 69305.6 | 67604.7 | -0.035 | +0.127 | 156 | P23 | 1 | 1001 | 1.86583 | 1.98906 | 0.000237685 | 21.1576 | 0.0394763 | 0.0168922 | 178
PLATINE | 41.608 | 69305.6 | 67495.3 | -0.035 | +0.127 | 156 | P23 | 1 | 1001 | 1.86583 | 1.98906 | 0.000237685 | 21.1576 | 0.0394763 | 0.0168922 | 178
PLATINE | -255.299 | 68969.6 | 44253.9 | -0.375 | -0.127 | 157 | P26 | 1 | 1001 | 2.98328 | 3.1065 | 0.000380035 | 20.6003 | 0.0614563 | 0.0263822 | 278
PLATINE | -255.299 | 68969.6 | 44146.1 | -0.375 | -0.127 | 157 | P26 | 1 | 1001 | 2.98328 | 3.1065 | 0.000380035 | 20.6003 | 0.0614563 | 0.0263822 | 278
PLATINE | -255.299 | 68969.6 | 55928.9 | -0.375 | -0.127 | 157 | P27 | 1 | 1001 | 2.98328 | 3.1065 | 0.000380035 | 20.6003 | 0.0614563 | 0.0263822 | 278
PLATINE | -255.299 | 68969.6 | 55821.1 | -0.375 | -0.127 | 157 | P27 | 1 | 1001 | 2.98328 | 3.1065 | 0.000380035 | 20.6003 | 0.0614563 | 0.0263822 | 278
PLATINE | -298.392 | 69305.6 | 55929.7 | -0.375 | -0.213 | 156 | P27 | 1 | 1001 | 1.86583 | 1.98906 | 0.000237685 | 21.1576 | 0.0394763 | 0.0168922 | 178
PLATINE | -298.392 | 69305.6 | 55820.3 | -0.375 | -0.213 | 156 | P27 | 1 | 1001 | 1.86583 | 1.98906 | 0.000237685 | 21.1576 | 0.0394763 | 0.0168922 | 178
PLATINE | -298.392 | 69305.6 | 44145.3 | -0.375 | -0.213 | 156 | P26 | 1 | 1001 | 1.86583 | 1.98906 | 0.000237685 | 21.1576 | 0.0394763 | 0.0168922 | 178
PLATINE | -298.392 | 69305.6 | 44254.7 | -0.375 | -0.213 | 156 | P26 | 1 | 1001 | 1.86583 | 1.98906 | 0.000237685 | 21.1576 | 0.0394763 | 0.0168922 | 178
PLATINE | -255.299 | 180.449 | 67496.1 | -0.375 | -0.127 | 157 | P24 | 1 | 1001 | 2.98328 | 3.1065 | 0.000380035 | 20.6003 | 0.0614563 | 0.0263822 | 278
PLATINE | -255.299 | 180.449 | 67603.9 | -0.375 | -0.127 | 157 | P24 | 1 | 1001 | 2.98328 | 3.1065 | 0.000380035 | 20.6003 | 0.0614563 | 0.0263822 | 278
PLATINE | -298.392 | -155.569 | 67495.3 | -0.375 | -0.213 | 156 | P24 | 1 | 1001 | 1.86583 | 1.98906 | 0.000237685 | 21.1576 | 0.0394763 | 0.0168922 | 178
PLATINE | -298.392 | -155.569 | 67604.7 | -0.375 | -0.213 | 156 | P24 | 1 | 1001 | 1.86583 | 1.98906 | 0.000237685 | 21.1576 | 0.0394763 | 0.0168922 | 178
PLATINE | -455.299 | 180.449 | 44146.1 | -0.575 | -0.327 | 157 | P22 | 1 | 1001 | 2.98328 | 3.1065 | 0.000380035 | 20.6003 | 0.0614563 | 0.0263822 | 278
PLATINE | -455.299 | 180.449 | 44253.9 | -0.575 | -0.327 | 157 | P22 | 1 | 1001 | 2.98328 | 3.1065 | 0.000380035 | 20.6003 | 0.0614563 | 0.0263822 | 278
PLATINE | -498.392 | -155.569 | 44145.3 | -0.575 | -0.413 | 156 | P22 | 1 | 1001 | 1.86583 | 1.98906 | 0.000237685 | 21.1576 | 0.0394763 | 0.0168922 | 178
PLATINE | -498.392 | -155.569 | 44254.7 | -0.575 | -0.413 | 156 | P22 | 1 | 1001 | 1.86583 | 1.98906 | 0.000237685 | 21.1576 | 0.0394763 | 0.0168922 | 178
PLATINE | -160.194 | 40196.7 | 21065.4 | -0.375 | +0.064 | 160 | P30 | 2 | 2001 | 5.44166 | 5.56489 | 0.000693205 | 20.1799 | 0.109812 | 0.0472602 | 498
PLATINE | -160.194 | 19503.3 | 56090.4 | -0.375 | +0.064 | 155 | P36 | 1 | 1001 | 5.44166 | 5.56489 | 0.000693205 | 20.1799 | 0.109812 | 0.0472602 | 498
PLATINE | -255.299 | 180.449 | 55821.1 | -0.375 | -0.127 | 157 | P25 | 1 | 1001 | 2.98328 | 3.1065 | 0.000380035 | 20.6003 | 0.0614563 | 0.0263822 | 278
PLATINE | -255.299 | 180.449 | 55928.9 | -0.375 | -0.127 | 157 | P25 | 1 | 1001 | 2.98328 | 3.1065 | 0.000380035 | 20.6003 | 0.0614563 | 0.0263822 | 278
PLATINE | -298.392 | -155.569 | 55820.3 | -0.375 | -0.213 | 156 | P25 | 1 | 1001 | 1.86583 | 1.98906 | 0.000237685 | 21.1576 | 0.0394763 | 0.0168922 | 178
PLATINE | -298.392 | -155.569 | 55929.7 | -0.375 | -0.213 | 156 | P25 | 1 | 1001 | 1.86583 | 1.98906 | 0.000237685 | 21.1576 | 0.0394763 | 0.0168922 | 178
PLATINE | -160.194 | 19503.3 | 44415.4 | -0.375 | +0.064 | 155 | P36 | 1 | 1001 | 5.44166 | 5.56489 | 0.000693205 | 20.1799 | 0.109812 | 0.0472602 | 498
PLATINE | -160.194 | 19396.7 | 44415.4 | -0.375 | +0.064 | 155 | P36 | 1 | 1001 | 5.44166 | 5.56489 | 0.000693205 | 20.1799 | 0.109812 | 0.0472602 | 498
PLATINE | -160.194 | 19503.3 | 32740.4 | -0.375 | +0.064 | 160 | P32 | 3 | 3001 | 5.44166 | 5.56489 | 0.000693205 | 20.1799 | 0.109812 | 0.0472602 | 498
PLATINE | -160.194 | 19396.7 | 32740.4 | -0.375 | +0.064 | 160 | P32 | 3 | 3001 | 5.44166 | 5.56489 | 0.000693205 | 20.1799 | 0.109812 | 0.0472602 | 498
PLATINE | -160.194 | 19503.3 | 67765.4 | -0.375 | +0.064 | 155 | P28 | 1 | 1001 | 5.44166 | 5.56489 | 0.000693205 | 20.1799 | 0.109812 | 0.0472602 | 498
PLATINE | -160.194 | 19396.7 | 67765.4 | -0.375 | +0.064 | 155 | P28 | 1 | 1001 | 5.44166 | 5.56489 | 0.000693205 | 20.1799 | 0.109812 | 0.0472602 | 498

# IfcPlate: PL1520*1994 (2)
In: Undefined
Description: PL1520*1994; Material: STEEL/S235JR
Tekla Common - Center of gravity Z: 5240 mm; Center of gravity X: 74827 mm; Bottom elevation: +4.480; Top elevation: +6.000; Part mark: Z63; Assembly mark: Z63; Phase: 10; Class: 77; Grade: S235JR; Profile: PL1520*1994; Name: CONDENSEUR; sets with these values: 2
Tekla Quantity - Net weight: 97382.3 kg; Gross weight: 97382.3 kg; Weight: 97382.3 kg; Net volume: 12.4054 m3; Gross volume: 12.4054 m3; Gross footprint area: 8.16144 m2; Area per tons: 0.357635 m2; Net surface area: 34.8274 m2; Gross area: 8.16144 m2; Height: 1994 mm; Width: 1520 mm; Length: 4093 mm; sets with these values: 2
Name | Center of gravity Y (mm)
CONDENSEUR | 22893.5
CONDENSEUR | 17716.7

# IfcPlate: PL180*11681, BETON
In: Undefined
Description: PL180*11681; Material: STEEL/S235JR
Tekla Common - Center of gravity Z: 5348.99 mm; Center of gravity Y: 6600 mm; Center of gravity X: 73390.3 mm; Bottom elevation: +5.078; Top elevation: +5.620; Part mark: Z8; Assembly mark: Z8; Phase: 10; Class: 2; Grade: S235JR; Profile: PL180*11681; Name: BETON; sets with these values: 2
Tekla Quantity - Net weight: 225949 kg; Gross weight: 225949 kg; Weight: 225949 kg; Net volume: 28.7834 m3; Gross volume: 28.7834 m3; Gross footprint area: 0 m2; Area per tons: 1.45585 m2; Net surface area: 328.948 m2; Gross area: 159.908 m2; Height: 11680.6 mm; Width: 180 mm; Length: 13690 mm; sets with these values: 2

# IfcPlate: PL180*11762, BETON
In: Undefined
Description: PL180*11762; Material: STEEL/S235JR
Tekla Common - Center of gravity Z: 5195.34 mm; Center of gravity Y: 50770 mm; Center of gravity X: 73398.4 mm; Bottom elevation: +4.393; Top elevation: +5.998; Part mark: Z9; Assembly mark: Z9; Phase: 10; Class: 1; Grade: S235JR; Profile: PL180*11762; Name: BETON; sets with these values: 2
Tekla Quantity - Net weight: 619072 kg; Gross weight: 619072 kg; Weight: 619072 kg; Net volume: 78.8626 m3; Gross volume: 78.8626 m3; Gross footprint area: 0 m2; Area per tons: 1.44393 m2; Net surface area: 893.896 m2; Gross area: 438.126 m2; Height: 11761.8 mm; Width: 180 mm; Length: 37250 mm; sets with these values: 2

# IfcPlate: PL180*2231, BETON
In: Undefined
Description: PL180*2231; Material: STEEL/S235JR
Tekla Common - Center of gravity Z: 5773.07 mm; Center of gravity Y: 29750 mm; Center of gravity X: 68668.4 mm; Bottom elevation: +5.548; Top elevation: +5.998; Part mark: Z10; Assembly mark: Z10; Phase: 10; Class: 1; Grade: S235JR; Profile: PL180*2231; Name: BETON; sets with these values: 2
Tekla Quantity - Net weight: 15103.1 kg; Gross weight: 15103.1 kg; Weight: 15103.1 kg; Net volume: 1.92397 m3; Gross volume: 1.92397 m3; Gross footprint area: 0 m2; Area per tons: 1.58279 m2; Net surface area: 23.9051 m2; Gross area: 10.6887 m2; Height: 2231.46 mm; Width: 180 mm; Length: 4790 mm; sets with these values: 2

# IfcPlate: PL180*4204, BETON
In: Undefined
Description: PL180*4204; Material: STEEL/S235JR
Tekla Common - Center of gravity Z: 5464.82 mm; Center of gravity Y: 16362 mm; Center of gravity X: 69653.9 mm; Bottom elevation: +5.310; Top elevation: +5.620; Part mark: Z7; Assembly mark: Z7; Phase: 10; Class: 2; Grade: S235JR; Profile: PL180*4204; Name: BETON; sets with these values: 2
Tekla Quantity - Net weight: 34657.8 kg; Gross weight: 34659.1 kg; Weight: 34657.8 kg; Net volume: 4.41501 m3; Gross volume: 4.41501 m3; Gross footprint area: 0 m2; Area per tons: 1.5197 m2; Net surface area: 52.6694 m2; Gross area: 24.5287 m2; Height: 4204.44 mm; Width: 180 mm; Length: 5834 mm; sets with these values: 2

# IfcPlate: PL180*4217, BETON
In: Undefined
Description: PL180*4217; Material: STEEL/S235JR
Tekla Common - Center of gravity Z: 5652.68 mm; Center of gravity Y: 23317 mm; Center of gravity X: 69654 mm; Bottom elevation: +5.308; Top elevation: +5.998; Part mark: Z11; Assembly mark: Z11; Phase: 10; Class: 1; Grade: S235JR; Profile: PL180*4217; Name: BETON; sets with these values: 2
Tekla Quantity - Net weight: 48125.1 kg; Gross weight: 48125.1 kg; Weight: 48125.1 kg; Net volume: 6.13059 m3; Gross volume: 6.13059 m3; Gross footprint area: 0 m2; Area per tons: 1.50739 m2; Net surface area: 72.5432 m2; Gross area: 34.0588 m2; Height: 4217.29 mm; Width: 180 mm; Length: 8076 mm; sets with these values: 2

# IfcPlate: PL180*5080, MACONNERIE
In: Undefined
Description: PL180*5080; Material: CONCRETE/BETON COURANT
Tekla Common - Center of gravity Z: 6050 mm; Center of gravity Y: 59637.5 mm; Center of gravity X: 30385 mm; Bottom elevation: +5.960; Top elevation: +6.140; Part mark: Z4; Assembly mark: Z4; Phase: 10; Class: 75; Grade: BETON COURANT; Profile: PL180*5080; Name: MACONNERIE; sets with these values: 2
Tekla Quantity - Net weight: 38088 kg; Gross weight: 38088 kg; Weight: 38088 kg; Net volume: 18.1371 m3; Gross volume: 18.1371 m3; Gross footprint area: 100.762 m2; Area per tons: 5.5265 m2; Net surface area: 210.493 m2; Gross area: 100.762 m2; Height: 5080 mm; Width: 180 mm; Length: 19835 mm; sets with these values: 2

# IfcPlate: PL180*5600, BETON
In: Undefined
Description: PL180*5600; Material: STEEL/S235JR
Tekla Common - Center of gravity Z: 5566.21 mm; Center of gravity Y: 29243.5 mm; Center of gravity X: 74547.3 mm; Bottom elevation: +5.383; Top elevation: +5.756; Part mark: Z5; Assembly mark: Z5; Phase: 10; Class: 7; Grade: S235JR; Profile: PL180*5600; Name: BETON; sets with these values: 2
Tekla Quantity - Net weight: 73455.8 kg; Gross weight: 76609.2 kg; Weight: 73455.8 kg; Net volume: 9.35743 m3; Gross volume: 9.35743 m3; Gross footprint area: 0 m2; Area per tons: 1.49032 m2; Net surface area: 109.473 m2; Gross area: 54.2174 m2; Height: 5600 mm; Width: 180 mm; Length: 9681.68 mm; sets with these values: 2

# IfcPlate: PL180*7414, BETON
In: Undefined
Description: PL180*7414; Material: STEEL/S235JR
Tekla Common - Center of gravity Z: 3975.1 mm; Center of gravity Y: 19847.5 mm; Center of gravity X: 75522.8 mm; Bottom elevation: +3.770; Top elevation: +4.180; Part mark: Z6; Assembly mark: Z6; Phase: 10; Class: 3; Grade: S235JR; Profile: PL180*7414; Name: BETON; sets with these values: 2
Tekla Quantity - Net weight: 131937 kg; Gross weight: 131937 kg; Weight: 131937 kg; Net volume: 16.8073 m3; Gross volume: 16.8073 m3; Gross footprint area: 0 m2; Area per tons: 1.47002 m2; Net surface area: 193.951 m2; Gross area: 93.3738 m2; Height: 7413.56 mm; Width: 180 mm; Length: 12595 mm; sets with these values: 2

# IfcPlate: PL200*1595, MACONNERIE
In: Undefined
Description: PL200*1595; Material: CONCRETE/BETON COURANT
Tekla Common - Center of gravity Z: 6040 mm; Center of gravity Y: 48922.5 mm; Center of gravity X: 24192.5 mm; Bottom elevation: +5.940; Top elevation: +6.140; Part mark: Z25; Assembly mark: Z25; Phase: 10; Class: 75; Grade: BETON COURANT; Profile: PL200*1595; Name: MACONNERIE; sets with these values: 2
Tekla Quantity - Net weight: 4893.65 kg; Gross weight: 4893.69 kg; Weight: 4893.65 kg; Net volume: 2.33031 m3; Gross volume: 2.33031 m3; Gross footprint area: 11.6516 m2; Area per tons: 5.48938 m2; Net surface area: 26.8631 m2; Gross area: 11.6516 m2; Height: 1595 mm; Width: 200 mm; Length: 7305.1 mm; sets with these values: 2

# IfcPlate: PL200*5600, MACONNERIE
In: Undefined
Description: PL200*5600; Material: CONCRETE/BETON COURANT
Tekla Common - Center of gravity Z: 3100 mm; Center of gravity Y: 29145 mm; Center of gravity X: 75745 mm; Bottom elevation: +3.000; Top elevation: +3.200; Part mark: Z43; Assembly mark: Z43; Phase: 10; Class: 75; Grade: BETON COURANT; Profile: PL200*5600; Name: MACONNERIE; sets with these values: 2
Tekla Quantity - Net weight: 16981.4 kg; Gross weight: 16981.5 kg; Weight: 16981.4 kg; Net volume: 8.0864 m3; Gross volume: 8.0864 m3; Gross footprint area: 40.432 m2; Area per tons: 5.06388 m2; Net surface area: 85.992 m2; Gross area: 40.432 m2; Height: 5600 mm; Width: 200 mm; Length: 7220 mm; sets with these values: 2

# IfcPlate: PL200*8285, MACONNERIE
In: Undefined
Description: PL200*8285; Material: CONCRETE/BETON COURANT
