Properties of the parts of a building model (IFC2X3), part 18 of 32

# IfcBeam: UPF-100*50*4 (379)
Name | Material | Center of gravity Z (mm) | Center of gravity Y (mm) | Center of gravity X (mm) | Bottom elevation | Top elevation | Part mark | Assembly mark | Phase | Class | Finish | Grade | Name | Net weight (kg) = Weight (kg) = NetWeight (kg) | Gross weight (kg) | Net volume (m3) = NetVolume (m3) | Gross volume (m3) | Gross footprint area (m2) | Area per tons (m2) | Net surface area (m2) = OuterSurfaceArea (m2) | Gross area (m2) | Width (mm) | Tekla Quantity, Length (mm) = BaseQuantities, Length (mm)
SOLIVE | STEEL/S235JR | 4315 | 38915.6 | 5677.69 | +4.265 | +4.365 | S78 | S78 | 2 | 2007 | GALVANISE | S235JR | SOLIVE | 15.3056 | 15.3056 | 0.00194976 | 0.00194976 | 0.126938 | 65.1216 | 0.996726 | 0.996726 | 50 | 2538.75
SOLIVE | STEEL/S235JR | 4315 | 38915.6 | 8326.02 | +4.265 | +4.365 | S78 | S78 | 2 | 2007 | GALVANISE | S235JR | SOLIVE | 15.3056 | 15.3056 | 0.00194976 | 0.00194976 | 0.126938 | 65.1216 | 0.996726 | 0.996726 | 50 | 2538.75
SOLIVE | STEEL/S235JR | 4415 | 37567.3 | 8080.84 | +4.365 | +4.465 | S75 | S75 | 2 | 2007 | GALVANISE | S235JR | SOLIVE | 28.7473 | 28.7473 | 0.00366208 | 0.00366208 | 0.238417 | 65.0747 | 1.87072 | 1.87072 | 50 | 4768.33
SOLIVE | STEEL/S235JR | 4415 | 37567.3 | 2663.33 | +4.365 | +4.465 | S52 | S52 | 2 | 2007 | GALVANISE | S235JR | SOLIVE | 36.4542 | 36.4542 | 0.00464384 | 0.00464384 | 0.302333 | 65.0634 | 2.37183 | 2.37183 | 50 | 6046.67
SOLIVE | STEEL/S235JR | 4315 | 36246.9 | 5677.69 | +4.265 | +4.365 | S78 | S78 | 2 | 2007 | GALVANISE | S235JR | SOLIVE | 15.3056 | 15.3056 | 0.00194976 | 0.00194976 | 0.126938 | 65.1216 | 0.996726 | 0.996726 | 50 | 2538.75
SOLIVE | STEEL/S235JR | 4315 | 36246.9 | 8326.02 | +4.265 | +4.365 | S78 | S78 | 2 | 2007 | GALVANISE | S235JR | SOLIVE | 15.3056 | 15.3056 | 0.00194976 | 0.00194976 | 0.126938 | 65.1216 | 0.996726 | 0.996726 | 50 | 2538.75
SOLIVE | STEEL/S235JR | 4415 | 34898.5 | 8080.84 | +4.365 | +4.465 | S75 | S75 | 2 | 2007 | GALVANISE | S235JR | SOLIVE | 28.7473 | 28.7473 | 0.00366208 | 0.00366208 | 0.238417 | 65.0747 | 1.87072 | 1.87072 | 50 | 4768.33
SOLIVE | STEEL/S235JR | 4415 | 34898.5 | 2663.33 | +4.365 | +4.465 | 1082 | S53 | 2 | 2007 | GALVANISE | S235JR | SOLIVE | 36.4542 | 36.4542 | 0.00464384 | 0.00464384 | 0.302333 | 65.0634 | 2.37183 | 2.37183 | 50 | 6046.67
SOLIVE | STEEL/S235JR | 4315 | 43008.3 | 10391 | +4.265 | +4.365 | 1094 | S65 | 2 | 2007 | GALVANISE | S235JR | SOLIVE | 33.1986 | 33.1986 | 0.00422911 | 0.00422911 | 0.275333 | 65.0675 | 2.16015 | 2.16015 | 50 | 5506.66
SOLIVE | STEEL/S235JR | 4315 | 37581.2 | 10391 | +4.265 | +4.365 | 1095 | S66 | 2 | 2007 | GALVANISE | S235JR | SOLIVE | 32.1184 | 32.1184 | 0.00409152 | 0.00409152 | 0.266375 | 65.0691 | 2.08992 | 2.08992 | 50 | 5327.5
SOLIVE | STEEL/S235JR | 4415 | 32229.8 | 2663.33 | +4.365 | +4.465 | S52 | S52 | 2 | 2007 | GALVANISE | S235JR | SOLIVE | 36.4542 | 36.4542 | 0.00464384 | 0.00464384 | 0.302333 | 65.0634 | 2.37183 | 2.37183 | 50 | 6046.67
SOLIVE | STEEL/S235JR | 4415 | 32229.8 | 8080.84 | +4.365 | +4.465 | S75 | S75 | 2 | 2007 | GALVANISE | S235JR | SOLIVE | 28.7473 | 28.7473 | 0.00366208 | 0.00366208 | 0.238417 | 65.0747 | 1.87072 | 1.87072 | 50 | 4768.33
SOLIVE | STEEL/S235JR | 4315 | 33578.1 | 8326.02 | +4.265 | +4.365 | S78 | S78 | 2 | 2007 | GALVANISE | S235JR | SOLIVE | 15.3056 | 15.3056 | 0.00194976 | 0.00194976 | 0.126938 | 65.1216 | 0.996726 | 0.996726 | 50 | 2538.75
SOLIVE | STEEL/S235JR | 4315 | 33578.1 | 5677.69 | +4.265 | +4.365 | S78 | S78 | 2 | 2007 | GALVANISE | S235JR | SOLIVE | 15.3056 | 15.3056 | 0.00194976 | 0.00194976 | 0.126938 | 65.1216 | 0.996726 | 0.996726 | 50 | 2538.75
SOLIVE | STEEL/S235JR | 4415 | 29561 | 2663.33 | +4.365 | +4.465 | 1082 | S53 | 2 | 2007 | GALVANISE | S235JR | SOLIVE | 36.4542 | 36.4542 | 0.00464384 | 0.00464384 | 0.302333 | 65.0634 | 2.37183 | 2.37183 | 50 | 6046.67
SOLIVE | STEEL/S235JR | 4315 | 30909.4 | 8326.02 | +4.265 | +4.365 | S78 | S78 | 2 | 2007 | GALVANISE | S235JR | SOLIVE | 15.3056 | 15.3056 | 0.00194976 | 0.00194976 | 0.126938 | 65.1216 | 0.996726 | 0.996726 | 50 | 2538.75
SOLIVE | STEEL/S235JR | 4315 | 30909.4 | 5677.69 | +4.265 | +4.365 | S78 | S78 | 2 | 2007 | GALVANISE | S235JR | SOLIVE | 15.3056 | 15.3056 | 0.00194976 | 0.00194976 | 0.126938 | 65.1216 | 0.996726 | 0.996726 | 50 | 2538.75
SOLIVE | STEEL/S235JR | 4415 | 29561 | 8080.84 | +4.365 | +4.465 | S75 | S75 | 2 | 2007 | GALVANISE | S235JR | SOLIVE | 28.7473 | 28.7473 | 0.00366208 | 0.00366208 | 0.238417 | 65.0747 | 1.87072 | 1.87072 | 50 | 4768.33
SOLIVE | STEEL/S235JR | 4315 | 21981.2 | 10391 | +4.265 | +4.365 | 1096 | S67 | 2 | 2007 | GALVANISE | S235JR | SOLIVE | 30.4605 | 30.4605 | 0.00388032 | 0.00388032 | 0.252625 | 65.0717 | 1.98212 | 1.98212 | 50 | 5052.5
SOLIVE | STEEL/S235JR | 4415 | 27029.8 | 2663.33 | +4.365 | +4.465 | S52 | S52 | 2 | 2007 | GALVANISE | S235JR | SOLIVE | 36.4542 | 36.4542 | 0.00464384 | 0.00464384 | 0.302333 | 65.0634 | 2.37183 | 2.37183 | 50 | 6046.67
SOLIVE | STEEL/S235JR | 4315 | 28309.4 | 8326.02 | +4.265 | +4.365 | S76 | S76 | 2 | 2007 | GALVANISE | S235JR | SOLIVE | 14.4767 | 14.4767 | 0.00184416 | 0.00184416 | 0.120063 | 65.1273 | 0.942826 | 0.942826 | 50 | 2401.25
SOLIVE | STEEL/S235JR | 4315 | 28309.4 | 5677.69 | +4.265 | +4.365 | S76 | S76 | 2 | 2007 | GALVANISE | S235JR | SOLIVE | 14.4767 | 14.4767 | 0.00184416 | 0.00184416 | 0.120063 | 65.1273 | 0.942826 | 0.942826 | 50 | 2401.25
SOLIVE | STEEL/S235JR | 4415 | 27029.8 | 8080.84 | +4.365 | +4.465 | S75 | S75 | 2 | 2007 | GALVANISE | S235JR | SOLIVE | 28.7473 | 28.7473 | 0.00366208 | 0.00366208 | 0.238417 | 65.0747 | 1.87072 | 1.87072 | 50 | 4768.33
SOLIVE | STEEL/S235JR | 4315 | 32243.7 | 10391 | +4.265 | +4.365 | 1095 | S66 | 2 | 2007 | GALVANISE | S235JR | SOLIVE | 32.1184 | 32.1184 | 0.00409152 | 0.00409152 | 0.266375 | 65.0691 | 2.08992 | 2.08992 | 50 | 5327.5
SOLIVE | STEEL/S235JR | 4415 | 24498.5 | 2663.33 | +4.365 | +4.465 | 1082 | S53 | 2 | 2007 | GALVANISE | S235JR | SOLIVE | 36.4542 | 36.4542 | 0.00464384 | 0.00464384 | 0.302333 | 65.0634 | 2.37183 | 2.37183 | 50 | 6046.67
SOLIVE | STEEL/S235JR | 4315 | 25778.1 | 8326.02 | +4.265 | +4.365 | S76 | S76 | 2 | 2007 | GALVANISE | S235JR | SOLIVE | 14.4767 | 14.4767 | 0.00184416 | 0.00184416 | 0.120063 | 65.1273 | 0.942826 | 0.942826 | 50 | 2401.25
SOLIVE | STEEL/S235JR | 4315 | 25778.1 | 5677.69 | +4.265 | +4.365 | S76 | S76 | 2 | 2007 | GALVANISE | S235JR | SOLIVE | 14.4767 | 14.4767 | 0.00184416 | 0.00184416 | 0.120063 | 65.1273 | 0.942826 | 0.942826 | 50 | 2401.25
SOLIVE | STEEL/S235JR | 4415 | 24498.5 | 8080.84 | +4.365 | +4.465 | S75 | S75 | 2 | 2007 | GALVANISE | S235JR | SOLIVE | 28.7473 | 28.7473 | 0.00366208 | 0.00366208 | 0.238417 | 65.0747 | 1.87072 | 1.87072 | 50 | 4768.33
SOLIVE | STEEL/S235JR | 4415 | 21967.3 | 2663.33 | +4.365 | +4.465 | S52 | S52 | 2 | 2007 | GALVANISE | S235JR | SOLIVE | 36.4542 | 36.4542 | 0.00464384 | 0.00464384 | 0.302333 | 65.0634 | 2.37183 | 2.37183 | 50 | 6046.67
SOLIVE | STEEL/S235JR | 4415 | 21967.3 | 8080.84 | +4.365 | +4.465 | S75 | S75 | 2 | 2007 | GALVANISE | S235JR | SOLIVE | 28.7473 | 28.7473 | 0.00366208 | 0.00366208 | 0.238417 | 65.0747 | 1.87072 | 1.87072 | 50 | 4768.33
SOLIVE | STEEL/S235JR | 4315 | 23246.9 | 5677.69 | +4.265 | +4.365 | S76 | S76 | 2 | 2007 | GALVANISE | S235JR | SOLIVE | 14.4767 | 14.4767 | 0.00184416 | 0.00184416 | 0.120063 | 65.1273 | 0.942826 | 0.942826 | 50 | 2401.25
SOLIVE | STEEL/S235JR | 4315 | 23246.9 | 8326.02 | +4.265 | +4.365 | S76 | S76 | 2 | 2007 | GALVANISE | S235JR | SOLIVE | 14.4767 | 14.4767 | 0.00184416 | 0.00184416 | 0.120063 | 65.1273 | 0.942826 | 0.942826 | 50 | 2401.25
SOLIVE | STEEL/S235JR | 4315 | 47084.2 | 10391 | +4.265 | +4.365 | 1074 | S44 | 2 | 2007 | GALVANISE | S235JR | SOLIVE | 15.8256 | 15.8256 | 0.002016 | 0.002016 | 0.13125 | 65.1183 | 1.03054 | 1.03054 | 50 | 2625
SOLIVE | STEEL/S235JR | 4415 | 19436 | 2663.33 | +4.365 | +4.465 | 1082 | S53 | 2 | 2007 | GALVANISE | S235JR | SOLIVE | 36.4542 | 36.4542 | 0.00464384 | 0.00464384 | 0.302333 | 65.0634 | 2.37183 | 2.37183 | 50 | 6046.67
SOLIVE | STEEL/S235JR | 4415 | 19436 | 8080.84 | +4.365 | +4.465 | S75 | S75 | 2 | 2007 | GALVANISE | S235JR | SOLIVE | 28.7473 | 28.7473 | 0.00366208 | 0.00366208 | 0.238417 | 65.0747 | 1.87072 | 1.87072 | 50 | 4768.33
SOLIVE | STEEL/S235JR | 4315 | 20715.6 | 8326.02 | +4.265 | +4.365 | S76 | S76 | 2 | 2007 | GALVANISE | S235JR | SOLIVE | 14.4767 | 14.4767 | 0.00184416 | 0.00184416 | 0.120063 | 65.1273 | 0.942826 | 0.942826 | 50 | 2401.25
SOLIVE | STEEL/S235JR | 4315 | 20715.6 | 5677.69 | +4.265 | +4.365 | S76 | S76 | 2 | 2007 | GALVANISE | S235JR | SOLIVE | 14.4767 | 14.4767 | 0.00184416 | 0.00184416 | 0.120063 | 65.1273 | 0.942826 | 0.942826 | 50 | 2401.25
SOLIVE | STEEL/S235JR | 4315 | 27043.7 | 10391 | +4.265 | +4.365 | 1096 | S67 | 2 | 2007 | GALVANISE | S235JR | SOLIVE | 30.4605 | 30.4605 | 0.00388032 | 0.00388032 | 0.252625 | 65.0717 | 1.98212 | 1.98212 | 50 | 5052.5
SOLIVE | STEEL/S235JR | 4415 | 17306 | 2663.33 | +4.365 | +4.465 | S52 | S52 | 2 | 2007 | GALVANISE | S235JR | SOLIVE | 36.4542 | 36.4542 | 0.00464384 | 0.00464384 | 0.302333 | 65.0634 | 2.37183 | 2.37183 | 50 | 6046.67
SOLIVE | STEEL/S235JR | 4415 | 17306 | 8080.84 | +4.365 | +4.465 | S75 | S75 | 2 | 2007 | GALVANISE | S235JR | SOLIVE | 28.7473 | 28.7473 | 0.00366208 | 0.00366208 | 0.238417 | 65.0747 | 1.87072 | 1.87072 | 50 | 4768.33
SOLIVE | STEEL/S235JR | 4315 | 18385 | 8326.02 | +4.265 | +4.365 | S77 | S77 | 2 | 2007 | GALVANISE | S235JR | SOLIVE | 12.0576 | 12.0576 | 0.001536 | 0.001536 | 0.1 | 65.1486 | 0.785536 | 0.785536 | 50 | 2000
SOLIVE | STEEL/S235JR | 4315 | 18385 | 5677.69 | +4.265 | +4.365 | S77 | S77 | 2 | 2007 | GALVANISE | S235JR | SOLIVE | 12.0576 | 12.0576 | 0.001536 | 0.001536 | 0.1 | 65.1486 | 0.785536 | 0.785536 | 50 | 2000
SOLIVE | STEEL/S235JR | 4415 | 15176 | 2663.33 | +4.365 | +4.465 | 1082 | S53 | 2 | 2007 | GALVANISE | S235JR | SOLIVE | 36.4542 | 36.4542 | 0.00464384 | 0.00464384 | 0.302333 | 65.0634 | 2.37183 | 2.37183 | 50 | 6046.67
SOLIVE | STEEL/S235JR | 4415 | 15176 | 8080.84 | +4.365 | +4.465 | S75 | S75 | 2 | 2007 | GALVANISE | S235JR | SOLIVE | 28.7473 | 28.7473 | 0.00366208 | 0.00366208 | 0.238417 | 65.0747 | 1.87072 | 1.87072 | 50 | 4768.33
SOLIVE | STEEL/S235JR | 4315 | 16255 | 5677.69 | +4.265 | +4.365 | S77 | S77 | 2 | 2007 | GALVANISE | S235JR | SOLIVE | 12.0576 | 12.0576 | 0.001536 | 0.001536 | 0.1 | 65.1486 | 0.785536 | 0.785536 | 50 | 2000
SOLIVE | STEEL/S235JR | 4315 | 16255 | 8326.02 | +4.265 | +4.365 | S77 | S77 | 2 | 2007 | GALVANISE | S235JR | SOLIVE | 12.0576 | 12.0576 | 0.001536 | 0.001536 | 0.1 | 65.1486 | 0.785536 | 0.785536 | 50 | 2000
SOLIVE | STEEL/S235JR | 4315 | 11537.5 | 5677.69 | +4.265 | +4.365 | S55 | S55 | 2 | 2007 | GALVANISE | S235JR | SOLIVE | 17.574 | 17.574 | 0.00223872 | 0.00223872 | 0.14575 | 65.1086 | 1.14422 | 1.14422 | 50 | 2915
SOLIVE | STEEL/S235JR | 4315 | 14125 | 5677.69 | +4.265 | +4.365 | S77 | S77 | 2 | 2007 | GALVANISE | S235JR | SOLIVE | 12.0576 | 12.0576 | 0.001536 | 0.001536 | 0.1 | 65.1486 | 0.785536 | 0.785536 | 50 | 2000
SOLIVE | STEEL/S235JR | 4415 | 12046 | 8080.84 | +4.365 | +4.465 | S81 | S81 | 2 | 2007 | GALVANISE | S235JR | SOLIVE | 28.7473 | 28.7473 | 0.00366208 | 0.00366208 | 0.238417 | 65.0747 | 1.87072 | 1.87072 | 50 | 4768.33
SOLIVE | STEEL/S235JR | 4415 | 10116 | 7493.34 | +4.365 | +4.465 | S40 | S40 | 2 | 2007 | GALVANISE | S235JR | SOLIVE | 21.6635 | 21.6635 | 0.00275968 | 0.00275968 | 0.179667 | 65.0921 | 1.41012 | 1.41012 | 50 | 3593.33
SOLIVE | STEEL/S235JR | 4415 | 13046 | 2663.33 | +4.365 | +4.465 | S52 | S52 | 2 | 2007 | GALVANISE | S235JR | SOLIVE | 36.4542 | 36.4542 | 0.00464384 | 0.00464384 | 0.302333 | 65.0634 | 2.37183 | 2.37183 | 50 | 6046.67
SOLIVE | STEEL/S235JR | 4415 | 10116 | 2663.34 | +4.365 | +4.465 | S54 | S54 | 2 | 2007 | GALVANISE | S235JR | SOLIVE | 36.4542 | 36.4542 | 0.00464384 | 0.00464384 | 0.302333 | 65.0634 | 2.37183 | 2.37183 | 50 | 6046.67
SOLIVE | STEEL/S235JR | 4415 | 12046 | 2663.34 | +4.365 | +4.465 | S54 | S54 | 2 | 2007 | GALVANISE | S235JR | SOLIVE | 36.4542 | 36.4542 | 0.00464384 | 0.00464384 | 0.302333 | 65.0634 | 2.37183 | 2.37183 | 50 | 6046.67
SOLIVE | STEEL/S235JR | 4415 | 11046 | 2663.34 | +4.365 | +4.465 | S54 | S54 | 2 | 2007 | GALVANISE | S235JR | SOLIVE | 36.4542 | 36.4542 | 0.00464384 | 0.00464384 | 0.302333 | 65.0634 | 2.37183 | 2.37183 | 50 | 6046.67
SOLIVE | STEEL/S235JR | 4315 | 14125 | 8326.02 | +4.265 | +4.365 | S77 | S77 | 2 | 2007 | GALVANISE | S235JR | SOLIVE | 12.0576 | 12.0576 | 0.001536 | 0.001536 | 0.1 | 65.1486 | 0.785536 | 0.785536 | 50 | 2000
SOLIVE | STEEL/S235JR | 4315 | 11537.5 | 8326.02 | +4.265 | +4.365 | S55 | S55 | 2 | 2007 | GALVANISE | S235JR | SOLIVE | 17.574 | 17.574 | 0.00223872 | 0.00223872 | 0.14575 | 65.1086 | 1.14422 | 1.14422 | 50 | 2915
SOLIVE | STEEL/S235JR | 4415 | 11046 | 8080.84 | +4.365 | +4.465 | S81 | S81 | 2 | 2007 | GALVANISE | S235JR | SOLIVE | 28.7473 | 28.7473 | 0.00366208 | 0.00366208 | 0.238417 | 65.0747 | 1.87072 | 1.87072 | 50 | 4768.33
SOLIVE | STEEL/S235JR | 4415 | 13046 | 8080.84 | +4.365 | +4.465 | S75 | S75 | 2 | 2007 | GALVANISE | S235JR | SOLIVE | 28.7473 | 28.7473 | 0.00366208 | 0.00366208 | 0.238417 | 65.0747 | 1.87072 | 1.87072 | 50 | 4768.33
CHEVETRE | STEEL/E24-2 | 4416.11 | 6375 | 55273.4 | +4.365 | +4.470 | 1149 | U2 | 1 | 1003 | GRENAILLE-PEINT | E24-2 | CHEVETRE | 14.4088 | 14.4088 | 0.00183552 | 0.00183552 | 0 | 65.1278 | 0.938416 | 0.938416 | 50 | 2390
CHEVETRE | STEEL/E24-2 | 4396.23 | 7261.02 | 55436.2 | +4.328 | +4.464 | 1142 | U2 | 1 | 1003 | GRENAILLE-PEINT | E24-2 | CHEVETRE | 1.80864 | 1.80864 | 0.0002304 | 0.0002304 | 0 | 65.8705 | 0.119136 | 0.119136 | 50 | 300
CHEVETRE | STEEL/E24-2 | 4376.35 | 6375 | 55598.9 | +4.322 | +4.428 | 1149 | U2 | 1 | 1003 | GRENAILLE-PEINT | E24-2 | CHEVETRE | 14.4088 | 14.4088 | 0.00183552 | 0.00183552 | 0 | 65.1278 | 0.938416 | 0.938416 | 50 | 2390
CHEVETRE | STEEL/E24-2 | 4376.35 | 6375 | 67273.9 | +4.322 | +4.428 | 1149 | U2 | 1 | 1003 | GRENAILLE-PEINT | E24-2 | CHEVETRE | 14.4088 | 14.4088 | 0.00183552 | 0.00183552 | 0 | 65.1278 | 0.938416 | 0.938416 | 50 | 2390
CHEVETRE | STEEL/E24-2 | 4396.23 | 7261.02 | 67111.2 | +4.328 | +4.464 | 1142 | U2 | 1 | 1003 | GRENAILLE-PEINT | E24-2 | CHEVETRE | 1.80864 | 1.80864 | 0.0002304 | 0.0002304 | 0 | 65.8705 | 0.119136 | 0.119136 | 50 | 300
CHEVETRE | STEEL/E24-2 | 4416.11 | 6375 | 66948.4 | +4.365 | +4.470 | 1149 | U2 | 1 | 1003 | GRENAILLE-PEINT | E24-2 | CHEVETRE | 14.4088 | 14.4088 | 0.00183552 | 0.00183552 | 0 | 65.1278 | 0.938416 | 0.938416 | 50 | 2390
CHEVETRE | STEEL/E24-2 | 4416.11 | 20760 | 66948.4 | +4.365 | +4.470 | 1150 | U3 | 1 | 1003 | GRENAILLE-PEINT | E24-2 | CHEVETRE | 14.5897 | 14.5897 | 0.00185856 | 0.00185856 | 0 | 65.1265 | 0.950176 | 0.950176 | 50 | 2420
CHEVETRE | STEEL/E24-2 | 4396.23 | 19859 | 67111.2 | +4.328 | +4.464 | 1142 | U3 | 1 | 1003 | GRENAILLE-PEINT | E24-2 | CHEVETRE | 1.80864 | 1.80864 | 0.0002304 | 0.0002304 | 0 | 65.8705 | 0.119136 | 0.119136 | 50 | 300
CHEVETRE | STEEL/E24-2 | 4376.35 | 20760 | 67273.9 | +4.322 | +4.428 | 1150 | U3 | 1 | 1003 | GRENAILLE-PEINT | E24-2 | CHEVETRE | 14.5897 | 14.5897 | 0.00185856 | 0.00185856 | 0 | 65.1265 | 0.950176 | 0.950176 | 50 | 2420
CHEVETRE | STEEL/E24-2 | 4376.35 | 20760 | 55598.9 | +4.322 | +4.428 | 1150 | U3 | 1 | 1003 | GRENAILLE-PEINT | E24-2 | CHEVETRE | 14.5897 | 14.5897 | 0.00185856 | 0.00185856 | 0 | 65.1265 | 0.950176 | 0.950176 | 50 | 2420
CHEVETRE | STEEL/E24-2 | 4396.23 | 19859 | 55436.2 | +4.328 | +4.464 | 1142 | U3 | 1 | 1003 | GRENAILLE-PEINT | E24-2 | CHEVETRE | 1.80864 | 1.80864 | 0.0002304 | 0.0002304 | 0 | 65.8705 | 0.119136 | 0.119136 | 50 | 300
CHEVETRE | STEEL/E24-2 | 4416.11 | 20760 | 55273.4 | +4.365 | +4.470 | 1150 | U3 | 1 | 1003 | GRENAILLE-PEINT | E24-2 | CHEVETRE | 14.5897 | 14.5897 | 0.00185856 | 0.00185856 | 0 | 65.1265 | 0.950176 | 0.950176 | 50 | 2420
CHEVETRE | STEEL/E24-2 | 4416.11 | 41560 | 55273.4 | +4.365 | +4.470 | 1150 | U3 | 1 | 1003 | GRENAILLE-PEINT | E24-2 | CHEVETRE | 14.5897 | 14.5897 | 0.00185856 | 0.00185856 | 0 | 65.1265 | 0.950176 | 0.950176 | 50 | 2420
CHEVETRE | STEEL/E24-2 | 4396.23 | 40659 | 55436.2 | +4.328 | +4.464 | 1142 | U3 | 1 | 1003 | GRENAILLE-PEINT | E24-2 | CHEVETRE | 1.80864 | 1.80864 | 0.0002304 | 0.0002304 | 0 | 65.8705 | 0.119136 | 0.119136 | 50 | 300
CHEVETRE | STEEL/E24-2 | 4376.35 | 41560 | 55598.9 | +4.322 | +4.428 | 1150 | U3 | 1 | 1003 | GRENAILLE-PEINT | E24-2 | CHEVETRE | 14.5897 | 14.5897 | 0.00185856 | 0.00185856 | 0 | 65.1265 | 0.950176 | 0.950176 | 50 | 2420
CHEVETRE | STEEL/E24-2 | 4376.35 | 41560 | 67273.9 | +4.322 | +4.428 | 1150 | U3 | 1 | 1003 | GRENAILLE-PEINT | E24-2 | CHEVETRE | 14.5897 | 14.5897 | 0.00185856 | 0.00185856 | 0 | 65.1265 | 0.950176 | 0.950176 | 50 | 2420
CHEVETRE | STEEL/E24-2 | 4396.23 | 40659 | 67111.2 | +4.328 | +4.464 | 1142 | U3 | 1 | 1003 | GRENAILLE-PEINT | E24-2 | CHEVETRE | 1.80864 | 1.80864 | 0.0002304 | 0.0002304 | 0 | 65.8705 | 0.119136 | 0.119136 | 50 | 300
CHEVETRE | STEEL/E24-2 | 4416.11 | 41560 | 66948.4 | +4.365 | +4.470 | 1150 | U3 | 1 | 1003 | GRENAILLE-PEINT | E24-2 | CHEVETRE | 14.5897 | 14.5897 | 0.00185856 | 0.00185856 | 0 | 65.1265 | 0.950176 | 0.950176 | 50 | 2420
CHEVETRE | STEEL/E24-2 | 4376.35 | 59750 | 55598.9 | +4.322 | +4.428 | 1151 | U4 | 1 | 1003 | GRENAILLE-PEINT | E24-2 | CHEVETRE | 14.7103 | 14.7103 | 0.00187392 | 0.00187392 | 0 | 65.1256 | 0.958016 | 0.958016 | 50 | 2440
CHEVETRE | STEEL/E24-2 | 4396.23 | 60661 | 55436.2 | +4.328 | +4.464 | 1142 | U4 | 1 | 1003 | GRENAILLE-PEINT | E24-2 | CHEVETRE | 1.80864 | 1.80864 | 0.0002304 | 0.0002304 | 0 | 65.8705 | 0.119136 | 0.119136 | 50 | 300
CHEVETRE | STEEL/E24-2 | 4416.11 | 59750 | 55273.4 | +4.365 | +4.470 | 1151 | U4 | 1 | 1003 | GRENAILLE-PEINT | E24-2 | CHEVETRE | 14.7103 | 14.7103 | 0.00187392 | 0.00187392 | 0 | 65.1256 | 0.958016 | 0.958016 | 50 | 2440
CHEVETRE | STEEL/E24-2 | 4416.11 | 51950 | 66948.4 | +4.365 | +4.470 | 1151 | U4 | 1 | 1003 | GRENAILLE-PEINT | E24-2 | CHEVETRE | 14.7103 | 14.7103 | 0.00187392 | 0.00187392 | 0 | 65.1256 | 0.958016 | 0.958016 | 50 | 2440
CHEVETRE | STEEL/E24-2 | 4396.23 | 52861 | 67111.2 | +4.328 | +4.464 | 1142 | U4 | 1 | 1003 | GRENAILLE-PEINT | E24-2 | CHEVETRE | 1.80864 | 1.80864 | 0.0002304 | 0.0002304 | 0 | 65.8705 | 0.119136 | 0.119136 | 50 | 300
CHEVETRE | STEEL/E24-2 | 4376.35 | 51950 | 67273.9 | +4.322 | +4.428 | 1151 | U4 | 1 | 1003 | GRENAILLE-PEINT | E24-2 | CHEVETRE | 14.7103 | 14.7103 | 0.00187392 | 0.00187392 | 0 | 65.1256 | 0.958016 | 0.958016 | 50 | 2440
CHEVETRE | STEEL/E24-2 | 4383.64 | 49350 | 78889.2 | +4.330 | +4.435 | 1151 | U4 | 1 | 1003 | GRENAILLE-PEINT | E24-2 | CHEVETRE | 14.7103 | 14.7103 | 0.00187392 | 0.00187392 | 0 | 65.1256 | 0.958016 | 0.958016 | 50 | 2440
CHEVETRE | STEEL/E24-2 | 4423.4 | 49350 | 78563.7 | +4.372 | +4.477 | 1151 | U4 | 1 | 1003 | GRENAILLE-PEINT | E24-2 | CHEVETRE | 14.7103 | 14.7103 | 0.00187392 | 0.00187392 | 0 | 65.1256 | 0.958016 | 0.958016 | 50 | 2440
CHEVETRE | STEEL/E24-2 | 4403.52 | 50261 | 78726.5 | +4.336 | +4.471 | 1142 | U4 | 1 | 1003 | GRENAILLE-PEINT | E24-2 | CHEVETRE | 1.80864 | 1.80864 | 0.0002304 | 0.0002304 | 0 | 65.8705 | 0.119136 | 0.119136 | 50 | 300
CHEVETRE | STEEL/E24-2 | 4403.52 | 39861 | 78726.5 | +4.336 | +4.471 | 1142 | U4 | 1 | 1003 | GRENAILLE-PEINT | E24-2 | CHEVETRE | 1.80864 | 1.80864 | 0.0002304 | 0.0002304 | 0 | 65.8705 | 0.119136 | 0.119136 | 50 | 300
CHEVETRE | STEEL/E24-2 | 4423.4 | 38950 | 78563.7 | +4.372 | +4.477 | 1151 | U4 | 1 | 1003 | GRENAILLE-PEINT | E24-2 | CHEVETRE | 14.7103 | 14.7103 | 0.00187392 | 0.00187392 | 0 | 65.1256 | 0.958016 | 0.958016 | 50 | 2440
CHEVETRE | STEEL/E24-2 | 4383.64 | 38950 | 78889.2 | +4.330 | +4.435 | 1151 | U4 | 1 | 1003 | GRENAILLE-PEINT | E24-2 | CHEVETRE | 14.7103 | 14.7103 | 0.00187392 | 0.00187392 | 0 | 65.1256 | 0.958016 | 0.958016 | 50 | 2440
CHEVETRE | STEEL/E24-2 | 5041.85 | 7261.02 | 78779.9 | +4.987 | +5.096 | 1142 | U2 | 1 | 1003 | GRENAILLE-PEINT | E24-2 | CHEVETRE | 1.80864 | 1.80864 | 0.0002304 | 0.0002304 | 0 | 65.8705 | 0.119136 | 0.119136 | 50 | 300
CHEVETRE | STEEL/E24-2 | 5046.93 | 6375 | 78616 | +4.997 | +5.098 | 1149 | U2 | 1 | 1003 | GRENAILLE-PEINT | E24-2 | CHEVETRE | 14.4088 | 14.4088 | 0.00183552 | 0.00183552 | 0 | 65.1278 | 0.938416 | 0.938416 | 50 | 2390
CHEVETRE | STEEL/E24-2 | 5036.77 | 6375 | 78943.8 | +4.986 | +5.087 | 1149 | U2 | 1 | 1003 | GRENAILLE-PEINT | E24-2 | CHEVETRE | 14.4088 | 14.4088 | 0.00183552 | 0.00183552 | 0 | 65.1278 | 0.938416 | 0.938416 | 50 | 2390
SOLIVE | STEEL/S235JR | 5900 | 29472.5 | 72644.8 | +5.850 | +5.950 | 1059 | S29 | 1 | 1008 | GALVANISE | S235JR | SOLIVE | 35.2986 | 35.2986 | 0.00449664 | 0.00449664 | 0.29275 | 65.0647 | 2.2967 | 2.2967 | 50 | 5855
SOLIVE | STEEL/S235JR | 5800 | 18192.5 | 70586 | +5.750 | +5.850 | S19 | S19 | 1 | 1008 | GALVANISE | S235JR | SOLIVE | 12.5098 | 12.5098 | 0.0015936 | 0.0015936 | 0.10375 | 65.144 | 0.814936 | 0.814936 | 50 | 2075
SOLIVE | STEEL/S235JR | 5800 | 18192.5 | 68111 | +5.750 | +5.850 | S19 | S19 | 1 | 1008 | GALVANISE | S235JR | SOLIVE | 12.5098 | 12.5098 | 0.0015936 | 0.0015936 | 0.10375 | 65.144 | 0.814936 | 0.814936 | 50 | 2075
SOLIVE | STEEL/S235JR | 5900 | 13303 | 71810 | +5.850 | +5.950 | S35 | S35 | 1 | 1008 | GALVANISE | S235JR | SOLIVE | 15.1926 | 15.1926 | 0.00193536 | 0.00193536 | 0.126 | 65.1223 | 0.989376 | 0.989376 | 50 | 2520
SOLIVE | STEEL/S235JR | 5900 | 19156 | 69731 | +5.850 | +5.950 | S25 | S25 | 1 | 1008 | GALVANISE | S235JR | SOLIVE | 23.8861 | 23.8861 | 0.00304282 | 0.00304282 | 0.1981 | 65.0855 | 1.55464 | 1.55464 | 50 | 3962
SOLIVE | STEEL/S235JR | 5800 | 15910 | 70586 | +5.750 | +5.850 | S23 | S23 | 1 | 1008 | GALVANISE | S235JR | SOLIVE | 13.4442 | 13.4442 | 0.00171264 | 0.00171264 | 0.1115 | 65.1355 | 0.875696 | 0.875696 | 50 | 2230
SOLIVE | STEEL/S235JR | 5800 | 13550 | 68111 | +5.750 | +5.850 | S23 | S23 | 1 | 1008 | GALVANISE | S235JR | SOLIVE | 13.4442 | 13.4442 | 0.00171264 | 0.00171264 | 0.1115 | 65.1355 | 0.875696 | 0.875696 | 50 | 2230
SOLIVE | STEEL/S235JR | 5800 | 13550 | 70586 | +5.750 | +5.850 | S18 | S18 | 1 | 1008 | GALVANISE | S235JR | SOLIVE | 13.4442 | 13.4442 | 0.00171264 | 0.00171264 | 0.1115 | 65.1355 | 0.875696 | 0.875696 | 50 | 2230
SOLIVE | STEEL/S235JR | 5800 | 8830 | 78011 | +5.750 | +5.850 | S23 | S23 | 1 | 1008 | GALVANISE | S235JR | SOLIVE | 13.4442 | 13.4442 | 0.00171264 | 0.00171264 | 0.1115 | 65.1355 | 0.875696 | 0.875696 | 50 | 2230
SOLIVE | STEEL/S235JR | 5900.91 | 9995.99 | 76108.9 | +5.850 | +5.950 | S14 | S14 | 1 | 1008 | GALVANISE | S235JR | SOLIVE | 36.4975 | 37.5293 | 0.00464936 | 0.0047808 | 0.31125 | 65.1008 | 2.37602 | 2.44174 | 50 | 6225
SOLIVE | STEEL/S235JR | 5800 | 8830 | 75536 | +5.750 | +5.850 | S23 | S23 | 1 | 1008 | GALVANISE | S235JR | SOLIVE | 13.4442 | 13.4442 | 0.00171264 | 0.00171264 | 0.1115 | 65.1355 | 0.875696 | 0.875696 | 50 | 2230
SOLIVE | STEEL/S235JR | 5800 | 8830 | 73061 | +5.750 | +5.850 | S23 | S23 | 1 | 1008 | GALVANISE | S235JR | SOLIVE | 13.4442 | 13.4442 | 0.00171264 | 0.00171264 | 0.1115 | 65.1355 | 0.875696 | 0.875696 | 50 | 2230
SOLIVE | STEEL/S235JR | 5900 | 9996.02 | 70410 | +5.850 | +5.950 | S21 | S21 | 1 | 1008 | GALVANISE | S235JR | SOLIVE | 32.0732 | 32.0732 | 0.00408576 | 0.00408576 | 0.266 | 65.0691 | 2.08698 | 2.08698 | 50 | 5320
SOLIVE | STEEL/S235JR | 5800 | 8830 | 70586 | +5.750 | +5.850 | S23 | S23 | 1 | 1008 | GALVANISE | S235JR | SOLIVE | 13.4442 | 13.4442 | 0.00171264 | 0.00171264 | 0.1115 | 65.1355 | 0.875696 | 0.875696 | 50 | 2230
SOLIVE | STEEL/S235JR | 5800 | 6375 | 68111 | +5.750 | +5.850 | S22 | S22 | 1 | 1008 | GALVANISE | S235JR | SOLIVE | 14.5897 | 14.5897 | 0.00185856 | 0.00185856 | 0.121 | 65.1265 | 0.950176 | 0.950176 | 50 | 2420
SOLIVE | STEEL/S235JR | 5900 | 7636.02 | 70410 | +5.850 | +5.950 | S21 | S21 | 1 | 1008 | GALVANISE | S235JR | SOLIVE | 32.0732 | 32.0732 | 0.00408576 | 0.00408576 | 0.266 | 65.0691 | 2.08698 | 2.08698 | 50 | 5320
SOLIVE | STEEL/S235JR | 5800 | 6375 | 70586 | +5.750 | +5.850 | S22 | S22 | 1 | 1008 | GALVANISE | S235JR | SOLIVE | 14.5897 | 14.5897 | 0.00185856 | 0.00185856 | 0.121 | 65.1265 | 0.950176 | 0.950176 | 50 | 2420
SOLIVE | STEEL/S235JR | 5800 | 6375 | 73061 | +5.750 | +5.850 | S22 | S22 | 1 | 1008 | GALVANISE | S235JR | SOLIVE | 14.5897 | 14.5897 | 0.00185856 | 0.00185856 | 0.121 | 65.1265 | 0.950176 | 0.950176 | 50 | 2420
SOLIVE | STEEL/S235JR | 5900.91 | 7635.99 | 76108.9 | +5.850 | +5.950 | S14 | S14 | 1 | 1008 | GALVANISE | S235JR | SOLIVE | 36.4975 | 37.5293 | 0.00464936 | 0.0047808 | 0.31125 | 65.1008 | 2.37602 | 2.44174 | 50 | 6225
SOLIVE | STEEL/S235JR | 5800 | 6375 | 75536 | +5.750 | +5.850 | S22 | S22 | 1 | 1008 | GALVANISE | S235JR | SOLIVE | 14.5897 | 14.5897 | 0.00185856 | 0.00185856 | 0.121 | 65.1265 | 0.950176 | 0.950176 | 50 | 2420
SOLIVE | STEEL/S235JR | 5902.38 | 20736.2 | 70116.8 | +5.850 | +5.950 | 1068 | S38 | 1 | 1008 | GALVANISE | S235JR | SOLIVE | 19.1562 | 20.2688 | 0.00244028 | 0.00258202 | 0.1681 | 65.2366 | 1.24968 | 1.31944 | 50 | 3362
SOLIVE | STEEL/S235JR | 5902.38 | 23336.2 | 70116.8 | +5.850 | +5.950 | 1068 | S38 | 1 | 1008 | GALVANISE | S235JR | SOLIVE | 19.1562 | 20.2688 | 0.00244028 | 0.00258202 | 0.1681 | 65.2366 | 1.24968 | 1.31944 | 50 | 3362
SOLIVE | STEEL/S235JR | 5902.38 | 22036.2 | 70116.8 | +5.850 | +5.950 | 1067 | S37 | 1 | 1008 | GALVANISE | S235JR | SOLIVE | 19.1562 | 20.2688 | 0.00244028 | 0.00258202 | 0.1681 | 65.2366 | 1.24968 | 1.31944 | 50 | 3362
SOLIVE | STEEL/S235JR | 5902.38 | 24636.2 | 70116.8 | +5.850 | +5.950 | 1067 | S37 | 1 | 1008 | GALVANISE | S235JR | SOLIVE | 19.1562 | 20.2688 | 0.00244028 | 0.00258202 | 0.1681 | 65.2366 | 1.24968 | 1.31944 | 50 | 3362
SOLIVE | STEEL/S235JR | 5901.23 | 26531.1 | 73833.4 | +5.850 | +5.950 | 1041 | S11 | 1 | 1008 | GALVANISE | S235JR | SOLIVE | 63.9011 | 66.0455 | 0.00814026 | 0.00841344 | 0.54775 | 65.1072 | 4.16042 | 4.2959 | 50 | 10955
SOLIVE | STEEL/S235JR | 5900 | 1336.02 | 70410 | +5.850 | +5.950 | S24 | S24 | 1 | 1008 | GALVANISE | S235JR | SOLIVE | 32.0732 | 32.0732 | 0.00408576 | 0.00408576 | 0.266 | 65.0691 | 2.08698 | 2.08698 | 50 | 5320
SOLIVE | STEEL/S235JR | 5900.91 | 2535.99 | 76108.9 | +5.850 | +5.950 | S14 | S14 | 1 | 1008 | GALVANISE | S235JR | SOLIVE | 36.4975 | 37.5293 | 0.00464936 | 0.0047808 | 0.31125 | 65.1008 | 2.37602 | 2.44174 | 50 | 6225
SOLIVE | STEEL/S235JR | 5900 | 5086.02 | 70410 | +5.850 | +5.950 | S21 | S21 | 1 | 1008 | GALVANISE | S235JR | SOLIVE | 32.0732 | 32.0732 | 0.00408576 | 0.00408576 | 0.266 | 65.0691 | 2.08698 | 2.08698 | 50 | 5320
SOLIVE | STEEL/S235JR | 5900 | 2536.02 | 70410 | +5.850 | +5.950 | S21 | S21 | 1 | 1008 | GALVANISE | S235JR | SOLIVE | 32.0732 | 32.0732 | 0.00408576 | 0.00408576 | 0.266 | 65.0691 | 2.08698 | 2.08698 | 50 | 5320
SOLIVE | STEEL/S235JR | 5900 | 136.021 | 70410 | +5.850 | +5.950 | S24 | S24 | 1 | 1008 | GALVANISE | S235JR | SOLIVE | 32.0732 | 32.0732 | 0.00408576 | 0.00408576 | 0.266 | 65.0691 | 2.08698 | 2.08698 | 50 | 5320
SOLIVE | STEEL/S235JR | 5800 | 1292.5 | 78011 | +5.750 | +5.850 | S17 | S17 | 1 | 1008 | GALVANISE | S235JR | SOLIVE | 14.3787 | 14.3787 | 0.00183168 | 0.00183168 | 0.11925 | 65.1281 | 0.936456 | 0.936456 | 50 | 2385
SOLIVE | STEEL/S235JR | 5800 | 8830 | 68111 | +5.750 | +5.850 | S23 | S23 | 1 | 1008 | GALVANISE | S235JR | SOLIVE | 13.4442 | 13.4442 | 0.00171264 | 0.00171264 | 0.1115 | 65.1355 | 0.875696 | 0.875696 | 50 | 2230
SOLIVE | STEEL/S235JR | 5900.91 | 6360.99 | 76108.9 | +5.850 | +5.950 | S15 | S15 | 1 | 1008 | GALVANISE | S235JR | SOLIVE | 36.4975 | 37.5293 | 0.00464936 | 0.0047808 | 0.31125 | 65.1008 | 2.37602 | 2.44174 | 50 | 6225
SOLIVE | STEEL/S235JR | 5900 | 6361.02 | 70410 | +5.850 | +5.950 | S24 | S24 | 1 | 1008 | GALVANISE | S235JR | SOLIVE | 32.0732 | 32.0732 | 0.00408576 | 0.00408576 | 0.266 | 65.0691 | 2.08698 | 2.08698 | 50 | 5320
SOLIVE | STEEL/S235JR | 5900 | 3811.02 | 70410 | +5.850 | +5.950 | S24 | S24 | 1 | 1008 | GALVANISE | S235JR | SOLIVE | 32.0732 | 32.0732 | 0.00408576 | 0.00408576 | 0.266 | 65.0691 | 2.08698 | 2.08698 | 50 | 5320
SOLIVE | STEEL/S235JR | 5800 | 6375 | 78011 | +5.750 | +5.850 | S22 | S22 | 1 | 1008 | GALVANISE | S235JR | SOLIVE | 14.5897 | 14.5897 | 0.00185856 | 0.00185856 | 0.121 | 65.1265 | 0.950176 | 0.950176 | 50 | 2420
SOLIVE | STEEL/S235JR | 5900 | 8816.02 | 70410 | +5.850 | +5.950 | S24 | S24 | 1 | 1008 | GALVANISE | S235JR | SOLIVE | 32.0732 | 32.0732 | 0.00408576 | 0.00408576 | 0.266 | 65.0691 | 2.08698 | 2.08698 | 50 | 5320
SOLIVE | STEEL/S235JR | 5900.91 | 13303 | 76108.9 | +5.850 | +5.950 | S16 | S16 | 1 | 1008 | GALVANISE | S235JR | SOLIVE | 36.4975 | 37.5293 | 0.00464936 | 0.0047808 | 0.31125 | 65.1008 | 2.37602 | 2.44174 | 50 | 6225
SOLIVE | STEEL/S235JR | 5900 | 13536 | 69731 | +5.850 | +5.950 | S33 | S33 | 1 | 1008 | GALVANISE | S235JR | SOLIVE | 23.8861 | 23.8861 | 0.00304282 | 0.00304282 | 0.1981 | 65.0855 | 1.55464 | 1.55464 | 50 | 3962
SOLIVE | STEEL/S235JR | 5900 | 14716 | 69731 | +5.850 | +5.950 | S34 | S34 | 1 | 1008 | GALVANISE | S235JR | SOLIVE | 23.8861 | 23.8861 | 0.00304282 | 0.00304282 | 0.1981 | 65.0855 | 1.55464 | 1.55464 | 50 | 3962
SOLIVE | STEEL/S235JR | 5900 | 15896 | 69731 | +5.850 | +5.950 | S33 | S33 | 1 | 1008 | GALVANISE | S235JR | SOLIVE | 23.8861 | 23.8861 | 0.00304282 | 0.00304282 | 0.1981 | 65.0855 | 1.55464 | 1.55464 | 50 | 3962
SOLIVE | STEEL/S235JR | 5900 | 17076 | 69731 | +5.850 | +5.950 | S34 | S34 | 1 | 1008 | GALVANISE | S235JR | SOLIVE | 23.8861 | 23.8861 | 0.00304282 | 0.00304282 | 0.1981 | 65.0855 | 1.55464 | 1.55464 | 50 | 3962
SOLIVE | STEEL/S235JR | 5900 | 18256 | 69731 | +5.850 | +5.950 | S33 | S33 | 1 | 1008 | GALVANISE | S235JR | SOLIVE | 23.8861 | 23.8861 | 0.00304282 | 0.00304282 | 0.1981 | 65.0855 | 1.55464 | 1.55464 | 50 | 3962
SOLIVE | STEEL/S235JR | 5902.38 | 19486.2 | 70116.8 | +5.850 | +5.950 | 1068 | S38 | 1 | 1008 | GALVANISE | S235JR | SOLIVE | 19.1562 | 20.2688 | 0.00244028 | 0.00258202 | 0.1681 | 65.2366 | 1.24968 | 1.31944 | 50 | 3362
SOLIVE | STEEL/S235JR | 5800 | 15910 | 68111 | +5.750 | +5.850 | S23 | S23 | 1 | 1008 | GALVANISE | S235JR | SOLIVE | 13.4442 | 13.4442 | 0.00171264 | 0.00171264 | 0.1115 | 65.1355 | 0.875696 | 0.875696 | 50 | 2230
SOLIVE | STEEL/S235JR | 5800 | 3825 | 78011 | +5.750 | +5.850 | S22 | S22 | 1 | 1008 | GALVANISE | S235JR | SOLIVE | 14.5897 | 14.5897 | 0.00185856 | 0.00185856 | 0.121 | 65.1265 | 0.950176 | 0.950176 | 50 | 2420
SOLIVE | STEEL/S235JR | 5800 | 3825 | 75536 | +5.750 | +5.850 | S22 | S22 | 1 | 1008 | GALVANISE | S235JR | SOLIVE | 14.5897 | 14.5897 | 0.00185856 | 0.00185856 | 0.121 | 65.1265 | 0.950176 | 0.950176 | 50 | 2420
SOLIVE | STEEL/S235JR | 5800 | 1292.5 | 75536 | +5.750 | +5.850 | S17 | S17 | 1 | 1008 | GALVANISE | S235JR | SOLIVE | 14.3787 | 14.3787 | 0.00183168 | 0.00183168 | 0.11925 | 65.1281 | 0.936456 | 0.936456 | 50 | 2385
SOLIVE | STEEL/S235JR | 5800 | 3825 | 73061 | +5.750 | +5.850 | S22 | S22 | 1 | 1008 | GALVANISE | S235JR | SOLIVE | 14.5897 | 14.5897 | 0.00185856 | 0.00185856 | 0.121 | 65.1265 | 0.950176 | 0.950176 | 50 | 2420
SOLIVE | STEEL/S235JR | 5800 | 1292.5 | 73061 | +5.750 | +5.850 | S17 | S17 | 1 | 1008 | GALVANISE | S235JR | SOLIVE | 14.3787 | 14.3787 | 0.00183168 | 0.00183168 | 0.11925 | 65.1281 | 0.936456 | 0.936456 | 50 | 2385
SOLIVE | STEEL/S235JR | 5800 | 3825 | 70586 | +5.750 | +5.850 | S22 | S22 | 1 | 1008 | GALVANISE | S235JR | SOLIVE | 14.5897 | 14.5897 | 0.00185856 | 0.00185856 | 0.121 | 65.1265 | 0.950176 | 0.950176 | 50 | 2420
SOLIVE | STEEL/S235JR | 5800 | 1292.5 | 70586 | +5.750 | +5.850 | S17 | S17 | 1 | 1008 | GALVANISE | S235JR | SOLIVE | 14.3787 | 14.3787 | 0.00183168 | 0.00183168 | 0.11925 | 65.1281 | 0.936456 | 0.936456 | 50 | 2385
SOLIVE | STEEL/S235JR | 5800 | 3825 | 68111 | +5.750 | +5.850 | S22 | S22 | 1 | 1008 | GALVANISE | S235JR | SOLIVE | 14.5897 | 14.5897 | 0.00185856 | 0.00185856 | 0.121 | 65.1265 | 0.950176 | 0.950176 | 50 | 2420
SOLIVE | STEEL/S235JR | 5800 | 1292.5 | 68111 | +5.750 | +5.850 | S17 | S17 | 1 | 1008 | GALVANISE | S235JR | SOLIVE | 14.3787 | 14.3787 | 0.00183168 | 0.00183168 | 0.11925 | 65.1281 | 0.936456 | 0.936456 | 50 | 2385
SOLIVE | STEEL/S235JR | 5900.91 | 5085.99 | 76108.9 | +5.850 | +5.950 | S14 | S14 | 1 | 1008 | GALVANISE | S235JR | SOLIVE | 36.4975 | 37.5293 | 0.00464936 | 0.0047808 | 0.31125 | 65.1008 | 2.37602 | 2.44174 | 50 | 6225
SOLIVE | STEEL/S235JR | 5800 | 11190 | 68111 | +5.750 | +5.850 | S23 | S23 | 1 | 1008 | GALVANISE | S235JR | SOLIVE | 13.4442 | 13.4442 | 0.00171264 | 0.00171264 | 0.1115 | 65.1355 | 0.875696 | 0.875696 | 50 | 2230
SOLIVE | STEEL/S235JR | 5800 | 11190 | 70586 | +5.750 | +5.850 | S23 | S23 | 1 | 1008 | GALVANISE | S235JR | SOLIVE | 13.4442 | 13.4442 | 0.00171264 | 0.00171264 | 0.1115 | 65.1355 | 0.875696 | 0.875696 | 50 | 2230
SOLIVE | STEEL/S235JR | 5800 | 11707 | 73061 | +5.750 | +5.850 | S12 | S12 | 1 | 1008 | GALVANISE | S235JR | SOLIVE | 19.678 | 19.678 | 0.00250675 | 0.00250675 | 0.1632 | 65.0993 | 1.28102 | 1.28102 | 50 | 3264
SOLIVE | STEEL/S235JR | 5800 | 11707 | 75536 | +5.750 | +5.850 | S13 | S13 | 1 | 1008 | GALVANISE | S235JR | SOLIVE | 19.678 | 19.678 | 0.00250675 | 0.00250675 | 0.1632 | 65.0993 | 1.28102 | 1.28102 | 50 | 3264
SOLIVE | STEEL/S235JR | 5900 | 12356 | 70410 | +5.850 | +5.950 | S21 | S21 | 1 | 1008 | GALVANISE | S235JR | SOLIVE | 32.0732 | 32.0732 | 0.00408576 | 0.00408576 | 0.266 | 65.0691 | 2.08698 | 2.08698 | 50 | 5320
SOLIVE | STEEL/S235JR | 5800 | 11707 | 78011 | +5.750 | +5.850 | S13 | S13 | 1 | 1008 | GALVANISE | S235JR | SOLIVE | 19.678 | 19.678 | 0.00250675 | 0.00250675 | 0.1632 | 65.0993 | 1.28102 | 1.28102 | 50 | 3264
SOLIVE | STEEL/S235JR | 5900.91 | 12356 | 76108.9 | +5.850 | +5.950 | S31 | S31 | 1 | 1008 | GALVANISE | S235JR | SOLIVE | 36.4975 | 37.5293 | 0.00464936 | 0.0047808 | 0.31125 | 65.1008 | 2.37602 | 2.44174 | 50 | 6225
SOLIVE | STEEL/S235JR | 5900 | 11176 | 70410 | +5.850 | +5.950 | S24 | S24 | 1 | 1008 | GALVANISE | S235JR | SOLIVE | 32.0732 | 32.0732 | 0.00408576 | 0.00408576 | 0.266 | 65.0691 | 2.08698 | 2.08698 | 50 | 5320
SOLIVE | STEEL/S235JR | 5900.91 | 11176 | 76108.9 | +5.850 | +5.950 | S15 | S15 | 1 | 1008 | GALVANISE | S235JR | SOLIVE | 36.4975 | 37.5293 | 0.00464936 | 0.0047808 | 0.31125 | 65.1008 | 2.37602 | 2.44174 | 50 | 6225
SOLIVE | STEEL/S235JR | 5900.91 | 8815.99 | 76108.9 | +5.850 | +5.950 | S15 | S15 | 1 | 1008 | GALVANISE | S235JR | SOLIVE | 36.4975 | 37.5293 | 0.00464936 | 0.0047808 | 0.31125 | 65.1008 | 2.37602 | 2.44174 | 50 | 6225
SOLIVE | STEEL/S235JR | 5900.91 | 3810.99 | 76108.9 | +5.850 | +5.950 | S15 | S15 | 1 | 1008 | GALVANISE | S235JR | SOLIVE | 36.4975 | 37.5293 | 0.00464936 | 0.0047808 | 0.31125 | 65.1008 | 2.37602 | 2.44174 | 50 | 6225
SOLIVE | STEEL/S235JR | 5900.91 | 1335.99 | 76108.9 | +5.850 | +5.950 | S15 | S15 | 1 | 1008 | GALVANISE | S235JR | SOLIVE | 36.4975 | 37.5293 | 0.00464936 | 0.0047808 | 0.31125 | 65.1008 | 2.37602 | 2.44174 | 50 | 6225
SOLIVE | STEEL/S235JR | 5900.91 | 135.989 | 76108.9 | +5.850 | +5.950 | S15 | S15 | 1 | 1008 | GALVANISE | S235JR | SOLIVE | 36.4975 | 37.5293 | 0.00464936 | 0.0047808 | 0.31125 | 65.1008 | 2.37602 | 2.44174 | 50 | 6225
SOLIVE | STEEL/S235JR | 5800 | 23350 | 70888 | +5.750 | +5.850 | S26 | S26 | 1 | 1008 | GALVANISE | S235JR | SOLIVE | 14.8911 | 14.8911 | 0.00189696 | 0.00189696 | 0.1235 | 65.1244 | 0.969776 | 0.969776 | 50 | 2470
SOLIVE | STEEL/S235JR | 5901.86 | 31136.2 | 70564.1 | +5.850 | +5.950 | 1069 | S39 | 1 | 1008 | GALVANISE | S235JR | SOLIVE | 24.5323 | 25.6449 | 0.00312513 | 0.00326686 | 0.212687 | 65.1894 | 1.59924 | 1.669 | 50 | 4253.73
SOLIVE | STEEL/S235JR | 5800 | 25597.5 | 70888 | +5.750 | +5.850 | S27 | S27 | 1 | 1008 | GALVANISE | S235JR | SOLIVE | 10.6408 | 10.6408 | 0.00135552 | 0.00135552 | 0.08825 | 65.1656 | 0.693416 | 0.693416 | 50 | 1765
SOLIVE | STEEL/S235JR | 5800 | 20717.5 | 70888 | +5.750 | +5.850 | S20 | S20 | 1 | 1008 | GALVANISE | S235JR | SOLIVE | 15.283 | 15.283 | 0.00194688 | 0.00194688 | 0.12675 | 65.1217 | 0.995256 | 0.995256 | 50 | 2535
SOLIVE | STEEL/S235JR | 5902.38 | 25533.7 | 70116.8 | +5.850 | +5.950 | 1068 | S38 | 1 | 1008 | GALVANISE | S235JR | SOLIVE | 19.1562 | 20.2688 | 0.00244028 | 0.00258202 | 0.1681 | 65.2366 | 1.24968 | 1.31944 | 50 | 3362
SOLIVE | STEEL/S235JR | 5901.46 | 31136 | 77251.9 | +5.850 | +5.950 | S32 | S32 | 1 | 1008 | GALVANISE | S235JR | SOLIVE | 22.7293 | 23.7611 | 0.00289546 | 0.0030269 | 0.197064 | 65.149 | 1.48079 | 1.54651 | 50 | 3941.27
SOLIVE | STEEL/S235JR | 5901.46 | 29886 | 77251.9 | +5.850 | +5.950 | S32 | S32 | 1 | 1008 | GALVANISE | S235JR | SOLIVE | 22.7293 | 23.7611 | 0.00289546 | 0.0030269 | 0.197064 | 65.149 | 1.48079 | 1.54651 | 50 | 3941.27
SOLIVE | STEEL/S235JR | 5901.46 | 28636 | 77251.9 | +5.850 | +5.950 | S32 | S32 | 1 | 1008 | GALVANISE | S235JR | SOLIVE | 22.7293 | 23.7611 | 0.00289546 | 0.0030269 | 0.197064 | 65.149 | 1.48079 | 1.54651 | 50 | 3941.27
SOLIVE | STEEL/S235JR | 5900 | 31136 | 73983.7 | +5.850 | +5.950 | S36 | S36 | 1 | 1008 | GALVANISE | S235JR | SOLIVE | 15.916 | 15.916 | 0.00202752 | 0.00202752 | 0.132 | 65.1177 | 1.03642 | 1.03642 | 50 | 2640
SOLIVE | STEEL/S235JR | 5901.86 | 28636.2 | 70564.1 | +5.850 | +5.950 | 1069 | S39 | 1 | 1008 | GALVANISE | S235JR | SOLIVE | 24.5323 | 25.6449 | 0.00312513 | 0.00326686 | 0.212687 | 65.1894 | 1.59924 | 1.669 | 50 | 4253.73
SOLIVE | STEEL/S235JR | 5900 | 28636 | 73983.7 | +5.850 | +5.950 | S36 | S36 | 1 | 1008 | GALVANISE | S235JR | SOLIVE | 15.916 | 15.916 | 0.00202752 | 0.00202752 | 0.132 | 65.1177 | 1.03642 | 1.03642 | 50 | 2640
SOLIVE | STEEL/S235JR | 5901.86 | 29886.2 | 70564.1 | +5.850 | +5.950 | 1069 | S39 | 1 | 1008 | GALVANISE | S235JR | SOLIVE | 24.5323 | 25.6449 | 0.00312513 | 0.00326686 | 0.212687 | 65.1894 | 1.59924 | 1.669 | 50 | 4253.73
SOLIVE | STEEL/S235JR | 5900 | 29886 | 73983.7 | +5.850 | +5.950 | S36 | S36 | 1 | 1008 | GALVANISE | S235JR | SOLIVE | 15.916 | 15.916 | 0.00202752 | 0.00202752 | 0.132 | 65.1177 | 1.03642 | 1.03642 | 50 | 2640
SOLIVE | STEEL/S235JR | 5901.23 | 32413.9 | 73833.4 | +5.850 | +5.950 | 1058 | S28 | 1 | 1008 | GALVANISE | S235JR | SOLIVE | 63.9011 | 66.0455 | 0.00814026 | 0.00841344 | 0.54775 | 65.1072 | 4.16042 | 4.2959 | 50 | 10955
SOLIVE | STEEL/S235JR | 5900 | 29472.5 | 75344.8 | +5.850 | +5.950 | 1059 | S29 | 1 | 1008 | GALVANISE | S235JR | SOLIVE | 35.2986 | 35.2986 | 0.00449664 | 0.00449664 | 0.29275 | 65.0647 | 2.2967 | 2.2967 | 50 | 5855
SOLIVE | STEEL/S235JR | 5800 | 29472.5 | 78031 | +5.750 | +5.850 | S30 | S30 | 1 | 1008 | GALVANISE | S235JR | SOLIVE | 35.9015 | 35.9015 | 0.00457344 | 0.00457344 | 0.29775 | 65.064 | 2.3359 | 2.3359 | 50 | 5955
SOLIVE | STEEL/S235JR | 5901.86 | 27386.2 | 70564.1 | +5.850 | +5.950 | 1069 | S39 | 1 | 1008 | GALVANISE | S235JR | SOLIVE | 24.5323 | 25.6449 | 0.00312513 | 0.00326686 | 0.212687 | 65.1894 | 1.59924 | 1.669 | 50 | 4253.73
SOLIVE | STEEL/S235JR | 5901.46 | 27386 | 77251.9 | +5.850 | +5.950 | S32 | S32 | 1 | 1008 | GALVANISE | S235JR | SOLIVE | 22.7293 | 23.7611 | 0.00289546 | 0.0030269 | 0.197064 | 65.149 | 1.48079 | 1.54651 | 50 | 3941.27
SOLIVE | STEEL/S235JR | 5900 | 27386 | 73983.7 | +5.850 | +5.950 | S36 | S36 | 1 | 1008 | GALVANISE | S235JR | SOLIVE | 15.916 | 15.916 | 0.00202752 | 0.00202752 | 0.132 | 65.1177 | 1.03642 | 1.03642 | 50 | 2640
SOLIVE | STEEL/S235JR | 4315 | 43008.3 | 571.021 | +4.265 | +4.365 | S56 | S56 | 2 | 2007 | GALVANISE | S235JR | SOLIVE | 33.1986 | 33.1986 | 0.00422911 | 0.00422911 | 0.275333 | 65.0675 | 2.16015 | 2.16015 | 50 | 5506.66
SOLIVE | STEEL/S235JR | 4315 | 44387.5 | 5677.69 | +4.265 | +4.365 | S82 | S82 | 2 | 2007 | GALVANISE | S235JR | SOLIVE | 15.8457 | 15.8457 | 0.00201856 | 0.00201856 | 0.131416 | 65.1182 | 1.03184 | 1.03184 | 50 | 2628.33
SOLIVE | STEEL/S235JR | 4315 | 44387.5 | 8326.02 | +4.265 | +4.365 | S82 | S82 | 2 | 2007 | GALVANISE | S235JR | SOLIVE | 15.8457 | 15.8457 | 0.00201856 | 0.00201856 | 0.131416 | 65.1182 | 1.03184 | 1.03184 | 50 | 2628.33
SOLIVE | STEEL/S235JR | 4415 | 42994.4 | 8080.84 | +4.365 | +4.465 | S75 | S75 | 2 | 2007 | GALVANISE | S235JR | SOLIVE | 28.7473 | 28.7473 | 0.00366208 | 0.00366208 | 0.238417 | 65.0747 | 1.87072 | 1.87072 | 50 | 4768.33
SOLIVE | STEEL/S235JR | 4415 | 42994.4 | 2663.33 | +4.365 | +4.465 | S52 | S52 | 2 | 2007 | GALVANISE | S235JR | SOLIVE | 36.4542 | 36.4542 | 0.00464384 | 0.00464384 | 0.302333 | 65.0634 | 2.37183 | 2.37183 | 50 | 6046.67
SOLIVE | STEEL/S235JR | 4315 | 17320 | 10391 | +4.265 | +4.365 | 1097 | S68 | 2 | 2007 | GALVANISE | S235JR | SOLIVE | 25.6224 | 25.6224 | 0.003264 | 0.003264 | 0.2125 | 65.0812 | 1.66754 | 1.66754 | 50 | 4250
SOLIVE | STEEL/S235JR | 4315 | 47590.8 | 571.021 | +4.265 | +4.365 | S57 | S57 | 2 | 2007 | GALVANISE | S235JR | SOLIVE | 21.9348 | 21.9348 | 0.00279425 | 0.00279425 | 0.181917 | 65.0913 | 1.42777 | 1.42777 | 50 | 3638.34
SOLIVE | STEEL/S235JR | 4315 | 47620.8 | 5677.69 | +4.265 | +4.365 | S58 | S58 | 2 | 2007 | GALVANISE | S235JR | SOLIVE | 21.5731 | 21.5731 | 0.00274817 | 0.00274817 | 0.178917 | 65.0924 | 1.40425 | 1.40425 | 50 | 3578.34
SOLIVE | STEEL/S235JR | 4315 | 47620.8 | 8326.02 | +4.265 | +4.365 | S58 | S58 | 2 | 2007 | GALVANISE | S235JR | SOLIVE | 21.5731 | 21.5731 | 0.00274817 | 0.00274817 | 0.178917 | 65.0924 | 1.40425 | 1.40425 | 50 | 3578.34
SOLIVE | STEEL/S235JR | 4415 | 45752.7 | 8080.84 | +4.365 | +4.465 | S75 | S75 | 2 | 2007 | GALVANISE | S235JR | SOLIVE | 28.7473 | 28.7473 | 0.00366208 | 0.00366208 | 0.238417 | 65.0747 | 1.87072 | 1.87072 | 50 | 4768.33
SOLIVE | STEEL/S235JR | 4415 | 45752.7 | 2663.33 | +4.365 | +4.465 | 1082 | S53 | 2 | 2007 | GALVANISE | S235JR | SOLIVE | 36.4542 | 36.4542 | 0.00464384 | 0.00464384 | 0.302333 | 65.0634 | 2.37183 | 2.37183 | 50 | 6046.67
SOLIVE | STEEL/S235JR | 4315 | 13097.5 | 10391 | +4.265 | +4.365 | 1079 | S49 | 2 | 2007 | GALVANISE | S235JR | SOLIVE | 25.1701 | 25.1701 | 0.00320638 | 0.00320638 | 0.208749 | 65.0823 | 1.63812 | 1.63812 | 50 | 4174.97
SOLIVE | STEEL/S235JR | 10915 | 65956 | 21550.5 | +10.865 | +10.965 | S83 | S83 | 2 | 2007 | GALVANISE | S235JR | SOLIVE | 20.3834 | 20.3834 | 0.00259661 | 0.00259661 | 0.16905 | 65.0966 | 1.32689 | 1.32689 | 50 | 3381
SOLIVE | STEEL/S235JR | 4415 | 14111 | 2663.34 | +4.365 | +4.465 | S54 | S54 | 2 | 2007 | GALVANISE | S235JR | SOLIVE | 36.4542 | 36.4542 | 0.00464384 | 0.00464384 | 0.302333 | 65.0634 | 2.37183 | 2.37183 | 50 | 6046.67
SOLIVE | STEEL/S235JR | 4415 | 14111 | 8080.84 | +4.365 | +4.465 | S81 | S81 | 2 | 2007 | GALVANISE | S235JR | SOLIVE | 28.7473 | 28.7473 | 0.00366208 | 0.00366208 | 0.238417 | 65.0747 | 1.87072 | 1.87072 | 50 | 4768.33
SOLIVE | STEEL/S235JR | 4415 | 16241 | 8080.84 | +4.365 | +4.465 | S81 | S81 | 2 | 2007 | GALVANISE | S235JR | SOLIVE | 28.7473 | 28.7473 | 0.00366208 | 0.00366208 | 0.238417 | 65.0747 | 1.87072 | 1.87072 | 50 | 4768.33
SOLIVE | STEEL/S235JR | 4415 | 16241 | 2663.34 | +4.365 | +4.465 | S54 | S54 | 2 | 2007 | GALVANISE | S235JR | SOLIVE | 36.4542 | 36.4542 | 0.00464384 | 0.00464384 | 0.302333 | 65.0634 | 2.37183 | 2.37183 | 50 | 6046.67
SOLIVE | STEEL/S235JR | 4415 | 18371 | 8080.84 | +4.365 | +4.465 | S81 | S81 | 2 | 2007 | GALVANISE | S235JR | SOLIVE | 28.7473 | 28.7473 | 0.00366208 | 0.00366208 | 0.238417 | 65.0747 | 1.87072 | 1.87072 | 50 | 4768.33
SOLIVE | STEEL/S235JR | 4415 | 18371 | 2663.34 | +4.365 | +4.465 | S54 | S54 | 2 | 2007 | GALVANISE | S235JR | SOLIVE | 36.4542 | 36.4542 | 0.00464384 | 0.00464384 | 0.302333 | 65.0634 | 2.37183 | 2.37183 | 50 | 6046.67
SOLIVE | STEEL/S235JR | 4415 | 20701.6 | 8080.84 | +4.365 | +4.465 | S81 | S81 | 2 | 2007 | GALVANISE | S235JR | SOLIVE | 28.7473 | 28.7473 | 0.00366208 | 0.00366208 | 0.238417 | 65.0747 | 1.87072 | 1.87072 | 50 | 4768.33
SOLIVE | STEEL/S235JR | 4415 | 20701.6 | 2663.34 | +4.365 | +4.465 | S54 | S54 | 2 | 2007 | GALVANISE | S235JR | SOLIVE | 36.4542 | 36.4542 | 0.00464384 | 0.00464384 | 0.302333 | 65.0634 | 2.37183 | 2.37183 | 50 | 6046.67
SOLIVE | STEEL/S235JR | 4415 | 23232.9 | 8080.84 | +4.365 | +4.465 | S81 | S81 | 2 | 2007 | GALVANISE | S235JR | SOLIVE | 28.7473 | 28.7473 | 0.00366208 | 0.00366208 | 0.238417 | 65.0747 | 1.87072 | 1.87072 | 50 | 4768.33
SOLIVE | STEEL/S235JR | 4415 | 23232.9 | 2663.34 | +4.365 | +4.465 | S54 | S54 | 2 | 2007 | GALVANISE | S235JR | SOLIVE | 36.4542 | 36.4542 | 0.00464384 | 0.00464384 | 0.302333 | 65.0634 | 2.37183 | 2.37183 | 50 | 6046.67
SOLIVE | STEEL/S235JR | 4415 | 25764.1 | 8080.84 | +4.365 | +4.465 | S81 | S81 | 2 | 2007 | GALVANISE | S235JR | SOLIVE | 28.7473 | 28.7473 | 0.00366208 | 0.00366208 | 0.238417 | 65.0747 | 1.87072 | 1.87072 | 50 | 4768.33
SOLIVE | STEEL/S235JR | 4415 | 25764.1 | 2663.34 | +4.365 | +4.465 | S54 | S54 | 2 | 2007 | GALVANISE | S235JR | SOLIVE | 36.4542 | 36.4542 | 0.00464384 | 0.00464384 | 0.302333 | 65.0634 | 2.37183 | 2.37183 | 50 | 6046.67
SOLIVE | STEEL/S235JR | 4415 | 28295.4 | 8080.84 | +4.365 | +4.465 | S81 | S81 | 2 | 2007 | GALVANISE | S235JR | SOLIVE | 28.7473 | 28.7473 | 0.00366208 | 0.00366208 | 0.238417 | 65.0747 | 1.87072 | 1.87072 | 50 | 4768.33
SOLIVE | STEEL/S235JR | 4415 | 28295.4 | 2663.34 | +4.365 | +4.465 | S54 | S54 | 2 | 2007 | GALVANISE | S235JR | SOLIVE | 36.4542 | 36.4542 | 0.00464384 | 0.00464384 | 0.302333 | 65.0634 | 2.37183 | 2.37183 | 50 | 6046.67
SOLIVE | STEEL/S235JR | 4315 | 32243.7 | 571.021 | +4.265 | +4.365 | S62 | S62 | 2 | 2007 | GALVANISE | S235JR | SOLIVE | 32.1184 | 32.1184 | 0.00409152 | 0.00409152 | 0.266375 | 65.0691 | 2.08992 | 2.08992 | 50 | 5327.5
SOLIVE | STEEL/S235JR | 4415 | 30895.4 | 8080.84 | +4.365 | +4.465 | S81 | S81 | 2 | 2007 | GALVANISE | S235JR | SOLIVE | 28.7473 | 28.7473 | 0.00366208 | 0.00366208 | 0.238417 | 65.0747 | 1.87072 | 1.87072 | 50 | 4768.33
SOLIVE | STEEL/S235JR | 4415 | 30895.4 | 2663.34 | +4.365 | +4.465 | S54 | S54 | 2 | 2007 | GALVANISE | S235JR | SOLIVE | 36.4542 | 36.4542 | 0.00464384 | 0.00464384 | 0.302333 | 65.0634 | 2.37183 | 2.37183 | 50 | 6046.67
SOLIVE | STEEL/S235JR | 4415 | 33564.1 | 8080.84 | +4.365 | +4.465 | S81 | S81 | 2 | 2007 | GALVANISE | S235JR | SOLIVE | 28.7473 | 28.7473 | 0.00366208 | 0.00366208 | 0.238417 | 65.0747 | 1.87072 | 1.87072 | 50 | 4768.33
SOLIVE | STEEL/S235JR | 4415 | 33564.1 | 2663.34 | +4.365 | +4.465 | S54 | S54 | 2 | 2007 | GALVANISE | S235JR | SOLIVE | 36.4542 | 36.4542 | 0.00464384 | 0.00464384 | 0.302333 | 65.0634 | 2.37183 | 2.37183 | 50 | 6046.67
SOLIVE | STEEL/S235JR | 4415 | 36232.9 | 8080.84 | +4.365 | +4.465 | S81 | S81 | 2 | 2007 | GALVANISE | S235JR | SOLIVE | 28.7473 | 28.7473 | 0.00366208 | 0.00366208 | 0.238417 | 65.0747 | 1.87072 | 1.87072 | 50 | 4768.33
SOLIVE | STEEL/S235JR | 4415 | 36232.9 | 2663.34 | +4.365 | +4.465 | S54 | S54 | 2 | 2007 | GALVANISE | S235JR | SOLIVE | 36.4542 | 36.4542 | 0.00464384 | 0.00464384 | 0.302333 | 65.0634 | 2.37183 | 2.37183 | 50 | 6046.67
SOLIVE | STEEL/S235JR | 4415 | 38901.6 | 8080.84 | +4.365 | +4.465 | S81 | S81 | 2 | 2007 | GALVANISE | S235JR | SOLIVE | 28.7473 | 28.7473 | 0.00366208 | 0.00366208 | 0.238417 | 65.0747 | 1.87072 | 1.87072 | 50 | 4768.33
SOLIVE | STEEL/S235JR | 4415 | 38901.6 | 2663.34 | +4.365 | +4.465 | S54 | S54 | 2 | 2007 | GALVANISE | S235JR | SOLIVE | 36.4542 | 36.4542 | 0.00464384 | 0.00464384 | 0.302333 | 65.0634 | 2.37183 | 2.37183 | 50 | 6046.67
SOLIVE | STEEL/S235JR | 4415 | 41615.2 | 8080.84 | +4.365 | +4.465 | S81 | S81 | 2 | 2007 | GALVANISE | S235JR | SOLIVE | 28.7473 | 28.7473 | 0.00366208 | 0.00366208 | 0.238417 | 65.0747 | 1.87072 | 1.87072 | 50 | 4768.33
SOLIVE | STEEL/S235JR | 4415 | 41615.2 | 2663.34 | +4.365 | +4.465 | S54 | S54 | 2 | 2007 | GALVANISE | S235JR | SOLIVE | 36.4542 | 36.4542 | 0.00464384 | 0.00464384 | 0.302333 | 65.0634 | 2.37183 | 2.37183 | 50 | 6046.67
SOLIVE | STEEL/S235JR | 4315 | 37581.2 | 571.021 | +4.265 | +4.365 | S62 | S62 | 2 | 2007 | GALVANISE | S235JR | SOLIVE | 32.1184 | 32.1184 | 0.00409152 | 0.00409152 | 0.266375 | 65.0691 | 2.08992 | 2.08992 | 50 | 5327.5
SOLIVE | STEEL/S235JR | 4415 | 44373.5 | 8080.84 | +4.365 | +4.465 | S81 | S81 | 2 | 2007 | GALVANISE | S235JR | SOLIVE | 28.7473 | 28.7473 | 0.00366208 | 0.00366208 | 0.238417 | 65.0747 | 1.87072 | 1.87072 | 50 | 4768.33
SOLIVE | STEEL/S235JR | 4415 | 44373.5 | 2663.34 | +4.365 | +4.465 | S54 | S54 | 2 | 2007 | GALVANISE | S235JR | SOLIVE | 36.4542 | 36.4542 | 0.00464384 | 0.00464384 | 0.302333 | 65.0634 | 2.37183 | 2.37183 | 50 | 6046.67
SOLIVE | STEEL/S235JR | 4415 | 48322.7 | 2663.34 | +4.365 | +4.465 | S54 | S54 | 2 | 2007 | GALVANISE | S235JR | SOLIVE | 36.4542 | 36.4542 | 0.00464384 | 0.00464384 | 0.302333 | 65.0634 | 2.37183 | 2.37183 | 50 | 6046.67
SOLIVE | STEEL/S235JR | 4415 | 48322.7 | 8080.84 | +4.365 | +4.465 | S81 | S81 | 2 | 2007 | GALVANISE | S235JR | SOLIVE | 28.7473 | 28.7473 | 0.00366208 | 0.00366208 | 0.238417 | 65.0747 | 1.87072 | 1.87072 | 50 | 4768.33
SOLIVE | STEEL/S235JR | 4415 | 49374 | 7495.84 | +4.365 | +4.465 | S41 | S41 | 2 | 2007 | GALVANISE | S235JR | SOLIVE | 21.6936 | 21.6936 | 0.00276352 | 0.00276352 | 0.179917 | 65.092 | 1.41208 | 1.41208 | 50 | 3598.33
SOLIVE | STEEL/S235JR | 4415 | 49374 | 2663.34 | +4.365 | +4.465 | S54 | S54 | 2 | 2007 | GALVANISE | S235JR | SOLIVE | 36.4542 | 36.4542 | 0.00464384 | 0.00464384 | 0.302333 | 65.0634 | 2.37183 | 2.37183 | 50 | 6046.67
SOLIVE | STEEL/S235JR | 4415 | 40236 | 8080.84 | +4.365 | +4.465 | S75 | S75 | 2 | 2007 | GALVANISE | S235JR | SOLIVE | 28.7473 | 28.7473 | 0.00366208 | 0.00366208 | 0.238417 | 65.0747 | 1.87072 | 1.87072 | 50 | 4768.33
SOLIVE | STEEL/S235JR | 10815 | 62367.5 | 31661 | +10.765 | +10.865 | S80 | S80 | 2 | 2007 | GALVANISE | S235JR | SOLIVE | 15.8859 | 15.8859 | 0.00202368 | 0.00202368 | 0.13175 | 65.1179 | 1.03446 | 1.03446 | 50 | 2635
SOLIVE | STEEL/S235JR | 10815 | 62367.5 | 26005 | +10.765 | +10.865 | S80 | S80 | 2 | 2007 | GALVANISE | S235JR | SOLIVE | 15.8859 | 15.8859 | 0.00202368 | 0.00202368 | 0.13175 | 65.1179 | 1.03446 | 1.03446 | 50 | 2635
SOLIVE | STEEL/S235JR | 10915 | 63736 | 22937 | +10.865 | +10.965 | S46 | S46 | 2 | 2007 | GALVANISE | S235JR | SOLIVE | 37.1012 | 37.1012 | 0.00472627 | 0.00472627 | 0.3077 | 65.0626 | 2.4139 | 2.4139 | 50 | 6154
SOLIVE | STEEL/S235JR | 10915 | 63736 | 29349.5 | +10.865 | +10.965 | S79 | S79 | 2 | 2007 | GALVANISE | S235JR | SOLIVE | 40.0975 | 40.0975 | 0.00510797 | 0.00510797 | 0.33255 | 65.0595 | 2.60873 | 2.60873 | 50 | 6651
SOLIVE | STEEL/S235JR | 10815 | 65142.5 | 31661 | +10.765 | +10.865 | S47 | S47 | 2 | 2007 | GALVANISE | S235JR | SOLIVE | 16.0065 | 16.0065 | 0.00203904 | 0.00203904 | 0.13275 | 65.1172 | 1.0423 | 1.0423 | 50 | 2655
SOLIVE | STEEL/S235JR | 10815 | 65142.5 | 26005 | +10.765 | +10.865 | S47 | S47 | 2 | 2007 | GALVANISE | S235JR | SOLIVE | 16.0065 | 16.0065 | 0.00203904 | 0.00203904 | 0.13275 | 65.1172 | 1.0423 | 1.0423 | 50 | 2655
SOLIVE | STEEL/S235JR | 10915 | 65066 | 22937 | +10.865 | +10.965 | S74 | S74 | 2 | 2007 | GALVANISE | S235JR | SOLIVE | 37.1012 | 37.1012 | 0.00472627 | 0.00472627 | 0.3077 | 65.0626 | 2.4139 | 2.4139 | 50 | 6154
SOLIVE | STEEL/S235JR | 10915 | 65066 | 29349.5 | +10.865 | +10.965 | S73 | S73 | 2 | 2007 | GALVANISE | S235JR | SOLIVE | 40.0975 | 40.0975 | 0.00510797 | 0.00510797 | 0.33255 | 65.0595 | 2.60873 | 2.60873 | 50 | 6651
SOLIVE | STEEL/S235JR | 10815 | 62367.5 | 23205 | +10.765 | +10.865 | S80 | S80 | 2 | 2007 | GALVANISE | S235JR | SOLIVE | 15.8859 | 15.8859 | 0.00202368 | 0.00202368 | 0.13175 | 65.1179 | 1.03446 | 1.03446 | 50 | 2635
SOLIVE | STEEL/S235JR | 10815 | 65142.5 | 23205 | +10.765 | +10.865 | S59 | S59 | 2 | 2007 | GALVANISE | S235JR | SOLIVE | 16.0065 | 16.0065 | 0.00203904 | 0.00203904 | 0.13275 | 65.1172 | 1.0423 | 1.0423 | 50 | 2655
SOLIVE | STEEL/S235JR | 10915 | 66396 | 29349.5 | +10.865 | +10.965 | S73 | S73 | 2 | 2007 | GALVANISE | S235JR | SOLIVE | 40.0975 | 40.0975 | 0.00510797 | 0.00510797 | 0.33255 | 65.0595 | 2.60873 | 2.60873 | 50 | 6651
SOLIVE | STEEL/S235JR | 10915 | 66396 | 22937 | +10.865 | +10.965 | S74 | S74 | 2 | 2007 | GALVANISE | S235JR | SOLIVE | 37.1012 | 37.1012 | 0.00472627 | 0.00472627 | 0.3077 | 65.0626 | 2.4139 | 2.4139 | 50 | 6154
SOLIVE | STEEL/S235JR | 10815 | 65142.5 | 28833 | +10.765 | +10.865 | S47 | S47 | 2 | 2007 | GALVANISE | S235JR | SOLIVE | 16.0065 | 16.0065 | 0.00203904 | 0.00203904 | 0.13275 | 65.1172 | 1.0423 | 1.0423 | 50 | 2655
SOLIVE | STEEL/S235JR | 10815 | 62367.5 | 28833 | +10.765 | +10.865 | S80 | S80 | 2 | 2007 | GALVANISE | S235JR | SOLIVE | 15.8859 | 15.8859 | 0.00202368 | 0.00202368 | 0.13175 | 65.1179 | 1.03446 | 1.03446 | 50 | 2635
SOLIVE | STEEL/S235JR | 10815 | 59602.5 | 31661 | +10.765 | +10.865 | S80 | S80 | 2 | 2007 | GALVANISE | S235JR | SOLIVE | 15.8859 | 15.8859 | 0.00202368 | 0.00202368 | 0.13175 | 65.1179 | 1.03446 | 1.03446 | 50 | 2635
SOLIVE | STEEL/S235JR | 10815 | 59602.5 | 28833 | +10.765 | +10.865 | S80 | S80 | 2 | 2007 | GALVANISE | S235JR | SOLIVE | 15.8859 | 15.8859 | 0.00202368 | 0.00202368 | 0.13175 | 65.1179 | 1.03446 | 1.03446 | 50 | 2635
SOLIVE | STEEL/S235JR | 10815 | 59602.5 | 26005 | +10.765 | +10.865 | S80 | S80 | 2 | 2007 | GALVANISE | S235JR | SOLIVE | 15.8859 | 15.8859 | 0.00202368 | 0.00202368 | 0.13175 | 65.1179 | 1.03446 | 1.03446 | 50 | 2635
SOLIVE | STEEL/S235JR | 10815 | 59602.5 | 23205 | +10.765 | +10.865 | S80 | S80 | 2 | 2007 | GALVANISE | S235JR | SOLIVE | 15.8859 | 15.8859 | 0.00202368 | 0.00202368 | 0.13175 | 65.1179 | 1.03446 | 1.03446 | 50 | 2635
SOLIVE | STEEL/S235JR | 10815 | 56837.5 | 31661 | +10.765 | +10.865 | S80 | S80 | 2 | 2007 | GALVANISE | S235JR | SOLIVE | 15.8859 | 15.8859 | 0.00202368 | 0.00202368 | 0.13175 | 65.1179 | 1.03446 | 1.03446 | 50 | 2635
SOLIVE | STEEL/S235JR | 10815 | 56837.5 | 28833 | +10.765 | +10.865 | S80 | S80 | 2 | 2007 | GALVANISE | S235JR | SOLIVE | 15.8859 | 15.8859 | 0.00202368 | 0.00202368 | 0.13175 | 65.1179 | 1.03446 | 1.03446 | 50 | 2635
SOLIVE | STEEL/S235JR | 10815 | 56837.5 | 26005 | +10.765 | +10.865 | S80 | S80 | 2 | 2007 | GALVANISE | S235JR | SOLIVE | 15.8859 | 15.8859 | 0.00202368 | 0.00202368 | 0.13175 | 65.1179 | 1.03446 | 1.03446 | 50 | 2635
SOLIVE | STEEL/S235JR | 10815 | 56837.5 | 23205 | +10.765 | +10.865 | S80 | S80 | 2 | 2007 | GALVANISE | S235JR | SOLIVE | 15.8859 | 15.8859 | 0.00202368 | 0.00202368 | 0.13175 | 65.1179 | 1.03446 | 1.03446 | 50 | 2635
SOLIVE | STEEL/S235JR | 10815 | 54072.5 | 31661 | +10.765 | +10.865 | S80 | S80 | 2 | 2007 | GALVANISE | S235JR | SOLIVE | 15.8859 | 15.8859 | 0.00202368 | 0.00202368 | 0.13175 | 65.1179 | 1.03446 | 1.03446 | 50 | 2635
SOLIVE | STEEL/S235JR | 10815 | 54072.5 | 28833 | +10.765 | +10.865 | S80 | S80 | 2 | 2007 | GALVANISE | S235JR | SOLIVE | 15.8859 | 15.8859 | 0.00202368 | 0.00202368 | 0.13175 | 65.1179 | 1.03446 | 1.03446 | 50 | 2635
SOLIVE | STEEL/S235JR | 10815 | 54072.5 | 26005 | +10.765 | +10.865 | S80 | S80 | 2 | 2007 | GALVANISE | S235JR | SOLIVE | 15.8859 | 15.8859 | 0.00202368 | 0.00202368 | 0.13175 | 65.1179 | 1.03446 | 1.03446 | 50 | 2635
SOLIVE | STEEL/S235JR | 10815 | 54072.5 | 23205 | +10.765 | +10.865 | S80 | S80 | 2 | 2007 | GALVANISE | S235JR | SOLIVE | 15.8859 | 15.8859 | 0.00202368 | 0.00202368 | 0.13175 | 65.1179 | 1.03446 | 1.03446 | 50 | 2635
SOLIVE | STEEL/S235JR | 10915 | 60971 | 29349.5 | +10.865 | +10.965 | S79 | S79 | 2 | 2007 | GALVANISE | S235JR | SOLIVE | 40.0975 | 40.0975 | 0.00510797 | 0.00510797 | 0.33255 | 65.0595 | 2.60873 | 2.60873 | 50 | 6651
SOLIVE | STEEL/S235JR | 10915 | 60971 | 22937 | +10.865 | +10.965 | S46 | S46 | 2 | 2007 | GALVANISE | S235JR | SOLIVE | 37.1012 | 37.1012 | 0.00472627 | 0.00472627 | 0.3077 | 65.0626 | 2.4139 | 2.4139 | 50 | 6154
SOLIVE | STEEL/S235JR | 10915 | 58206 | 29349.5 | +10.865 | +10.965 | S79 | S79 | 2 | 2007 | GALVANISE | S235JR | SOLIVE | 40.0975 | 40.0975 | 0.00510797 | 0.00510797 | 0.33255 | 65.0595 | 2.60873 | 2.60873 | 50 | 6651
SOLIVE | STEEL/S235JR | 10915 | 58206 | 22937 | +10.865 | +10.965 | S46 | S46 | 2 | 2007 | GALVANISE | S235JR | SOLIVE | 37.1012 | 37.1012 | 0.00472627 | 0.00472627 | 0.3077 | 65.0626 | 2.4139 | 2.4139 | 50 | 6154
SOLIVE | STEEL/S235JR | 10915 | 55441 | 29349.5 | +10.865 | +10.965 | S79 | S79 | 2 | 2007 | GALVANISE | S235JR | SOLIVE | 40.0975 | 40.0975 | 0.00510797 | 0.00510797 | 0.33255 | 65.0595 | 2.60873 | 2.60873 | 50 | 6651
SOLIVE | STEEL/S235JR | 10915 | 55441 | 22937 | +10.865 | +10.965 | S46 | S46 | 2 | 2007 | GALVANISE | S235JR | SOLIVE | 37.1012 | 37.1012 | 0.00472627 | 0.00472627 | 0.3077 | 65.0626 | 2.4139 | 2.4139 | 50 | 6154
SOLIVE | STEEL/S235JR | 10915 | 52676 | 29349.5 | +10.865 | +10.965 | S79 | S79 | 2 | 2007 | GALVANISE | S235JR | SOLIVE | 40.0975 | 40.0975 | 0.00510797 | 0.00510797 | 0.33255 | 65.0595 | 2.60873 | 2.60873 | 50 | 6651
SOLIVE | STEEL/S235JR | 10915 | 52676 | 22937 | +10.865 | +10.965 | S46 | S46 | 2 | 2007 | GALVANISE | S235JR | SOLIVE | 37.1012 | 37.1012 | 0.00472627 | 0.00472627 | 0.3077 | 65.0626 | 2.4139 | 2.4139 | 50 | 6154
SOLIVE | STEEL/S235JR | 10915 | 62353.5 | 22937 | +10.865 | +10.965 | S74 | S74 | 2 | 2007 | GALVANISE | S235JR | SOLIVE | 37.1012 | 37.1012 | 0.00472627 | 0.00472627 | 0.3077 | 65.0626 | 2.4139 | 2.4139 | 50 | 6154
SOLIVE | STEEL/S235JR | 10815 | 51322.5 | 23205 | +10.765 | +10.865 | S60 | S60 | 2 | 2007 | GALVANISE | S235JR | SOLIVE | 15.705 | 15.705 | 0.00200064 | 0.00200064 | 0.13025 | 65.119 | 1.0227 | 1.0227 | 50 | 2605
SOLIVE | STEEL/S235JR | 10815 | 51322.5 | 28833 | +10.765 | +10.865 | S45 | S45 | 2 | 2007 | GALVANISE | S235JR | SOLIVE | 15.705 | 15.705 | 0.00200064 | 0.00200064 | 0.13025 | 65.119 | 1.0227 | 1.0227 | 50 | 2605
SOLIVE | STEEL/S235JR | 10915 | 51374 | 29349.5 | +10.865 | +10.965 | S73 | S73 | 2 | 2007 | GALVANISE | S235JR | SOLIVE | 40.0975 | 40.0975 | 0.00510797 | 0.00510797 | 0.33255 | 65.0595 | 2.60873 | 2.60873 | 50 | 6651
SOLIVE | STEEL/S235JR | 10915 | 51374 | 22937 | +10.865 | +10.965 | S74 | S74 | 2 | 2007 | GALVANISE | S235JR | SOLIVE | 37.1012 | 37.1012 | 0.00472627 | 0.00472627 | 0.3077 | 65.0626 | 2.4139 | 2.4139 | 50 | 6154
SOLIVE | STEEL/S235JR | 10815 | 51322.5 | 26005 | +10.765 | +10.865 | S45 | S45 | 2 | 2007 | GALVANISE | S235JR | SOLIVE | 15.705 | 15.705 | 0.00200064 | 0.00200064 | 0.13025 | 65.119 | 1.0227 | 1.0227 | 50 | 2605
SOLIVE | STEEL/S235JR | 10815 | 51322.5 | 31661 | +10.765 | +10.865 | S45 | S45 | 2 | 2007 | GALVANISE | S235JR | SOLIVE | 15.705 | 15.705 | 0.00200064 | 0.00200064 | 0.13025 | 65.119 | 1.0227 | 1.0227 | 50 | 2605
SOLIVE | STEEL/S235JR | 10915 | 62353.5 | 29349.5 | +10.865 | +10.965 | S73 | S73 | 2 | 2007 | GALVANISE | S235JR | SOLIVE | 40.0975 | 40.0975 | 0.00510797 | 0.00510797 | 0.33255 | 65.0595 | 2.60873 | 2.60873 | 50 | 6651
SOLIVE | STEEL/S235JR | 4315 | 47620.8 | 3029.35 | +4.265 | +4.365 | S58 | S58 | 2 | 2007 | GALVANISE | S235JR | SOLIVE | 21.5731 | 21.5731 | 0.00274817 | 0.00274817 | 0.178917 | 65.0924 | 1.40425 | 1.40425 | 50 | 3578.34
SOLIVE | STEEL/S235JR | 4315 | 44387.5 | 3029.35 | +4.265 | +4.365 | S82 | S82 | 2 | 2007 | GALVANISE | S235JR | SOLIVE | 15.8457 | 15.8457 | 0.00201856 | 0.00201856 | 0.131416 | 65.1182 | 1.03184 | 1.03184 | 50 | 2628.33
SOLIVE | STEEL/S235JR | 4315 | 41629.2 | 3029.35 | +4.265 | +4.365 | S82 | S82 | 2 | 2007 | GALVANISE | S235JR | SOLIVE | 15.8457 | 15.8457 | 0.00201856 | 0.00201856 | 0.131416 | 65.1182 | 1.03184 | 1.03184 | 50 | 2628.33
SOLIVE | STEEL/S235JR | 4315 | 38915.6 | 3029.35 | +4.265 | +4.365 | S78 | S78 | 2 | 2007 | GALVANISE | S235JR | SOLIVE | 15.3056 | 15.3056 | 0.00194976 | 0.00194976 | 0.126938 | 65.1216 | 0.996726 | 0.996726 | 50 | 2538.75
SOLIVE | STEEL/S235JR | 4315 | 36246.9 | 3029.35 | +4.265 | +4.365 | S78 | S78 | 2 | 2007 | GALVANISE | S235JR | SOLIVE | 15.3056 | 15.3056 | 0.00194976 | 0.00194976 | 0.126938 | 65.1216 | 0.996726 | 0.996726 | 50 | 2538.75
