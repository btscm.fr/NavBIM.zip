Properties of the parts of a building model (IFC2X3), part 23 of 32

# IfcElementAssembly (4665)
Name | Assembly/Cast unit weight (kg) | Assembly/Cast unit bottom elevation | Assembly/Cast unit top elevation | Assembly/Cast unit name | Assembly/Cast unit position code | Assembly/Cast unit Mark
IPE200 | 3.73032 | -0.400 | +5.875 | IPE200 | /D1-C1 | P9
IPE200 | 10.6694 | -0.400 | +5.875 | IPE200 | /D1 | P8
IPE200 | 3.73032 | -0.400 | +5.875 | IPE200 | 8/F-E | P7
IPE200 | 8.65992 | -0.400 | +5.875 | IPE200 | 8/E | P6
IPEA300 | 13.0903 | -0.400 | +5.880 | IPEA300 | 8/F | P122
IPEA300 | 8.80535 | -0.400 | +5.875 | IPEA300 | 7-8/F | P117
IPEA300 | 9.9263 | -0.400 | +5.965 | IPEA300 | 6-7/F | P116
IPEA300 | 24.1003 | -0.400 | +5.965 | IPEA300 | 5-6/F | P115
PL5950*200 | 64027.7 | +0.000 | +5.561 | PL5950*200 | 7-8/D-B | Z41 | PredefinedType: REINFORCEMENT_UNIT; Tekla Assembly - Cast unit vertical position code: A-+3940; Cast unit rebar weight: 0 kg
IPEA300 | 14.8363 | -0.400 | +5.965 | IPEA300 | 4-5/F | P114
IPEA300 | 40.9955 | -0.400 | +5.890 | IPEA300 | 4/F | P113
IPEA300 | 14.8363 | -0.400 | +5.965 | IPEA300 | 3-4/F | P121
IPEA300 | 14.8363 | -0.400 | +5.965 | IPEA300 | 3-4/F | P120
IPEA300 | 34.4216 | -0.400 | +5.890 | IPEA300 | 3/F | P119
IPE400 | 17.9166 | -0.400 | +5.890 | IPE400 | 3/E | P39
IPE400 | 17.9166 | -0.400 | +5.890 | IPE400 | 4/E | P5
IPE400 | 17.9166 | -0.600 | +5.890 | IPE400 | 5/E | P3
IPE500 | 63.4686 | -0.400 | +5.890 | IPE500 | 5/D | P36
IPE500 | 63.4686 | -0.400 | +5.890 | IPE500 | 4/D | P32
IPE500 | 39.016 | -0.400 | +5.890 | IPE500 | 3/D | P29
IPE500 | 63.4686 | -0.400 | +5.890 | IPE500 | 6/D | P36
2 x IPEA300 | 0 | +4.104 | +5.809 | IPEA300 | 3-4/E-D | K16
IPE500 | 58.6468 | -0.400 | +5.890 | IPE500 | 4/C | P31
IPE500 | 39.016 | -0.400 | +5.890 | IPE500 | 3/C | P30
2 x IPEA300 | 0 | +4.104 | +5.809 | IPEA300 | 3-4/E-D | K14
IPE400 | 22.2968 | -0.060 | +5.975 | IPE400 | 7/B | P37
IPE400 | 22.2968 | -0.400 | +5.975 | IPE400 | 6/B | P2
IPE400 | 22.2968 | -0.400 | +5.975 | IPE400 | 5/B | P1
IPE450 | 142.182 | +3.767 | +5.771 | IPE450 | 6-7/D | K21
PL8 | 6.82104 | +4.774 | +4.831 | PL8 | 5-6/A | G3
IPEA300 | 80.4134 | +3.863 | +5.901 | IPEA300 | 5/F-E | N16
IPE450 | 142.284 | +3.767 | +5.771 | IPE450 | 6-7/C | K24
IPE500 | 58.6468 | -0.400 | +5.890 | IPE500 | 5/C | P35
IPE500 | 48.8314 | -0.400 | +5.890 | IPE500 | 7/C | P33
2 x IPEA300 | 0 | +4.104 | +5.809 | IPEA300 | 6-7/E-D | K16
PL50*8 | 0.157 | +5.264 | +5.280 | PL50*8 | 5-6/F-E | Y3
IPE500 | 0 | -0.375 | +5.890 | IPE500 | 8/C | P34
IPE450 | 142.284 | +3.767 | +5.771 | IPE450 | 3-4/C | K23
IPE450 | 142.284 | +3.767 | +5.771 | IPE450 | 4-5/C | K22
2 x IPEA300 | 0 | +4.104 | +5.809 | IPEA300 | 6-7/E-D | K14
IPEA300 | 0 | +4.113 | +5.809 | IPEA300 | 3-4/F-E | K12
IPEA300 | 83.3645 | +3.863 | +5.901 | IPEA300 | 3/F-E | N18
IPEA300 | 0 | +4.104 | +5.809 | IPEA300 | 3-4/F-E | K11
IPEA300 | 0 | +4.104 | +5.809 | IPEA300 | 6-7/F-E | K11
PL8 | 6.82104 | +4.774 | +4.831 | PL8 | 4-5/F | G2
4 x IPEA300 | 0 | +4.104 | +5.809 | IPEA300 | 6-7/D-C | K16
3 x IPEA300 | 0 | +4.104 | +5.809 | IPEA300 | 6-7/D-C | K14
2 x L70*7 | 0 | +4.803 | +4.881 | L70*7 | 4-5/F-E | C103
4 x IPEA300 | 0 | +4.104 | +5.809 | IPEA300 | 3-4/D-C | K16
3 x IPEA300 | 0 | +4.104 | +5.809 | IPEA300 | 3-4/D-C | K14
PL50*8 | 0.157 | +5.447 | +5.463 | PL50*8 | 5-6/F | Y3
PL50*8 | 0.157 | +5.401 | +5.418 | PL50*8 | 5-6/F-E | Y3
PL8 | 2.57354 | +4.792 | +4.814 | PL8 | 4-5/F-E | G18
PL50*8 | 0.157 | +5.355 | +5.372 | PL50*8 | 5-6/F-E | Y3
PL8 | 8.43791 | +4.773 | +4.832 | PL8 | 4-5/F-E | G9
PL50*8 | 0.157 | +5.310 | +5.326 | PL50*8 | 5-6/F-E | Y3
L70*7 | 0 | +4.733 | +4.804 | L70*7 | 4-5/E-D | C115
PL50*8 | 0.157 | +5.218 | +5.234 | PL50*8 | 5-6/F-E | Y3
4 x IPEA300 | 0 | +4.104 | +5.809 | IPEA300 | 6-7/C-B | K16
3 x IPEA300 | 0 | +4.104 | +5.809 | IPEA300 | 6-7/C-B | K14
PL50*8 | 0.157 | +4.504 | +4.521 | PL50*8 | 4-5/F-E | Y3
IPEA300 | 0 | +4.104 | +5.809 | IPEA300 | 3-4/C-B | K2
PL50*8 | 0.157 | +4.142 | +4.159 | PL50*8 | 5-6/F | Y3
PL50*8 | 0.157 | +4.549 | +4.565 | PL50*8 | 4-5/F-E | Y3
IPEA300 | 0 | +4.113 | +5.809 | IPEA300 | 3-4/C-B | K19
PL50*8 | 0.157 | +4.188 | +4.204 | PL50*8 | 5-6/F-E | Y3
PL50*8 | 0.157 | +4.234 | +4.250 | PL50*8 | 5-6/F-E | Y3
IPE330 | 0 | +4.071 | +5.792 | IPE330 | 4-5/C-B | K29
PL2800*200 | 23629.2 | +3.140 | +5.940 | PL2800*200 | 3-4/C-A | Z58 | PredefinedType: REINFORCEMENT_UNIT; Tekla Assembly - Cast unit vertical position code: A-+3940; Cast unit rebar weight: 0 kg
PL50*8 | 0.157 | +4.279 | +4.296 | PL50*8 | 5-6/F-E | Y3
3 x IPE330 | 0 | +4.071 | +5.792 | IPE330 | 4-5/C-B | K30
PL3860*200 | 10740.9 | +3.140 | +7.000 | PL3860*200 | 3-4/C-B | Z48 | PredefinedType: REINFORCEMENT_UNIT; Tekla Assembly - Cast unit vertical position code: A-+3940>; Cast unit rebar weight: 0 kg
PL50*8 | 0.157 | +4.325 | +4.342 | PL50*8 | 5-6/F-E | Y3
PL5940*200 | 52889.8 | -0.000 | +5.940 | PL5940*200 | 3/C-A | Z15 | PredefinedType: REINFORCEMENT_UNIT; Tekla Assembly - Cast unit vertical position code: A-+3940; Cast unit rebar weight: 0 kg
IPEA300 | 0 | +4.113 | +5.809 | IPEA300 | 6-7/B-A | K13
PL6140*400 | 2063.04 | +0.000 | +6.140 | PL6140*400 | 4/C-B | Z77 | PredefinedType: REINFORCEMENT_UNIT; Tekla Assembly - Cast unit vertical position code: A-+3940; Cast unit rebar weight: 0 kg
IPEA300 | 0 | +4.104 | +5.809 | IPEA300 | 6-7/B-A | K11
IPE330 | 0 | +4.080 | +5.792 | IPE330 | 4-5/B-A | K31
PL6140*400 | 4126.08 | +0.000 | +6.140 | PL6140*400 | 3-4/B | Z78 | PredefinedType: REINFORCEMENT_UNIT; Tekla Assembly - Cast unit vertical position code: A-+3940; Cast unit rebar weight: 0 kg
IPE330 | 0 | +4.071 | +5.792 | IPE330 | 4-5/B-A | K32
PL6140*400 | 2063.04 | +0.000 | +6.140 | PL6140*400 | 4/A | Z77 | PredefinedType: REINFORCEMENT_UNIT; Tekla Assembly - Cast unit vertical position code: A-+3940; Cast unit rebar weight: 0 kg
IPEA300 | 80.4134 | +3.863 | +5.901 | IPEA300 | 4/F-E | N15
IPE400 | 16.64 | +3.999 | +5.790 | IPE400 | 4-5/B | K1
PL50*8 | 0.157 | +4.371 | +4.388 | PL50*8 | 5-6/F-E | Y3
IPEA300 | 4.9455 | +4.112 | +5.785 | IPEA300 | 6-7/B | K41
IPEA300 | 4.9455 | +4.112 | +5.785 | IPEA300 | 6-7/E | K42
IPEA300 | 4.9455 | +4.112 | +5.785 | IPEA300 | 3-4/E | K42
IPEA300 | 138.375 | +3.869 | +5.900 | IPEA300 | 4/C-B | N43
IPEA300 | 124.86 | +3.494 | +5.900 | IPEA300 | 3/C-B | N46
IPEA300 | 98.7068 | +3.864 | +5.902 | IPEA300 | 7/C-B | N13
2 x PL10*55 | 2.20193 | +5.602 | +5.612 | PL10*55 | 7/C-B | H4
PL10*150 | 6.00525 | +5.583 | +5.593 | PL10*150 | 7/C-B | H3
2 x PL10*55 | 2.20193 | +5.871 | +5.881 | PL10*55 | 7/C-B | H4
PL10*150 | 6.00525 | +5.890 | +5.900 | PL10*150 | 7/C-B | H3
2 x PL6*240 | 3.73032 | +5.622 | +5.862 | PL6*240 | 7/C-B | H8
2 x PL6*240 | 3.73032 | +3.969 | +4.209 | PL6*240 | 7/C-B | H8
PL10*150 | 6.00525 | +4.237 | +4.247 | PL10*150 | 7/C-B | H3
2 x PL10*55 | 2.20193 | +4.218 | +4.228 | PL10*55 | 7/C-B | H4
PL10*150 | 6.00525 | +3.930 | +3.940 | PL10*150 | 7/C-B | H3
2 x PL10*55 | 2.20193 | +3.949 | +3.959 | PL10*55 | 7/C-B | H4
IPEA300 | 80.7879 | +3.864 | +5.902 | IPEA300 | 7/B-A | N17
IPEA300 | 143.979 | +3.869 | +5.900 | IPEA300 | 7/C-B | N6
IPEA300 | 126.619 | +3.869 | +5.900 | IPEA300 | 7/D-C | N11
IPEA300 | 147.845 | +3.869 | +5.900 | IPEA300 | 7/D-C | N7
2 x PL6*240 | 3.73032 | +5.622 | +5.862 | PL6*240 | 7/D-C | H8
2 x PL10*55 | 2.20193 | +4.218 | +4.228 | PL10*55 | 4/D-C | H4
PL10*150 | 6.00525 | +4.237 | +4.247 | PL10*150 | 4/D-C | H3
PL10*150 | 6.00525 | +3.930 | +3.940 | PL10*150 | 4/D-C | H3
2 x PL10*55 | 2.20193 | +3.949 | +3.959 | PL10*55 | 4/D-C | H4
2 x PL6*240 | 3.73032 | +3.968 | +4.208 | PL6*240 | 4/D-C | H8
2 x PL6*240 | 3.73032 | +5.621 | +5.861 | PL6*240 | 4/D-C | H8
IPEA300 | 123.054 | +3.868 | +5.900 | IPEA300 | 4/D-C | N9
IPEA300 | 143.976 | +3.869 | +5.900 | IPEA300 | 4/D-C | N40
2 x PL10*55 | 2.20193 | +5.602 | +5.612 | PL10*55 | 4/D-C | H4
PL10*150 | 6.00525 | +5.583 | +5.593 | PL10*150 | 4/D-C | H3
2 x PL10*55 | 2.20193 | +5.871 | +5.881 | PL10*55 | 4/D-C | H4
PL10*150 | 6.00525 | +5.890 | +5.900 | PL10*150 | 4/D-C | H3
IPEA300 | 146.945 | +3.863 | +5.901 | IPEA300 | 4/E-D | N48
PL4860*250 | 25836.6 | +6.140 | +11.000 | PL4860*250 | 2-3/C-A | Z61 | PredefinedType: REINFORCEMENT_UNIT; Tekla Assembly - Cast unit vertical position code: +3940>; Cast unit rebar weight: 0 kg
PL4860*200 | 14686.4 | +6.140 | +11.000 | PL4860*200 | 3-4/C-B | Z17 | PredefinedType: REINFORCEMENT_UNIT; Tekla Assembly - Cast unit vertical position code: +3940>; Cast unit rebar weight: 0 kg
IPEA300 | 154.337 | +3.494 | +5.901 | IPEA300 | 3/E-D | N49
PL4860*200 | 25593.7 | +6.140 | +11.000 | PL4860*200 | 2-4/B-A | Z45 | PredefinedType: REINFORCEMENT_UNIT; Tekla Assembly - Cast unit vertical position code: +3940>; Cast unit rebar weight: 0 kg
PL2920*200 | 2403.74 | +0.000 | +2.920 | PL2920*200 | 3-4/B-A | Z34 | PredefinedType: REINFORCEMENT_UNIT; Tekla Assembly - Cast unit vertical position code: A-+0; Cast unit rebar weight: 0 kg
PL6140 | 5157.6 | +0.000 | +6.140 | PL6140 | 3-4/B-A | Z65 | PredefinedType: REINFORCEMENT_UNIT; Tekla Assembly - Cast unit vertical position code: A-+3940; Cast unit rebar weight: 0 kg
PL5920*200 | 15126.3 | +0.000 | +5.920 | PL5920*200 | 3-4/B-A | Z47 | PredefinedType: REINFORCEMENT_UNIT; Tekla Assembly - Cast unit vertical position code: A-+3940; Cast unit rebar weight: 0 kg
PL4500*200 | 1597.05 | -0.000 | +4.500 | PL4500*200 | 2/C-B | Z16 | PredefinedType: REINFORCEMENT_UNIT; Tekla Assembly - Cast unit vertical position code: A-+3940; Cast unit rebar weight: 0 kg
PL5680*200 | 21663.4 | -0.000 | +5.680 | PL5680*200 | 2-3/C-B | Z40 | PredefinedType: REINFORCEMENT_UNIT; Tekla Assembly - Cast unit vertical position code: A-+3940; Cast unit rebar weight: 0 kg
IPEA300 | 127.126 | +3.494 | +5.900 | IPEA300 | 3/D-C | N45
IPEA300 | 145.478 | +3.488 | +5.900 | IPEA300 | 3/D-C | N44
2 x PL6*240 | 3.73032 | +5.621 | +5.861 | PL6*240 | 3/D-C | H8
PL10*150 | 6.00525 | +5.890 | +5.900 | PL10*150 | 3/D-C | H3
2 x PL10*55 | 2.20193 | +5.871 | +5.881 | PL10*55 | 3/D-C | H4
PL10*150 | 6.00525 | +5.583 | +5.593 | PL10*150 | 3/D-C | H3
2 x PL10*55 | 2.20193 | +5.602 | +5.612 | PL10*55 | 3/D-C | H4
2 x PL10*55 | 2.20193 | +3.949 | +3.959 | PL10*55 | 3/D-C | H4
PL10*150 | 6.00525 | +3.930 | +3.940 | PL10*150 | 3/D-C | H3
2 x PL10*55 | 2.20193 | +4.218 | +4.228 | PL10*55 | 3/D-C | H4
PL10*150 | 6.00525 | +4.237 | +4.247 | PL10*150 | 3/D-C | H3
2 x PL6*240 | 3.73032 | +3.968 | +4.208 | PL6*240 | 3/D-C | H8
PL5960*200 | 28999.8 | +0.000 | +5.960 | PL5960*200 | 3-4/A | Z14 | PredefinedType: REINFORCEMENT_UNIT; Tekla Assembly - Cast unit vertical position code: A-+3940; Cast unit rebar weight: 0 kg
PL6000*180 | 105711 | +0.000 | +6.000 | PL6000*180 | 4-8/A | Z12 | PredefinedType: REINFORCEMENT_UNIT; Tekla Assembly - Cast unit vertical position code: A-+3940; Cast unit rebar weight: 0 kg
PL4450*200 | 18176 | -0.000 | +4.450 | PL4450*200 | 1-2/C-B | Z19 | PredefinedType: REINFORCEMENT_UNIT; Tekla Assembly - Cast unit vertical position code: A-+3940; Cast unit rebar weight: 0 kg
PL5680*200 | 22080.8 | -0.000 | +5.680 | PL5680*200 | -/D' | Z37 | PredefinedType: REINFORCEMENT_UNIT; Tekla Assembly - Cast unit vertical position code: >; Cast unit rebar weight: 0 kg
PL6000*200 | 27417.6 | -0.000 | +6.000 | PL6000*200 | /<-D' | Z52 | PredefinedType: REINFORCEMENT_UNIT; Tekla Assembly - Cast unit vertical position code: >; Cast unit rebar weight: 0 kg
PL6000*180 | 156946 | -0.000 | +6.000 | PL6000*180 | /<-C1> | Z1 | PredefinedType: REINFORCEMENT_UNIT; Tekla Assembly - Cast unit vertical position code: -; Cast unit rebar weight: 0 kg
PL4860*200 | 33490.8 | +6.140 | +11.000 | PL4860*200 | 4/C-A | Z49 | PredefinedType: REINFORCEMENT_UNIT; Tekla Assembly - Cast unit vertical position code: +3940>; Cast unit rebar weight: 0 kg
IPEA300 | 98.7068 | +3.864 | +5.902 | IPEA300 | 6/C-B | N13
2 x PL10*55 | 2.20193 | +5.602 | +5.612 | PL10*55 | 6/C-B | H4
PL10*150 | 6.00525 | +5.583 | +5.593 | PL10*150 | 6/C-B | H3
2 x PL10*55 | 2.20193 | +5.871 | +5.881 | PL10*55 | 6/C-B | H4
PL10*150 | 6.00525 | +5.890 | +5.900 | PL10*150 | 6/C-B | H3
2 x PL6*240 | 3.73032 | +5.622 | +5.862 | PL6*240 | 6/C-B | H8
2 x PL6*240 | 3.73032 | +3.969 | +4.209 | PL6*240 | 6/C-B | H8
PL10*150 | 6.00525 | +4.237 | +4.247 | PL10*150 | 6/C-B | H3
2 x PL10*55 | 2.20193 | +4.218 | +4.228 | PL10*55 | 6/C-B | H4
PL10*150 | 6.00525 | +3.930 | +3.940 | PL10*150 | 6/C-B | H3
2 x PL10*55 | 2.20193 | +3.949 | +3.959 | PL10*55 | 6/C-B | H4
IPEA300 | 80.9356 | +3.864 | +5.902 | IPEA300 | 6/B-A | N38
IPEA300 | 143.979 | +3.869 | +5.900 | IPEA300 | 6/C-B | N41
IPEA300 | 123.054 | +3.868 | +5.900 | IPEA300 | 6/D-C | N10
IPEA300 | 143.979 | +3.869 | +5.900 | IPEA300 | 6/D-C | N8
2 x PL6*240 | 3.73032 | +5.622 | +5.862 | PL6*240 | 6/D-C | H8
PL10*150 | 6.00525 | +5.890 | +5.900 | PL10*150 | 6/D-C | H3
2 x PL10*55 | 2.20193 | +5.871 | +5.881 | PL10*55 | 6/D-C | H4
PL10*150 | 6.00525 | +5.583 | +5.593 | PL10*150 | 6/D-C | H3
2 x PL10*55 | 2.20193 | +5.602 | +5.612 | PL10*55 | 6/D-C | H4
2 x PL10*55 | 2.20193 | +3.949 | +3.959 | PL10*55 | 6/D-C | H4
PL10*150 | 6.00525 | +3.930 | +3.940 | PL10*150 | 6/D-C | H3
2 x PL10*55 | 2.20193 | +4.218 | +4.228 | PL10*55 | 6/D-C | H4
PL10*150 | 6.00525 | +4.237 | +4.247 | PL10*150 | 6/D-C | H3
2 x PL6*240 | 3.73032 | +3.969 | +4.209 | PL6*240 | 6/D-C | H8
IPEA300 | 146.948 | +3.863 | +5.901 | IPEA300 | 6/E-D | N47
IPEA300 | 80.4134 | +3.863 | +5.901 | IPEA300 | 6/F-E | N16
PL10*150 | 6.00525 | +5.890 | +5.900 | PL10*150 | 7/D-C | H3
2 x PL10*55 | 2.20193 | +5.871 | +5.881 | PL10*55 | 7/D-C | H4
PL10*150 | 6.00525 | +5.583 | +5.593 | PL10*150 | 7/D-C | H3
2 x PL10*55 | 2.20193 | +5.602 | +5.612 | PL10*55 | 7/D-C | H4
2 x PL10*55 | 2.20193 | +3.949 | +3.959 | PL10*55 | 7/D-C | H4
PL10*150 | 6.00525 | +3.930 | +3.940 | PL10*150 | 7/D-C | H3
2 x PL10*55 | 2.20193 | +4.218 | +4.228 | PL10*55 | 7/D-C | H4
PL10*150 | 6.00525 | +4.237 | +4.247 | PL10*150 | 7/D-C | H3
2 x PL6*240 | 3.73032 | +3.969 | +4.209 | PL6*240 | 7/D-C | H8
IPEA300 | 138.412 | +3.863 | +5.901 | IPEA300 | 7/E-D | N12
IPEA300 | 76.0877 | +3.863 | +5.901 | IPEA300 | 7/F-E | N14
HEA200 | 8.46858 | -0.400 | +3.215 | HEA200 | /C' | P124
IPEA300 | 5.8864 | +3.418 | +4.036 | IPEA300 | 1-2/D-C | K84
HEA180 | 4.57686 | -0.400 | +3.928 | HEA180 | -/-D' | P131
IPEA300 | 9.43001 | +3.059 | +3.708 | IPEA300 | 2-3/E-D | K72
IPEA300 | 13.1905 | +2.859 | +3.708 | IPEA300 | 2-3/E-D | K102
IPEA300 | 2.9432 | +3.418 | +4.036 | IPEA300 | 1-2/D | K79
2 x L70*7 | 0 | +3.497 | +3.677 | L70*7 | 3/C | H35
IPEA300 | 5.8864 | +3.418 | +4.036 | IPEA300 | 1-2/D-C | K85
IPEA300 | 2.9432 | +3.418 | +4.036 | IPEA300 | 1-2/C-B | K82
IPEA300 | 12.476 | +2.859 | +3.701 | IPEA300 | 2-3/C-B | K101
IPEA300 | 5.52273 | +3.059 | +3.707 | IPEA300 | 2-3/C | K64
IPEA300 | 7.44975 | +3.059 | +3.708 | IPEA300 | 2-3/C-B | K60
2 x IPEA300 | 2.9432 | +3.418 | +4.036 | IPEA300 | 1-2/C-B | K83
IPEA300 | 12.185 | +3.059 | +3.708 | IPEA300 | 2-3/D-C | K61
IPEA300 | 2.9432 | +3.418 | +4.036 | IPEA300 | 1-2/D-C | K78
IPEA300 | 2.9432 | +3.418 | +4.036 | IPEA300 | 1-2/E-D | K74
IPEA300 | 2.9432 | +3.418 | +4.036 | IPEA300 | 1-2/D-C | K73
IPEA300 | 2.9432 | +3.418 | +4.036 | IPEA300 | 1-2/E-D | K75
IPE400 | 29.4669 | +3.640 | +4.040 | IPE400 | 1/E-D | N20
IPE400 | 21.6089 | +3.640 | +4.040 | IPE400 | 1/E-C | N19
IPE400 | 14.8024 | +3.640 | +4.040 | IPE400 | 1/D-C | N21
IPE400 | 3.92568 | +3.640 | +4.040 | IPE400 | 1/C-B | N22
HEA180 | 11.9155 | -0.400 | +3.640 | HEA180 | 1/C-B | P127
HEA180 | 6.48096 | -0.400 | +3.640 | HEA180 | /D' | P125
2 x L60*6 | 0 | -0.379 | +1.612 | L60*6 | 1/C-B | V1
2 x L60*6 | 0 | +1.628 | +3.619 | L60*6 | 1/C-B | V1
IPE500 | 2.88911 | +3.215 | +3.715 | IPE500 | 2/C-B | N1
IPE500 | 1.92608 | +3.215 | +3.715 | IPE500 | 2/D-C | N2
IPE500 | 1.92608 | +3.215 | +3.715 | IPE500 | 2/D-C | N3
IPE500 | 7.41071 | +3.215 | +3.715 | IPE500 | 2/E-D | N4
HEA180 | 6.48096 | -0.400 | +3.215 | HEA180 | 2/C-B | P128
HEA180 | 8.12946 | -0.400 | +3.215 | HEA180 | /D' | P129
UPN260 | 0 | +3.273 | +3.533 | UPN260 | /D1-C1 | N23
HEA120 | 4.75898 | +4.000 | +5.894 | HEA120 | 7'/D1-C1 | M1
2 x L70*7 | 0 | +3.579 | +3.649 | L70*7 | 1-2/D-C | C110
2 x L70*7 | 0 | +3.501 | +3.573 | L70*7 | 1-2/D-C | C110
HEA120 | 2.78706 | +3.883 | +5.830 | HEA120 | 7'-/D1 | M5
TUBE-C-80*80*3 | 0 | +3.713 | +3.817 | TUBE-C-80*80*3 | 7'-/D1-C1 | B12
TUBE-C-80*80*3 | 0 | +4.993 | +5.096 | TUBE-C-80*80*3 | 7'-/7'-D1 | B13
TUBE-C-80*80*3 | 0 | +4.996 | +5.205 | TUBE-C-80*80*3 | 7'-/<-D1 | B14
TUBE-C-80*80*3 | 0 | +4.884 | +5.090 | TUBE-C-80*80*3 | 7'-/<-D1 | B15
PL8 | 2.57354 | +4.792 | +4.814 | PL8 | 6-7/F-E | G18
PL8 | 9.10531 | +5.131 | +5.188 | PL8 | 6-7/F-E | G39
L50*5 | 0 | +4.760 | +5.143 | L50*5 | 6-7/C-B | C29
L70*7 | 0 | +4.733 | +4.804 | L70*7 | 6-7/C-B | C117
PL8 | 7.51422 | +4.795 | +4.848 | PL8 | 6-7/B | G1
PL8 | 10.1004 | +4.773 | +4.848 | PL8 | 6-7/B-A | G32
PL8 | 9.10531 | +4.418 | +4.475 | PL8 | 6-7/F-E | G39
6 x PL60*8 | 0.22608 | +4.795 | +4.810 | PL60*8 | 6-7/B-A | Y2
6 x PL60*8 | 0.22608 | +4.795 | +4.810 | PL60*8 | 6-7/F-E | Y2
PL50*8 | 0.157 | +4.905 | +4.922 | PL50*8 | 6-7/F-E | Y3
PL50*8 | 0.157 | +4.861 | +4.877 | PL50*8 | 6-7/F-E | Y3
PL50*8 | 0.157 | +4.950 | +4.967 | PL50*8 | 6-7/F-E | Y3
PL50*8 | 0.157 | +4.995 | +5.012 | PL50*8 | 6-7/F-E | Y3
PL50*8 | 0.157 | +5.040 | +5.057 | PL50*8 | 6-7/F-E | Y3
PL50*8 | 0.157 | +5.085 | +5.101 | PL50*8 | 6-7/F-E | Y3
PL50*8 | 0.157 | +4.504 | +4.521 | PL50*8 | 6-7/F-E | Y3
PL50*8 | 0.157 | +4.549 | +4.565 | PL50*8 | 6-7/F-E | Y3
PL50*8 | 0.157 | +4.594 | +4.610 | PL50*8 | 6-7/F-E | Y3
PL50*8 | 0.157 | +4.639 | +4.655 | PL50*8 | 6-7/F-E | Y3
PL50*8 | 0.157 | +4.684 | +4.700 | PL50*8 | 6-7/F-E | Y3
PL50*8 | 0.157 | +4.728 | +4.745 | PL50*8 | 6-7/F-E | Y3
PL8 | 6.82104 | +4.774 | +4.831 | PL8 | 6-7/F | G2
PL50*8 | 0.157 | +4.325 | +4.342 | PL50*8 | 6-7/F-E | Y3
PL50*8 | 0.157 | +4.371 | +4.388 | PL50*8 | 6-7/F-E | Y3
PL50*8 | 0.157 | +4.279 | +4.296 | PL50*8 | 6-7/F-E | Y3
PL50*8 | 0.157 | +4.234 | +4.250 | PL50*8 | 6-7/F-E | Y3
PL50*8 | 0.157 | +4.188 | +4.204 | PL50*8 | 6-7/F-E | Y3
PL50*8 | 0.157 | +4.142 | +4.159 | PL50*8 | 6-7/F | Y3
PL50*8 | 0.157 | +5.218 | +5.234 | PL50*8 | 6-7/F-E | Y3
PL50*8 | 0.157 | +5.264 | +5.280 | PL50*8 | 6-7/F-E | Y3
PL50*8 | 0.157 | +5.310 | +5.326 | PL50*8 | 6-7/F-E | Y3
PL50*8 | 0.157 | +5.355 | +5.372 | PL50*8 | 6-7/F-E | Y3
PL50*8 | 0.157 | +5.401 | +5.418 | PL50*8 | 6-7/F-E | Y3
PL50*8 | 0.157 | +5.447 | +5.463 | PL50*8 | 6-7/F | Y3
PL8 | 6.82104 | +4.774 | +4.831 | PL8 | 6-7/A | G3
PL8 | 4.37716 | +5.005 | +5.019 | PL8 | 7'/D1-C1 | G49
PL8 | 6.10912 | +5.065 | +5.083 | PL8 | 7-8/F-E | G24
PL8 | 7.9331 | +5.065 | +5.083 | PL8 | 7-8/E | G45
PL8 | 7.82778 | +5.065 | +5.083 | PL8 | 7-8/E-D | G44
PL8 | 1.79922 | +5.004 | +5.016 | PL8 | 7-8/F-E | G60
L50*5 | 0 | +4.963 | +5.125 | L50*5 | 7-8/F-E | C8
L50*5 | 0 | +4.963 | +5.126 | L50*5 | 7-8/F-E | C9
PL50*8 | 0.157 | +5.169 | +5.179 | PL50*8 | 7-8/F-E | Y3
PL50*8 | 0.157 | +5.149 | +5.159 | PL50*8 | 7-8/F-E | Y3
PL50*8 | 0.157 | +5.179 | +5.189 | PL50*8 | 7-8/F-E | Y3
PL50*8 | 0.157 | +5.070 | +5.121 | PL50*8 | 7-8/F | Y3
PL50*8 | 0.157 | +5.058 | +5.109 | PL50*8 | 7-8/F | Y3
PL50*8 | 0.157 | +5.046 | +5.097 | PL50*8 | 7-8/F-E | Y3
PL50*8 | 0.157 | +5.033 | +5.085 | PL50*8 | 7-8/F-E | Y3
PL50*8 | 0.157 | +5.021 | +5.073 | PL50*8 | 7-8/F-E | Y3
PL50*8 | 0.157 | +5.009 | +5.061 | PL50*8 | 7-8/F-E | Y3
PL50*8 | 0.157 | +4.997 | +5.049 | PL50*8 | 7-8/F-E | Y3
PL50*8 | 0.157 | +4.985 | +5.037 | PL50*8 | 7-8/F-E | Y3
PL50*8 | 0.157 | +4.973 | +5.024 | PL50*8 | 7-8/F-E | Y3
PL50*8 | 0.157 | +4.961 | +5.012 | PL50*8 | 7-8/F-E | Y3
PL60*8 | 0.22608 | +5.126 | +5.187 | PL60*8 | 7-8/F-E | Y2
PL60*8 | 0.22608 | +5.141 | +5.202 | PL60*8 | 7-8/F-E | Y2
PL60*8 | 0.22608 | +5.111 | +5.172 | PL60*8 | 7-8/F-E | Y2
PL60*8 | 0.22608 | +5.096 | +5.157 | PL60*8 | 7-8/F-E | Y2
PL60*8 | 0.22608 | +5.081 | +5.143 | PL60*8 | 7-8/F-E | Y2
PL60*8 | 0.22608 | +5.066 | +5.127 | PL60*8 | 7-8/F | Y2
3 x PL60*8 | 0.22608 | +5.128 | +5.138 | PL60*8 | 7-8/F-E | Y2
PL50*8 | 0.157 | +5.122 | +5.132 | PL50*8 | 7/F-E | Y3
3 x PL50*8 | 0.157 | +5.112 | +5.122 | PL50*8 | 7-8/F-E | Y3
3 x PL50*8 | 0.157 | +5.102 | +5.112 | PL50*8 | 7-8/F-E | Y3
2 x PL50*8 | 0.157 | +5.092 | +5.102 | PL50*8 | 7-8/F-E | Y3
PL50*8 | 0.157 | +5.082 | +5.092 | PL50*8 | 7-8/F-E | Y3
2 x PL50*8 | 0.157 | +5.055 | +5.066 | PL50*8 | 7-8/F-E | Y3
2 x PL50*8 | 0.157 | +5.046 | +5.056 | PL50*8 | 7-8/F-E | Y3
2 x PL50*8 | 0.157 | +5.037 | +5.047 | PL50*8 | 7-8/F-E | Y3
2 x PL50*8 | 0.157 | +5.027 | +5.037 | PL50*8 | 7-8/F-E | Y3
2 x PL50*8 | 0.157 | +5.018 | +5.028 | PL50*8 | 7-8/F-E | Y3
2 x PL50*8 | 0.157 | +5.121 | +5.131 | PL50*8 | 7/F-E | Y3
2 x PL50*8 | 0.157 | +5.083 | +5.093 | PL50*8 | 7-8/F-E | Y3
PL50*8 | 0.157 | +5.092 | +5.103 | PL50*8 | 7-8/F-E | Y3
5 x PL50*8 | 0.157 | +5.083 | +5.093 | PL50*8 | 7-8/E-D | Y3
4 x PL50*8 | 0.157 | +5.092 | +5.103 | PL50*8 | 7-8/E-D | Y3
4 x PL50*8 | 0.157 | +5.102 | +5.112 | PL50*8 | 7-8/E-D | Y3
5 x PL50*8 | 0.157 | +5.112 | +5.122 | PL50*8 | 7-8/E-D | Y3
4 x PL50*8 | 0.157 | +5.121 | +5.131 | PL50*8 | 7/E-D | Y3
2 x PL50*8 | 0.157 | +5.018 | +5.028 | PL50*8 | 7-8/E-D | Y3
2 x PL50*8 | 0.157 | +5.027 | +5.037 | PL50*8 | 7-8/E-D | Y3
2 x PL50*8 | 0.157 | +5.037 | +5.047 | PL50*8 | 7-8/E-D | Y3
PL50*8 | 0.157 | +5.046 | +5.056 | PL50*8 | 7-8/E-D | Y3
PL50*8 | 0.157 | +5.055 | +5.065 | PL50*8 | 7-8/E-D | Y3
PL50*8 | 0.157 | +5.046 | +5.056 | PL50*8 | <7'/-7' | Y3
PL50*8 | 0.157 | +5.055 | +5.065 | PL50*8 | <7'/7' | Y3
PL50*8 | 0.157 | +5.055 | +5.065 | PL50*8 | <7'/7'-D1 | Y3
PL50*8 | 0.157 | +5.046 | +5.056 | PL50*8 | <7'/D1 | Y3
PL50*8 | 0.157 | +5.037 | +5.047 | PL50*8 | <7'/D1 | Y3
PL50*8 | 0.157 | +5.027 | +5.037 | PL50*8 | <7'/D1 | Y3
PL50*8 | 0.157 | +5.037 | +5.047 | PL50*8 | <7'/D1-C1 | Y3
PL50*8 | 0.157 | +5.093 | +5.103 | PL50*8 | 7-8/E-D | Y3
PL50*8 | 0.157 | +5.102 | +5.113 | PL50*8 | 7-8/E-D | Y3
PL50*8 | 0.157 | +5.122 | +5.132 | PL50*8 | 7/D | Y3
FPL6*120 | 0.779671 | +5.509 | +5.584 | FPL6*120 | 7/D | H46
PL8 | 2.57354 | +5.005 | +5.017 | PL8 | 7'/D1-C1 | G27
PL8 | 2.02629 | +5.481 | +5.517 | PL8 | 7/D | G36
L70*7 | 0 | +5.411 | +5.496 | L70*7 | 7/D | H39
PL60*8 | 0.22608 | +5.005 | +5.015 | PL60*8 | 7'/7'-D1 | Y2
L50*5 | 0 | +5.020 | +5.180 | L50*5 | <7'/D1-C1 | C88
PL8 | 4.63098 | +5.001 | +5.031 | PL8 | 7'/D1-C1 | G5
PL50*8 | 0.157 | +5.455 | +5.472 | PL50*8 | 7/D-C | Y3
PL50*8 | 0.157 | +5.418 | +5.435 | PL50*8 | 7-8/D-C | Y3
PL50*8 | 0.157 | +5.381 | +5.397 | PL50*8 | 7-8/D-C | Y3
PL50*8 | 0.157 | +5.344 | +5.360 | PL50*8 | 7-8/D-C | Y3
2 x PL50*8 | 0.157 | +5.053 | +5.069 | PL50*8 | <7'/D1-C1 | Y3
2 x PL50*8 | 0.157 | +5.090 | +5.107 | PL50*8 | <7'/D1-C1 | Y3
2 x PL50*8 | 0.157 | +5.127 | +5.144 | PL50*8 | <7'/D1-C1 | Y3
2 x PL50*8 | 0.157 | +5.165 | +5.181 | PL50*8 | <7'/D1-C1 | Y3
2 x PL50*8 | 0.157 | +5.202 | +5.218 | PL50*8 | <7'/D1-C1 | Y3
PL50*8 | 0.157 | +5.308 | +5.324 | PL50*8 | 7-8/D-C | Y3
PL50*8 | 0.157 | +5.345 | +5.362 | PL50*8 | 7-8/D-C | Y3
PL50*8 | 0.157 | +5.383 | +5.400 | PL50*8 | 7-8/D-C | Y3
HEA180 | 0 | +5.263 | +5.403 | HEA180 | 7/D | H10
HEA180 | 0 | +5.144 | +5.284 | HEA180 | 7'/D1-C1 | H10
6 x L50*5 | 0 | +4.761 | +5.143 | L50*5 | 5-6/D-C | C25
2 x L70*7 | 0 | +4.733 | +4.804 | L70*7 | 5-6/D-C | C118
3 x PL8 | 6.37364 | +4.795 | +4.833 | PL8 | 5-6/D-C | G48
2 x PL8 | 9.76032 | +5.129 | +5.190 | PL8 | 5-6/E-D | G41
L50*5 | 0 | +4.756 | +5.141 | L50*5 | 5-6/E-D | C24
L50*5 | 0 | +5.120 | +5.502 | L50*5 | 5-6/E-D | C35
L70*7 | 0 | +4.733 | +4.804 | L70*7 | 5-6/D-C | C117
PL8 | 9.43281 | +5.129 | +5.190 | PL8 | 5-6/E | G40
PL8 | 9.10531 | +5.131 | +5.188 | PL8 | 5-6/F-E | G39
4 x L50*5 | 0 | +5.120 | +5.504 | L50*5 | 5-6/E-D | C24
4 x L50*5 | 0 | +4.763 | +5.141 | L50*5 | 5-6/E-D | C30
2 x PL8 | 6.37364 | +4.795 | +4.833 | PL8 | 5-6/E-D | G47
L70*7 | 0 | +4.733 | +4.804 | L70*7 | 5-6/E-D | C115
L70*7 | 0 | +4.733 | +4.804 | L70*7 | 5-6/E-D | C116
PL8 | 8.43791 | +4.773 | +4.832 | PL8 | 5-6/F-E | G9
PL8 | 2.57354 | +4.792 | +4.814 | PL8 | 5-6/F-E | G18
2 x L70*7 | 0 | +4.803 | +4.881 | L70*7 | 5-6/F-E | C103
2 x L70*7 | 0 | +4.733 | +4.804 | L70*7 | 5-6/F-E | C103
L70*7 | 0 | +4.733 | +4.804 | L70*7 | 5-6/B-A | C121
L70*7 | 0 | +4.733 | +4.804 | L70*7 | 5-6/F-D | C113
L50*5 | 0 | +5.176 | +5.559 | L50*5 | 5-6/F-E | C55
L50*5 | 0 | +5.118 | +5.505 | L50*5 | 5-6/F-E | C55
L50*5 | 0 | +4.819 | +5.196 | L50*5 | 5-6/F-E | C54
L50*5 | 0 | +4.762 | +5.142 | L50*5 | 5-6/F-E | C54
L50*5 | 0 | +4.046 | +4.430 | L50*5 | 5-6/F-E | C55
L50*5 | 0 | +4.100 | +4.487 | L50*5 | 5-6/F-E | C55
L50*5 | 0 | +4.409 | +4.786 | L50*5 | 5-6/F-E | C54
L50*5 | 0 | +4.463 | +4.844 | L50*5 | 5-6/F-E | C54
2 x L50*5 | 0 | +4.762 | +5.142 | L50*5 | 5-6/F-E | C23
2 x L50*5 | 0 | +5.118 | +5.505 | L50*5 | 5-6/F-E | C22
L50*5 | 0 | +4.760 | +5.143 | L50*5 | 5-6/D-C | C29
L50*5 | 0 | +4.776 | +5.484 | L50*5 | 5-6/B-A | C96
2 x L50*5 | 0 | +5.122 | +5.506 | L50*5 | 5-6/B-A | C26
2 x L50*5 | 0 | +4.765 | +5.143 | L50*5 | 5-6/B-A | C27
2 x L50*5 | 0 | +4.409 | +4.787 | L50*5 | 5-6/B-A | C27
2 x L50*5 | 0 | +4.046 | +4.430 | L50*5 | 5-6/B-A | C26
L50*5 | 0 | +4.834 | +5.562 | L50*5 | 5-6/B-A | C95
L50*5 | 0 | +4.409 | +4.786 | L50*5 | 5-6/F-E | C23
L50*5 | 0 | +4.046 | +4.430 | L50*5 | 5-6/F-E | C22
IPEA300 | 0 | +4.116 | +5.806 | IPEA300 | 5-6/A | K18
IPEA300 | 4.9455 | +4.112 | +5.785 | IPEA300 | 5-6/B | K41
IPEA300 | 4.9455 | +4.112 | +5.785 | IPEA300 | 5-6/E | K42
IPEA300 | 0 | +4.104 | +5.809 | IPEA300 | 5-6/B-A | K11
IPEA300 | 0 | +4.113 | +5.809 | IPEA300 | 5-6/B-A | K13
4 x IPEA300 | 0 | +4.104 | +5.809 | IPEA300 | 5-6/C-B | K16
3 x IPEA300 | 0 | +4.104 | +5.809 | IPEA300 | 5-6/C-B | K14
4 x IPEA300 | 0 | +4.104 | +5.809 | IPEA300 | 5-6/D-C | K16
2 x IPEA300 | 0 | +4.104 | +5.809 | IPEA300 | 5-6/D-C | K14
IPEA300 | 0 | +4.114 | +5.819 | IPEA300 | 5-6/D-C | K15
2 x IPEA300 | 0 | +4.104 | +5.809 | IPEA300 | 5-6/E-D | K16
2 x IPEA300 | 0 | +4.104 | +5.809 | IPEA300 | 5-6/E-D | K14
IPEA300 | 0 | +4.113 | +5.809 | IPEA300 | 5-6/F-E | K12
IPEA300 | 0 | +4.104 | +5.809 | IPEA300 | 5-6/F-E | K11
2 x FPL6*120 | 0.793042 | +5.509 | +5.584 | FPL6*120 | 5/C | H49
IPE450 | 142.284 | +3.767 | +5.771 | IPE450 | 5-6/C | K22
IPE450 | 142.182 | +3.767 | +5.771 | IPE450 | 5-6/D | K21
IPEA300 | 0 | +4.116 | +5.806 | IPEA300 | 5-6/F | K18
PL60*8 | 0.22608 | +1.873 | +1.952 | PL60*8 | 5-6/F | Y2
PL60*8 | 0.22608 | +0.729 | +0.808 | PL60*8 | 5-6/F | Y2
PL60*8 | 0.22608 | +1.000 | +1.080 | PL60*8 | 5-6/F | Y2
PL60*8 | 0.22608 | +1.596 | +1.676 | PL60*8 | 5-6/F | Y2
PL60*8 | 0.22608 | -0.086 | -0.007 | PL60*8 | 5-6/F | Y2
PL60*8 | 0.22608 | +1.320 | +1.400 | PL60*8 | 5-6/F | Y2
PL60*8 | 0.22608 | +1.044 | +1.123 | PL60*8 | 5-6/F | Y2
PL60*8 | 0.22608 | +0.768 | +0.847 | PL60*8 | 5-6/F | Y2
PL60*8 | 0.22608 | +0.492 | +0.571 | PL60*8 | 5-6/F | Y2
PL60*8 | 0.22608 | +0.215 | +0.295 | PL60*8 | 5-6/F | Y2
PL60*8 | 0.22608 | -0.061 | +0.019 | PL60*8 | 5-6/F | Y2
PL60*8 | 0.22608 | +3.767 | +3.842 | PL60*8 | 5-6/F | Y2
PL60*8 | 0.22608 | +3.558 | +3.633 | PL60*8 | 5-6/F | Y2
PL60*8 | 0.22608 | +3.349 | +3.424 | PL60*8 | 5-6/F | Y2
PL60*8 | 0.22608 | +3.140 | +3.216 | PL60*8 | 5-6/F | Y2
PL60*8 | 0.22608 | +2.932 | +3.007 | PL60*8 | 5-6/F | Y2
PL60*8 | 0.22608 | +2.723 | +2.798 | PL60*8 | 5-6/F | Y2
PL60*8 | 0.22608 | +2.514 | +2.590 | PL60*8 | 5-6/F | Y2
BLU300*80*5 | 2.2608 | +4.600 | +4.680 | BLU300*80*5 | 7-8/F | L4
BLU300*80*5 | 2.2608 | +4.600 | +4.680 | BLU300*80*5 | 7-8/F | L5
PL50*8 | 0.157 | +4.279 | +4.296 | PL50*8 | 4-5/F-E | Y3
PL50*8 | 0.157 | +4.234 | +4.250 | PL50*8 | 4-5/F-E | Y3
PL50*8 | 0.157 | +4.188 | +4.204 | PL50*8 | 4-5/F-E | Y3
PL50*8 | 0.157 | +4.142 | +4.159 | PL50*8 | 4-5/F | Y3
PL50*8 | 0.157 | +5.217 | +5.233 | PL50*8 | 4-5/F-E | Y3
PL50*8 | 0.157 | +5.262 | +5.279 | PL50*8 | 4-5/F-E | Y3
PL50*8 | 0.157 | +5.308 | +5.325 | PL50*8 | 4-5/F-E | Y3
PL50*8 | 0.157 | +5.354 | +5.370 | PL50*8 | 4-5/F-E | Y3
PL50*8 | 0.157 | +5.400 | +5.416 | PL50*8 | 4-5/F-E | Y3
PL50*8 | 0.157 | +5.446 | +5.462 | PL50*8 | 4-5/F | Y3
2 x FPL6*120 | 0.793042 | +5.509 | +5.584 | FPL6*120 | 4/D | H49
2 x L70*7 | 0 | +5.411 | +5.496 | L70*7 | 4/D | H39
PL8 | 2.02629 | +5.481 | +5.517 | PL8 | 4/D | G35
4 x IPEA300 | 0 | +4.104 | +5.809 | IPEA300 | 4-5/D-C | K16
3 x IPEA300 | 0 | +4.104 | +5.809 | IPEA300 | 4-5/D-C | K14
6 x L50*5 | 0 | +4.761 | +5.143 | L50*5 | 4-5/D-C | C25
6 x L50*5 | 0 | +5.122 | +5.506 | L50*5 | 4-5/D-C | C28
L50*5 | 0 | +4.760 | +5.143 | L50*5 | 4-5/D-C | C29
L70*7 | 0 | +4.733 | +4.804 | L70*7 | 4-5/D-C | C117
3 x PL8 | 6.37364 | +4.795 | +4.833 | PL8 | 4-5/D-C | G48
4 x PL8 | 9.12418 | +5.131 | +5.188 | PL8 | 4-5/D-C | G42
2 x L70*7 | 0 | +4.733 | +4.804 | L70*7 | 4-5/D-C | C118
L50*5 | 0 | +4.756 | +5.143 | L50*5 | 4-5/D-C | C29
L70*7 | 0 | +4.733 | +4.804 | L70*7 | 4-5/D-C | C119
2 x L50*5 | 0 | +5.122 | +5.503 | L50*5 | 4-5/D-C | C36
2 x PL8 | 2.02629 | +5.481 | +5.517 | PL8 | 4/C | G34
PL8 | 2.02629 | +5.481 | +5.517 | PL8 | 4/D | G34
2 x FPL6*120 | 0.793042 | +5.509 | +5.584 | FPL6*120 | 4/C | H49
2 x IPEA300 | 0 | +4.104 | +5.809 | IPEA300 | 4-5/C-B | K16
IPEA300 | 0 | +4.104 | +5.809 | IPEA300 | 4-5/C-B | K14
L50*5 | 0 | +4.762 | +5.143 | L50*5 | 4-5/C-B | C38
PL8 | 9.30651 | +5.131 | +5.188 | PL8 | 4-5/C-B | G68
L70*7 | 0 | +4.733 | +4.804 | L70*7 | 4-5/C-B | C120
2 x L50*5 | 0 | +4.761 | +5.143 | L50*5 | 4-5/C-B | C25
PL8 | 6.37364 | +4.795 | +4.833 | PL8 | 4-5/C-B | G48
PL8 | 9.12418 | +5.131 | +5.188 | PL8 | 4-5/C-B | G42
L50*5 | 0 | +4.760 | +5.143 | L50*5 | 4-5/C-B | C29
L70*7 | 0 | +4.733 | +4.804 | L70*7 | 4-5/C-B | C117
L50*5 | 0 | +5.122 | +5.503 | L50*5 | 4-5/C-B | C36
2 x L50*5 | 0 | +5.122 | +5.506 | L50*5 | 4-5/C-B | C28
IPEA300 | 6.81276 | +4.116 | +5.809 | IPEA300 | 4-5/F | K27
L50*5 | 0 | +5.122 | +5.473 | L50*5 | 4-5/C-B | C39
TUBE-C-90*90*3 | 0.348352 | +5.800 | +5.890 | TUBE-C-90*90*3 | /D1-C1 | L91
TUBE-C-90*90*3 | 0.348352 | +4.126 | +4.216 | TUBE-C-90*90*3 | /D1-C1 | L92
TUBE-C-90*90*3 | 0.348352 | +5.800 | +5.890 | TUBE-C-90*90*3 | /D1-C1> | L94
TUBE-C-90*90*3 | 0.348352 | +4.126 | +4.276 | TUBE-C-90*90*3 | /D1-C1 | L89
L70*7 | 0.35975 | +3.983 | +5.830 | L70*7 | /D1 | L11
L60*6 | 0 | +4.096 | +5.814 | L60*6 | 7'/D1 | L12
UPF-120*50*4 | 1.80299 | +5.894 | +5.950 | UPF-120*50*4 | 7'/D1-C1 | L10
UPF-120*50*4 | 1.80299 | +5.894 | +5.950 | UPF-120*50*4 | 7'/D1-C1 | L9
UPF-120*50*4 | 2.62253 | +5.894 | +5.950 | UPF-120*50*4 | 7'/D1-C1 | L8
TUBE-C-120*120*4 | 0.633778 | +5.830 | +5.950 | TUBE-C-120*120*4 | 7'-/D1 | L104
TUBE-C-70*70*3 | 0.20517 | +5.434 | +5.611 | TUBE-C-70*70*3 | 7'-/D1 | L105
TUBE-C-90*90*3 | 0.348352 | +5.740 | +5.890 | TUBE-C-90*90*3 | /<-D1 | L90
TUBE-C-90*90*3 | 0.348352 | +5.800 | +5.890 | TUBE-C-90*90*3 | 8/F-E | L93
TUBE-C-90*90*3 | 0.348352 | +5.374 | +5.524 | TUBE-C-90*90*3 | /<-D1 | L88
TUBE-C-90*90*3 | 0.348352 | +5.434 | +5.524 | TUBE-C-90*90*3 | 8/F-E | L93
2 x TUBE-C-100*100*3 | 0.434074 | +4.768 | +4.868 | TUBE-C-100*100*3 | 8/C-B | L102
2 x TUBE-C-90*90*3 | 0.348352 | +5.800 | +5.890 | TUBE-C-90*90*3 | 8/C-B | L94
TUBE-C-90*90*3 | 0.348352 | +5.800 | +5.890 | TUBE-C-90*90*3 | 8/B-A | L95
TUBE-C-100*100*3 | 0.434074 | +4.768 | +4.868 | TUBE-C-100*100*3 | 8/B-A | L103
TUBE-C-90*90*3 | 0.348352 | +5.800 | +5.890 | TUBE-C-90*90*3 | 8/D-C | L99
TUBE-C-100*100*3 | 0.434074 | +4.768 | +4.868 | TUBE-C-100*100*3 | 8/D-C | L101
TUBE-C-60*60*3 | 0.147706 | +4.730 | +4.790 | TUBE-C-60*60*3 | 3/D-C | L48
TUBE-C-60*60*3 | 0.147706 | +5.590 | +5.650 | TUBE-C-60*60*3 | 3/D-C | L48
TUBE-C-60*60*3 | 0.147706 | +4.730 | +4.790 | TUBE-C-60*60*3 | 3/D-C | L47
TUBE-C-60*60*3 | 0.147706 | +5.590 | +5.650 | TUBE-C-60*60*3 | 3/D-C | L47
2 x TUBE-C-60*60*3 | 0.147706 | +4.730 | +4.790 | TUBE-C-60*60*3 | 4/D-C | L47
2 x TUBE-C-60*60*3 | 0.147706 | +5.590 | +5.650 | TUBE-C-60*60*3 | 4/D-C | L47
2 x TUBE-C-60*60*3 | 0.147706 | +5.590 | +5.650 | TUBE-C-60*60*3 | 5/D-C | L47
TUBE-C-60*60*3 | 1.45395 | +4.417 | +5.588 | TUBE-C-60*60*3 | 5/F | L43
L60*6 | 0 | +5.374 | +5.434 | L60*6 | 8/F | H11
L60*6 | 0 | +5.740 | +5.800 | L60*6 | 8/F | H12
L60*6 | 0 | +5.369 | +5.429 | L60*6 | 8/F | H12
UPN180 | 0 | +4.902 | +5.062 | UPN180 | /D1 | H50
PL140*10 | 4.47264 | +4.871 | +5.041 | PL140*10 | 6-7/A | H6
TUBE-C-90*90*3 | 1.30429 | +4.757 | +5.890 | TUBE-C-90*90*3 | 5-6/A | L22
PL140*10 | 4.47264 | +4.871 | +5.041 | PL140*10 | 5-6/A | H6
PL60*8 | 0.22608 | +0.768 | +0.847 | PL60*8 | 5-6/A | Y2
PL60*8 | 0.22608 | +1.044 | +1.123 | PL60*8 | 5-6/A | Y2
PL60*8 | 0.22608 | +1.320 | +1.400 | PL60*8 | 5-6/A | Y2
PL60*8 | 0.22608 | +1.596 | +1.676 | PL60*8 | 5-6/A | Y2
PL60*8 | 0.22608 | +1.873 | +1.952 | PL60*8 | 5-6/A | Y2
PL60*8 | 0.22608 | +2.653 | +2.734 | PL60*8 | 5-6/A | Y2
PL60*8 | 0.22608 | +2.991 | +3.072 | PL60*8 | 5-6/A | Y2
IPE270 | 0 | +5.110 | +5.570 | IPE270 | 7-8/D-C | K96
PL60*8 | 0.22608 | +3.329 | +3.410 | PL60*8 | 5-6/A | Y2
PL60*8 | 0.22608 | +3.667 | +3.748 | PL60*8 | 5-6/A | Y2
PL60*8 | 0.22608 | +4.005 | +4.086 | PL60*8 | 5-6/A | Y2
IPE270 | 1.9782 | +5.110 | +5.529 | IPE270 | 7'-/C1> | K95
PL60*8 | 0.22608 | +4.343 | +4.424 | PL60*8 | 5-6/A | Y2
PL60*8 | 0.22608 | +4.681 | +4.762 | PL60*8 | 5-6/A | Y2
PL60*8 | 0.22608 | +5.019 | +5.100 | PL60*8 | 5-6/A | Y2
PL60*8 | 0.22608 | +1.874 | +1.953 | PL60*8 | 5-6/A | Y2
PL60*8 | 0.22608 | +1.600 | +1.679 | PL60*8 | 5-6/A | Y2
PL60*8 | 0.22608 | +1.325 | +1.405 | PL60*8 | 5-6/A | Y2
PL60*8 | 0.22608 | +1.051 | +1.131 | PL60*8 | 5-6/A | Y2
PL60*8 | 0.22608 | +0.777 | +0.857 | PL60*8 | 5-6/A | Y2
PL60*8 | 0.22608 | +0.503 | +0.582 | PL60*8 | 5-6/A | Y2
PL60*8 | 0.22608 | +0.229 | +0.308 | PL60*8 | 5-6/A | Y2
PL60*8 | 0.22608 | -0.045 | +0.034 | PL60*8 | 5-6/A | Y2
UPN180 | 0 | +2.400 | +2.470 | UPN180 | 6-7/F | L29
UPN180 | 1.34549 | -0.200 | +2.400 | UPN180 | 6-7/F | P44
L50*5 | 0 | +5.122 | +5.510 | L50*5 | 7-8/C-B | C59
24 x PL60*8 | 0.22608 | +4.795 | +4.810 | PL60*8 | 7-8/C-B | Y2
4 x L50*5 | 0 | +5.122 | +5.506 | L50*5 | 7-8/C-B | C28
4 x L50*5 | 0 | +4.761 | +5.143 | L50*5 | 7-8/C-B | C25
8 x L70*7 | 0 | +4.733 | +4.804 | L70*7 | 7-8/C-B | C108
L50*5 | 0 | +5.122 | +5.503 | L50*5 | 7-8/C-B | C60
2 x L50*5 | 0 | +4.761 | +5.143 | L50*5 | 7-8/D-C | C58
8 x L70*7 | 0 | +4.803 | +4.881 | L70*7 | 7-8/C-B | C108
2 x FPL6*120 | 0.793042 | +5.509 | +5.584 | FPL6*120 | 7/C | H49
2 x PL8 | 2.02629 | +5.481 | +5.517 | PL8 | 7/C | G34
2 x L70*7 | 0 | +5.411 | +5.496 | L70*7 | 7/C | H38
PL8 | 6.57196 | +4.795 | +4.836 | PL8 | 7-8/D-C | G31
L50*5 | 0 | +5.122 | +5.506 | L50*5 | 7-8/D-C | C57
PL8 | 9.12418 | +5.131 | +5.188 | PL8 | 7-8/D-C | G42
L50*5 | 0 | +5.122 | +5.503 | L50*5 | 7-8/D-C | C60
PL8 | 6.37364 | +4.795 | +4.833 | PL8 | 7-8/C | G48
4 x PL8 | 2.57354 | +4.792 | +4.814 | PL8 | 7-8/C-B | G18
2 x L70*7 | 0 | +4.733 | +4.804 | L70*7 | 7-8/D-C | C108
2 x L70*7 | 0 | +4.803 | +4.881 | L70*7 | 7-8/D-C | C108
9 x PL60*8 | 0.22608 | +4.795 | +4.810 | PL60*8 | 7-8/D-C | Y2
PL8 | 2.57354 | +4.792 | +4.814 | PL8 | 7-8/D-C | G18
PL8 | 5.21228 | +5.231 | +5.288 | PL8 | 7-8/D-C | G57
L70*7 | 0 | +4.803 | +4.881 | L70*7 | 7-8/D-C | C109
L70*7 | 0 | +4.733 | +4.804 | L70*7 | 7-8/D-C | C109
L50*5 | 0 | +5.176 | +5.563 | L50*5 | 7-8/D-C | C57
2 x L50*5 | 0 | +4.819 | +5.196 | L50*5 | 7-8/D-C | C58
L50*5 | 0 | +5.176 | +5.560 | L50*5 | 7-8/D-C | C60
2 x L50*5 | 0 | +5.176 | +5.563 | L50*5 | 7-8/C-B | C57
4 x L50*5 | 0 | +4.819 | +5.196 | L50*5 | 7-8/C-B | C58
L50*5 | 0 | +5.176 | +5.560 | L50*5 | 7-8/C-B | C60
PL50*8 | 0.157 | +5.446 | +5.462 | PL50*8 | 7-8/D-C | Y3
PL50*8 | 0.157 | +5.401 | +5.417 | PL50*8 | 7-8/D-C | Y3
PL50*8 | 0.157 | +5.355 | +5.372 | PL50*8 | 7-8/D-C | Y3
PL50*8 | 0.157 | +5.310 | +5.326 | PL50*8 | 7-8/D-C | Y3
PL50*8 | 0.157 | +5.264 | +5.281 | PL50*8 | 7-8/D-C | Y3
PL50*8 | 0.157 | +5.219 | +5.235 | PL50*8 | 7-8/D-C | Y3
2 x PL50*8 | 0.157 | +5.041 | +5.057 | PL50*8 | 7-8/D-C | Y3
2 x PL50*8 | 0.157 | +5.086 | +5.103 | PL50*8 | 7-8/D-C | Y3
2 x PL50*8 | 0.157 | +4.950 | +4.967 | PL50*8 | 7-8/D-C | Y3
2 x PL50*8 | 0.157 | +4.995 | +5.012 | PL50*8 | 7-8/D-C | Y3
2 x PL50*8 | 0.157 | +4.859 | +4.876 | PL50*8 | 7-8/D-C | Y3
2 x PL50*8 | 0.157 | +4.905 | +4.921 | PL50*8 | 7-8/D-C | Y3
PL50*8 | 0.157 | +5.217 | +5.234 | PL50*8 | 7-8/D-C | Y3
PL50*8 | 0.157 | +5.263 | +5.279 | PL50*8 | 7-8/D-C | Y3
PL50*8 | 0.157 | +5.308 | +5.325 | PL50*8 | 7-8/D-C | Y3
PL50*8 | 0.157 | +5.354 | +5.370 | PL50*8 | 7-8/D-C | Y3
PL50*8 | 0.157 | +5.399 | +5.415 | PL50*8 | 7-8/D-C | Y3
2 x PL50*8 | 0.157 | +5.444 | +5.461 | PL50*8 | 7-8/C | Y3
PL50*8 | 0.157 | +5.399 | +5.415 | PL50*8 | 7-8/C-B | Y3
PL50*8 | 0.157 | +5.354 | +5.370 | PL50*8 | 7-8/C-B | Y3
PL50*8 | 0.157 | +5.308 | +5.325 | PL50*8 | 7-8/C-B | Y3
PL50*8 | 0.157 | +5.263 | +5.279 | PL50*8 | 7-8/C-B | Y3
PL50*8 | 0.157 | +5.217 | +5.234 | PL50*8 | 7-8/C-B | Y3
4 x PL50*8 | 0.157 | +5.086 | +5.103 | PL50*8 | 7-8/C-B | Y3
4 x PL50*8 | 0.157 | +5.041 | +5.057 | PL50*8 | 7-8/C-B | Y3
4 x PL50*8 | 0.157 | +4.995 | +5.012 | PL50*8 | 7-8/C-B | Y3
4 x PL50*8 | 0.157 | +4.950 | +4.967 | PL50*8 | 7-8/C-B | Y3
4 x PL50*8 | 0.157 | +4.905 | +4.921 | PL50*8 | 7-8/C-B | Y3
4 x PL50*8 | 0.157 | +4.859 | +4.876 | PL50*8 | 7-8/C-B | Y3
2 x PL50*8 | 0.157 | +5.446 | +5.462 | PL50*8 | 7-8/C-B | Y3
2 x PL50*8 | 0.157 | +5.401 | +5.417 | PL50*8 | 7-8/C-B | Y3
2 x PL50*8 | 0.157 | +5.355 | +5.372 | PL50*8 | 7-8/C-B | Y3
2 x PL50*8 | 0.157 | +5.310 | +5.326 | PL50*8 | 7-8/C-B | Y3
2 x PL50*8 | 0.157 | +5.264 | +5.281 | PL50*8 | 7-8/C-B | Y3
2 x PL50*8 | 0.157 | +5.219 | +5.235 | PL50*8 | 7-8/C-B | Y3
UPN180 | 3.56311 | -0.060 | +2.400 | UPN180 | 6-7/A | P47
UPN180 | 0 | +2.400 | +2.470 | UPN180 | 6-7/A | L30
L50*5 | 0 | +5.176 | +5.567 | L50*5 | 7-8/C-B | C59
PL50*8 | 0.157 | +5.448 | +5.464 | PL50*8 | 7-8/B | Y3
PL50*8 | 0.157 | +5.402 | +5.419 | PL50*8 | 7-8/C-B | Y3
PL50*8 | 0.157 | +5.221 | +5.237 | PL50*8 | 7-8/C-B | Y3
PL50*8 | 0.157 | +5.266 | +5.283 | PL50*8 | 7-8/C-B | Y3
PL50*8 | 0.157 | +5.312 | +5.328 | PL50*8 | 7-8/C-B | Y3
PL50*8 | 0.157 | +5.357 | +5.373 | PL50*8 | 7-8/C-B | Y3
2 x UPF-100*50*4 | 0 | +5.850 | +5.950 | UPF-100*50*4 | 7-8/F-E | S14
UPF-100*50*4 | 0 | +5.850 | +5.950 | UPF-100*50*4 | 7-8/F | S15
UPF-100*50*4 | 6.83783 | +5.844 | +5.950 | UPF-100*50*4 | 7-8/D-C | S28
UPF-100*50*4 | 6.83783 | +5.844 | +5.950 | UPF-100*50*4 | <7'-/C1 | S11
2 x UPF-100*50*4 | 6.83783 | +5.844 | +5.950 | UPF-100*50*4 | <7'/D1-C1 | S37
PL2*340 | 1.25977 | +5.512 | +5.518 | PL2*340 | 7'-/C1> | Y7
L70*7 | 0 | +4.709 | +4.880 | L70*7 | 7-8/F-E | C102
L70*7 | 0 | +4.787 | +4.957 | L70*7 | 7-8/F-E | C102
HEA100 | 0 | +5.248 | +5.347 | HEA100 | 7-8/F-E | N50
HEA100 | 0 | +5.325 | +5.424 | HEA100 | 7-8/F-E | N50
HEA100 | 0 | +5.171 | +5.270 | HEA100 | 7-8/F-E | N50
HEA100 | 0 | +5.094 | +5.194 | HEA100 | 7-8/F-E | N50
HEA100 | 0 | +5.018 | +5.117 | HEA100 | 7-8/F-E | N50
2 x PL8 | 2.89787 | +3.744 | +3.758 | PL8 | 7'/D1-C1 | G64
PL8 | 11.9341 | +3.625 | +3.655 | PL8 | 7'-/D1-C1 | G66
PL1385 | 41874.6 | +4.480 | +5.865 | PL1385 | 7'-/D1-C1 | Z64
UPN260 | 0 | +4.854 | +5.114 | UPN260 | /D1-C1> | N31
TUBE-C-100*100*3 | 0 | +3.845 | +5.114 | TUBE-C-100*100*3 | 8/D-C | M12
2 x L40*4 | 0 | +3.987 | +4.969 | L40*4 | 8/D-C | C135
L70*7 | 0 | +5.186 | +5.264 | L70*7 | 7-8/D-C | C109
TUBE-C-100*100*3 | 7.80298 | +5.344 | +5.850 | TUBE-C-100*100*3 | 7-8/E | P71
L70*7 | 0 | +5.167 | +5.245 | L70*7 | 7-8/D-C | C107
TUBE-C-100*100*3 | 7.80298 | +5.344 | +5.850 | TUBE-C-100*100*3 | 7-8/E-D | P71
L70*7 | 0 | +5.244 | +5.315 | L70*7 | 7-8/D-C | C107
PL8 | 4.40188 | +5.223 | +5.270 | PL8 | <7'/D1-C1 | G12
TUBE-C-100*100*3 | 7.80298 | +5.267 | +5.850 | TUBE-C-100*100*3 | 7-8/E | P70
PL8 | 2.45814 | +5.371 | +5.405 | PL8 | 7-8/D-C | G51
PL8 | 2.45814 | +5.373 | +5.407 | PL8 | 7-8/D-C | G50
L60*6 | 0 | +5.850 | +5.910 | L60*6 | 7-8/E | H20
UPF-100*50*4 | 0 | +5.850 | +5.950 | UPF-100*50*4 | 7-8/E-D | S21
PL8 | 2.55846 | +5.365 | +5.401 | PL8 | 7-8/D-C | G52
UPF-100*50*4 | 0 | +5.850 | +5.950 | UPF-100*50*4 | 7-8/E | S14
PL8 | 2.43946 | +5.013 | +5.054 | PL8 | 7-8/D-C | G53
PL8 | 2.56961 | +5.362 | +5.399 | PL8 | 7-8/D-C | G54
TUBE-C-100*100*3 | 7.80298 | +5.191 | +5.850 | TUBE-C-100*100*3 | 7-8/E | P69
TUBE-C-100*100*3 | 7.80298 | +5.267 | +5.850 | TUBE-C-100*100*3 | 7-8/E-D | P70
PL8 | 2.50236 | +5.110 | +5.144 | PL8 | <7'/C1 | G55
UPF-100*50*4 | 0 | +5.850 | +5.950 | UPF-100*50*4 | 7-8/E | S21
TUBE-C-100*100*3 | 7.8018 | +5.421 | +5.850 | TUBE-C-100*100*3 | 7-8/E | P73
TUBE-C-100*100*3 | 7.80298 | +5.191 | +5.850 | TUBE-C-100*100*3 | 7-8/E-D | P69
UPF-100*50*4 | 0 | +5.850 | +5.950 | UPF-100*50*4 | 7-8/E-D | S14
TUBE-C-100*100*3 | 7.80298 | +5.114 | +5.850 | TUBE-C-100*100*3 | 7-8/E-D | P68
11 x L60*6 | 0 | +5.754 | +5.946 | L60*6 | 7-8/E-D | H25
2 x L60*6 | 0 | +5.854 | +5.946 | L60*6 | 7-8/E-D | H26
2 x L60*6 | 0 | +5.754 | +5.946 | L60*6 | 7-8/E-D | H21
TUBE-C-100*100*3 | 7.18432 | +5.114 | +5.750 | TUBE-C-100*100*3 | 7'-/7'-D1 | P82
TUBE-C-100*100*3 | 7.18432 | +5.267 | +5.750 | TUBE-C-100*100*3 | 7'-/7'-D1 | P80
UPF-100*50*4 | 0 | +5.750 | +5.850 | UPF-100*50*4 | 7-8/E-D | S19
UPF-100*50*4 | 0 | +5.850 | +5.950 | UPF-100*50*4 | <7'/D1-C1 | S25
2 x PL2*340 | 1.44126 | +5.340 | +5.353 | PL2*340 | <7'/D1-C1 | Y6
2 x TUBE-C-100*100*3 | 7.80298 | +5.344 | +5.850 | TUBE-C-100*100*3 | <7'/D1-C1 | P71
L60*6 | 0 | +5.754 | +5.946 | L60*6 | <7'/D1 | H25
UPF-100*50*4 | 0 | +5.750 | +5.850 | UPF-100*50*4 | <7'/D1-C1 | S23
PL2*340 | 1.25977 | +5.342 | +5.351 | PL2*340 | <7'/D1-C1 | Y7
UPF-100*50*4 | 0 | +5.750 | +5.850 | UPF-100*50*4 | <7'/7'-C1 | S18
L60*6 | 0 | +5.754 | +5.946 | L60*6 | <7'/D1 | H27
L60*6 | 0 | +5.854 | +5.946 | L60*6 | 7'-/D1 | H26
UPF-100*50*4 | 0 | +5.850 | +5.950 | UPF-100*50*4 | <7'-/D1 | S35
HEA100 | 0 | +5.325 | +5.424 | HEA100 | 7-8/E-D | N51
TUBE-C-100*100*3 | 6.71458 | +5.346 | +5.750 | TUBE-C-100*100*3 | <7'/D1-C1 | P87
UPF-100*50*4 | 0 | +5.750 | +5.850 | UPF-100*50*4 | <7'/D1-C1 | S19
HEA100 | 0 | +5.248 | +5.347 | HEA100 | <7'/D1-C1 | N51
PL2*340 | 1.25977 | +5.395 | +5.426 | PL2*340 | <7'/C1> | Y7
PL2*340 | 1.25977 | +5.419 | +5.428 | PL2*340 | 7-8/E-D | Y7
TUBE-C-100*100*3 | 5.52766 | +5.422 | +5.810 | TUBE-C-100*100*3 | 7-8/E-D | P102
L60*6 | 0 | +5.754 | +5.946 | L60*6 | 7-8/D | H25
PL2*340 | 1.25977 | +5.395 | +5.426 | PL2*340 | <7'/D1-C1 | Y7
TUBE-C-100*100*3 | 5.52766 | +5.405 | +5.810 | TUBE-C-100*100*3 | <7'/D1-C1 | P103
2 x TUBE-C-100*100*3 | 5.9974 | +5.514 | +5.910 | TUBE-C-100*100*3 | 7-8/D-C | P97
HEA100 | 0 | +5.417 | +5.515 | HEA100 | 7'-/C1> | N54
PL2*340 | 1.25977 | +5.512 | +5.518 | PL2*340 | 7-8/D-C | Y7
PL2*340 | 1.44126 | +5.511 | +5.519 | PL2*340 | 7'-/C1> | Y6
TUBE-C-100*100*3 | 5.9974 | +5.514 | +5.910 | TUBE-C-100*100*3 | 7'-/C1> | P97
TUBE-C-100*100*3 | 5.52765 | +5.515 | +5.910 | TUBE-C-100*100*3 | 7'-/C1> | P104
HEA100 | 0 | +5.417 | +5.515 | HEA100 | 7-8/D-C | N54
TUBE-C-100*100*3 | 5.52765 | +5.515 | +5.910 | TUBE-C-100*100*3 | 7-8/D-C | P104
PL180 | 48125.1 | +5.308 | +5.998 | PL180 | <7'/D1-C1> | Z11
PL180 | 15103.1 | +5.548 | +5.998 | PL180 | 7-8/D-C | Z10
PL180 | 619072 | +4.393 | +5.998 | PL180 | 7-8/D-A | Z9
PL180 | 225949 | +5.078 | +5.620 | PL180 | <7'-/<-D1 | Z8
PL180 | 34657.8 | +5.310 | +5.620 | PL180 | <7'/D1-C1 | Z7
PL180 | 131937 | +3.770 | +4.180 | PL180 | 7'-/D1-C1 | Z6
PL180 | 73455.8 | +5.383 | +5.756 | PL180 | <7'-/C1> | Z5
2 x TUBE-C-60*60*3 | 0.147706 | +4.730 | +4.790 | TUBE-C-60*60*3 | 6/D-C | L47
2 x TUBE-C-60*60*3 | 0.147706 | +5.590 | +5.650 | TUBE-C-60*60*3 | 6/D-C | L47
2 x TUBE-C-60*60*3 | 0.147706 | +4.730 | +4.790 | TUBE-C-60*60*3 | 5/D-C | L47
UPN140 | 0 | +5.710 | +5.850 | UPN140 | 7'/D1-C1> | S86
2 x L60*6 | 0 | +5.754 | +5.946 | L60*6 | 7-8/D-C | H27
UPN100 | 0 | +5.750 | +5.850 | UPN100 | <7'/C1> | S85
2 x L60*6 | 0 | +5.720 | +5.946 | L60*6 | 7'/D1-C1 | H23
L60*6 | 0 | +5.720 | +5.946 | L60*6 | 7'/C1> | H29
L60*6 | 0 | +5.754 | +5.946 | L60*6 | <7'/C1> | H25
6 x L60*6 | 0 | +5.754 | +5.946 | L60*6 | 7-8/D-C | H25
2 x L60*6 | 0 | +5.754 | +5.946 | L60*6 | 7'-/C1> | H25
8 x L60*6 | 0 | +5.854 | +5.946 | L60*6 | 7-8/D-C | H26
4 x L60*6 | 0 | +5.854 | +5.946 | L60*6 | 7'-/C1> | H26
PL2*340 | 1.25977 | +5.395 | +5.426 | PL2*340 | 7-8/D-C | Y7
TUBE-C-100*100*3 | 5.52766 | +5.405 | +5.810 | TUBE-C-100*100*3 | 7-8/D-C | P103
PL2*340 | 1.25977 | +5.404 | +5.411 | PL2*340 | 7'-/C1> | Y7
HEA100 | 0 | +5.308 | +5.416 | HEA100 | 7-8/D-C | N55
PL2*340 | 1.25977 | +5.458 | +5.464 | PL2*340 | 7'-/C1> | Y7
HEA140 | 0 | +3.704 | +3.841 | HEA140 | 7'-/D1-C1 | N32
HEA140 | 0 | +3.675 | +3.812 | HEA140 | 7'-/D1-C1 | N33
HEA140 | 0 | +3.802 | +3.940 | HEA140 | 7'-/D1-C1 | N35
HEA140 | 0 | +3.741 | +3.878 | HEA140 | 7'-/D1-C1 | N35
HEA140 | 0 | +3.675 | +3.812 | HEA140 | 7'-/D1-C1 | N32
HEA140 | 0 | +3.704 | +3.841 | HEA140 | 7'-/D1-C1 | N33
HEA140 | 0 | +3.802 | +3.940 | HEA140 | 7'-/D1-C1 | N34
HEA140 | 0 | +3.741 | +3.878 | HEA140 | 7'-/D1-C1 | N34
IPEA300 | 10.5911 | +3.023 | +3.328 | IPEA300 | 5/8-F | K20
TUBE-C-90*90*3 | 1.76135 | +5.738 | +5.980 | TUBE-C-90*90*3 | 4-5/A | L106
TUBE-C-90*90*3 | 1.30429 | +4.757 | +5.890 | TUBE-C-90*90*3 | 4-5/A | L22
TUBE-C-60*60*3 | 1.45395 | +4.417 | +5.588 | TUBE-C-60*60*3 | 5/A | L45
2 x FPL6*50 | 0.393167 | +5.330 | +5.387 | FPL6*50 | 7-8/D-C | H47
2 x FPL6*50 | 0.393167 | +5.338 | +5.395 | FPL6*50 | 7-8/D-C | H47
FPL6*50 | 0.393167 | +5.338 | +5.395 | FPL6*50 | <7'/C1> | H47
FPL6*50 | 0.393167 | +5.330 | +5.387 | FPL6*50 | <7'/C1> | H47
3 x FPL6*50 | 0.393167 | +5.338 | +5.395 | FPL6*50 | <7'/D1-C1 | H47
3 x FPL6*50 | 0.393167 | +5.330 | +5.387 | FPL6*50 | <7'/D1-C1 | H47
FPL6*50 | 0.393167 | +5.347 | +5.399 | FPL6*50 | 7-8/D | H47
FPL6*50 | 0.393167 | +5.349 | +5.401 | FPL6*50 | 7-8/D | H47
FPL6*50 | 0.393167 | +5.349 | +5.401 | FPL6*50 | 7-8/E-D | H47
FPL6*50 | 0.393167 | +5.347 | +5.399 | FPL6*50 | 7-8/E-D | H47
2 x FPL6*50 | 0.393167 | +5.271 | +5.322 | FPL6*50 | <7'/D1-C1 | H47
2 x FPL6*50 | 0.393167 | +5.273 | +5.324 | FPL6*50 | <7'/D1-C1 | H47
FPL6*50 | 0.393167 | +5.349 | +5.401 | FPL6*50 | 7-8/F | H47
FPL6*50 | 0.393167 | +5.347 | +5.399 | FPL6*50 | 7-8/F | H47
FPL6*50 | 0.393167 | +5.347 | +5.399 | FPL6*50 | 7-8/F-E | H47
FPL6*50 | 0.393167 | +5.349 | +5.401 | FPL6*50 | 7-8/F-E | H47
FPL6*50 | 0.393167 | +5.271 | +5.322 | FPL6*50 | 7-8/F-E | H47
FPL6*50 | 0.393167 | +5.273 | +5.324 | FPL6*50 | 7-8/F-E | H47
FPL6*50 | 0.393167 | +5.271 | +5.322 | FPL6*50 | 7-8/F | H47
FPL6*50 | 0.393167 | +5.273 | +5.324 | FPL6*50 | 7-8/F | H47
FPL6*50 | 0.393167 | +5.194 | +5.246 | FPL6*50 | 7-8/F-E | H47
FPL6*50 | 0.393167 | +5.196 | +5.248 | FPL6*50 | 7-8/F-E | H47
FPL6*50 | 0.393167 | +5.194 | +5.246 | FPL6*50 | 7-8/F | H47
FPL6*50 | 0.393167 | +5.196 | +5.248 | FPL6*50 | 7-8/F | H47
FPL6*50 | 0.393167 | +5.117 | +5.169 | FPL6*50 | 7-8/F-E | H47
FPL6*50 | 0.393167 | +5.119 | +5.171 | FPL6*50 | 7-8/F-E | H47
FPL6*50 | 0.393167 | +5.117 | +5.169 | FPL6*50 | 7-8/F | H47
FPL6*50 | 0.393167 | +5.119 | +5.171 | FPL6*50 | 7-8/F | H47
FPL6*50 | 0.393167 | +5.040 | +5.092 | FPL6*50 | 7-8/F-E | H47
FPL6*50 | 0.393167 | +5.042 | +5.094 | FPL6*50 | 7-8/F-E | H47
FPL6*50 | 0.393167 | +5.040 | +5.092 | FPL6*50 | 7-8/F | H47
FPL6*50 | 0.393167 | +5.042 | +5.094 | FPL6*50 | 7-8/F | H47
2 x FPL6*50 | 0.393167 | +5.440 | +5.491 | FPL6*50 | 7-8/D-C | H47
2 x FPL6*50 | 0.393167 | +5.441 | +5.492 | FPL6*50 | 7-8/D-C | H47
2 x FPL6*50 | 0.393167 | +5.386 | +5.437 | FPL6*50 | 7-8/D-C | H47
2 x FPL6*50 | 0.393167 | +5.387 | +5.438 | FPL6*50 | 7-8/D-C | H47
2 x FPL6*50 | 0.393167 | +5.332 | +5.383 | FPL6*50 | 7-8/D-C | H47
2 x FPL6*50 | 0.393167 | +5.333 | +5.385 | FPL6*50 | 7-8/D-C | H47
2 x FPL6*50 | 0.393167 | +5.441 | +5.492 | FPL6*50 | 7'-/C1> | H47
2 x FPL6*50 | 0.393167 | +5.440 | +5.491 | FPL6*50 | 7'-/C1> | H47
2 x FPL6*50 | 0.393167 | +5.386 | +5.437 | FPL6*50 | 7'-/C1> | H47
2 x FPL6*50 | 0.393167 | +5.387 | +5.438 | FPL6*50 | 7'-/C1> | H47
2 x FPL6*50 | 0.393167 | +5.332 | +5.383 | FPL6*50 | 7'-/C1> | H47
2 x FPL6*50 | 0.393167 | +5.333 | +5.385 | FPL6*50 | 7'-/C1> | H47
FPL6*90 | 0.707701 | +3.762 | +3.854 | FPL6*90 | 7'-/C1 | H45
FPL6*90 | 0.707701 | +3.764 | +3.856 | FPL6*90 | 7'-/C1 | H45
3 x FPL6*90 | 0.707701 | +3.762 | +3.854 | FPL6*90 | 7'-/D1-C1 | H45
3 x FPL6*90 | 0.707701 | +3.764 | +3.856 | FPL6*90 | 7'-/D1-C1 | H45
3 x FPL6*90 | 0.707701 | +3.826 | +3.918 | FPL6*90 | 7'-/D1-C1 | H45
3 x FPL6*90 | 0.707701 | +3.824 | +3.916 | FPL6*90 | 7'-/D1-C1 | H45
FPL6*90 | 0.707701 | +3.826 | +3.918 | FPL6*90 | 7'-/C1 | H45
FPL6*90 | 0.707701 | +3.824 | +3.916 | FPL6*90 | 7'-/C1 | H45
4 x FPL6*90 | 0.707701 | +3.728 | +3.820 | FPL6*90 | 7'-/D1-C1 | H45
4 x FPL6*90 | 0.707701 | +3.726 | +3.818 | FPL6*90 | 7'-/D1-C1 | H45
4 x FPL6*90 | 0.707701 | +3.697 | +3.788 | FPL6*90 | 7'-/D1-C1 | H45
4 x FPL6*90 | 0.707701 | +3.699 | +3.791 | FPL6*90 | 7'-/D1-C1 | H45
PL8 | 9.733 | +4.876 | +4.905 | PL8 | 7-8/F-E | G38
L80*8 | 0 | +4.046 | +4.126 | L80*8 | /C1 | H58
UPF-100*50*4 | 1.35648 | +4.330 | +4.484 | UPF-100*50*4 | 7-8/D-C | U4
UPF-100*50*4 | 1.35648 | +4.986 | +5.104 | UPF-100*50*4 | 7-8/F-E | U2
UPF-100*50*4 | 1.35648 | +4.322 | +4.477 | UPF-100*50*4 | 6-7/C-B | U3
UPF-100*50*4 | 1.35648 | +4.330 | +4.484 | UPF-100*50*4 | 7-8/C-B | U4
UPF-100*50*4 | 1.35648 | +4.322 | +4.477 | UPF-100*50*4 | 5-6/C-B | U4
UPF-100*50*4 | 1.35648 | +4.322 | +4.477 | UPF-100*50*4 | 6-7/C-B | U4
UPF-100*50*4 | 1.35648 | +4.322 | +4.477 | UPF-100*50*4 | 5-6/C-B | U3
UPF-100*50*4 | 1.35648 | +4.322 | +4.477 | UPF-100*50*4 | 5-6/D-C | U3
UPF-100*50*4 | 1.35648 | +4.322 | +4.477 | UPF-100*50*4 | 6-7/F-E | U2
UPF-100*50*4 | 1.35648 | +4.322 | +4.477 | UPF-100*50*4 | 6-7/D-C | U3
UPF-100*50*4 | 1.35648 | +4.322 | +4.477 | UPF-100*50*4 | 5-6/F-E | U2
PL4860*250 | 11943 | +6.140 | +11.000 | PL4860*250 | 2-4/C-B | Z60 | PredefinedType: REINFORCEMENT_UNIT; Tekla Assembly - Cast unit vertical position code: +3940>; Cast unit rebar weight: 0 kg
HEA180 | 6.48096 | -0.400 | +3.640 | HEA180 | 1/E-D | P125
PL4500*200 | 1423.59 | -0.000 | +4.500 | PL4500*200 | /-D' | Z39 | PredefinedType: REINFORCEMENT_UNIT; Tekla Assembly - Cast unit vertical position code: >; Cast unit rebar weight: 0 kg
TUBE-C-90*90*3 | 0.348352 | +5.890 | +5.980 | TUBE-C-90*90*3 | 5-6/A | L98
PL2900*150 | 844.987 | -0.000 | +2.900 | PL2900*150 | -/-D' | Z67 | PredefinedType: REINFORCEMENT_UNIT; Tekla Assembly - Cast unit vertical position code: >; Cast unit rebar weight: 0 kg
2 x PL2900*150 | 1242.36 | -0.000 | +2.900 | PL2900*150 | -/-D' | Z68 | PredefinedType: REINFORCEMENT_UNIT; Tekla Assembly - Cast unit vertical position code: >; Cast unit rebar weight: 0 kg
PL2900*150 | 794.745 | -0.000 | +2.900 | PL2900*150 | -/D' | Z69 | PredefinedType: REINFORCEMENT_UNIT; Tekla Assembly - Cast unit vertical position code: >; Cast unit rebar weight: 0 kg
PL2900*150 | 1242.36 | -0.000 | +2.900 | PL2900*150 | /-D' | Z68 | PredefinedType: REINFORCEMENT_UNIT; Tekla Assembly - Cast unit vertical position code: >; Cast unit rebar weight: 0 kg
PL2900*150 | 959.175 | -0.000 | +2.900 | PL2900*150 | -/D' | Z70 | PredefinedType: REINFORCEMENT_UNIT; Tekla Assembly - Cast unit vertical position code: >; Cast unit rebar weight: 0 kg
PL2900*150 | 400.484 | -0.000 | +2.900 | PL2900*150 | -/D' | Z71 | PredefinedType: REINFORCEMENT_UNIT; Tekla Assembly - Cast unit vertical position code: >; Cast unit rebar weight: 0 kg
PL2900*150 | 959.175 | -0.000 | +2.900 | PL2900*150 | -/-D' | Z70 | PredefinedType: REINFORCEMENT_UNIT; Tekla Assembly - Cast unit vertical position code: >; Cast unit rebar weight: 0 kg
TUBE-C-90*90*3 | 1.30429 | +4.757 | +5.890 | TUBE-C-90*90*3 | 6-7/A | L22
TUBE-C-90*90*3 | 0.348352 | +5.890 | +5.980 | TUBE-C-90*90*3 | 6-7/A | L98
IPE270 | 0 | +5.110 | +5.570 | IPE270 | 7-8/D-C | K97
PL4340*200 | 29916.1 | -0.000 | +4.340 | PL4340*200 | /C'> | Z38 | PredefinedType: REINFORCEMENT_UNIT; Tekla Assembly - Cast unit vertical position code: >; Cast unit rebar weight: 0 kg
PL6000*200 | 4842.12 | -0.000 | +4.053 | PL6000*200 | 1-2/D-C | Z57 | PredefinedType: REINFORCEMENT_UNIT; Tekla Assembly - Cast unit vertical position code: A-+0; Cast unit rebar weight: 0 kg
PL6000*200 | 17196.8 | -0.000 | +3.960 | PL6000*200 | 1-2/D-B | Z56 | PredefinedType: REINFORCEMENT_UNIT; Tekla Assembly - Cast unit vertical position code: A-+0; Cast unit rebar weight: 0 kg
PL6000*200 | 4501.92 | -0.000 | +4.046 | PL6000*200 | 1-2/C-B | Z55 | PredefinedType: REINFORCEMENT_UNIT; Tekla Assembly - Cast unit vertical position code: A-+0; Cast unit rebar weight: 0 kg
PL3920*200 | 12841.9 | -0.000 | +3.920 | PL3920*200 | 7-8/F-E | Z21 | PredefinedType: REINFORCEMENT_UNIT; Tekla Assembly - Cast unit vertical position code: A-+0; Cast unit rebar weight: 0 kg
PL1760*400 | 5144.83 | +4.200 | +5.960 | PL1760*400 | 3-4/B | Z80 | PredefinedType: REINFORCEMENT_UNIT; Tekla Assembly - Cast unit vertical position code: +0-+3940; Cast unit rebar weight: 0 kg
UPN160 | 1.41696 | +7.565 | +7.725 | UPN160 | 4/B-A | S93
UPN160 | 1.41696 | +7.565 | +7.725 | UPN160 | 3-4/A | S89
UPN160 | 1.41696 | +7.565 | +7.725 | UPN160 | 3-4/B-A | S90
IPE220 | 0 | +7.505 | +7.725 | IPE220 | 3-4/B-A | S96
UPN160 | 2.83393 | +7.205 | +7.365 | UPN160 | 2-4/A | S91
UPN160 | 2.83393 | +7.205 | +7.365 | UPN160 | 2-4/B-A | S92
UPN160 | 1.41696 | +7.205 | +7.365 | UPN160 | 2-3/B-A | S94
2 x PL4500*200 | 137150 | +4.500 | +9.000 | PL4500*200 | 2-3/8-A> | Z54 | PredefinedType: REINFORCEMENT_UNIT; Tekla Assembly - Cast unit vertical position code: +0-+3940>; Cast unit rebar weight: 0 kg
HEA180 | 4.57686 | -0.400 | +3.640 | HEA180 | -/-D' | P130
PL9000*200 | 274301 | +4.500 | +4.700 | PL9000*200 | 2-3/8-A> | Z53 | PredefinedType: REINFORCEMENT_UNIT; Tekla Assembly - Cast unit vertical position code: +0-+3940; Cast unit rebar weight: 0 kg
4 x PL2*340 | 1.44126 | +3.742 | +3.756 | PL2*340 | 1-2/E-D | Y6
TUBE-C-100*100*3 | 7.18432 | +3.746 | +4.265 | TUBE-C-100*100*3 | 1-2/E-D | P79
TUBE-C-100*100*3 | 5.9974 | +4.018 | +4.325 | TUBE-C-100*100*3 | 1-2/E-D | P94
3 x UPF-100*50*4 | 0 | +4.365 | +4.465 | UPF-100*50*4 | 1-3/E-D | S75
UPF-100*50*4 | 0 | +4.365 | +4.465 | UPF-100*50*4 | 1-2/E-D | S40
3 x PL2*340 | 1.44126 | +4.020 | +4.034 | PL2*340 | 1-2/E-D | Y6
3 x TUBE-C-100*100*3 | 5.9974 | +4.024 | +4.425 | TUBE-C-100*100*3 | 1/E-D | P96
3 x TUBE-C-100*100*3 | 7.80298 | +3.746 | +4.365 | TUBE-C-100*100*3 | 1-2/E-D | P67
2 x UPF-100*50*4 | 0 | +4.365 | +4.465 | UPF-100*50*4 | 1-2/E-D | S52
UPF-100*50*4 | 0 | +4.265 | +4.425 | UPF-100*50*4 | 2-3/C-B | S65
3 x TUBE-C-100*100*3 | 7.80298 | +3.839 | +4.365 | TUBE-C-100*100*3 | 1-2/E-D | P66
TUBE-C-100*100*3 | 7.18432 | +3.839 | +4.265 | TUBE-C-100*100*3 | 1-2/E-D | P78
3 x L60*6 | 0 | +4.365 | +4.425 | L60*6 | 1-2/E-D | H20
4 x PL2*340 | 1.44126 | +3.835 | +3.849 | PL2*340 | 1-2/E-D | Y6
TUBE-C-100*100*3 | 7.80298 | +3.746 | +4.365 | TUBE-C-100*100*3 | 1-2/D | P67
7 x UPF-100*50*4 | 0 | +4.365 | +4.465 | UPF-100*50*4 | 1-3/D-C | S75
7 x TUBE-C-100*100*3 | 7.80298 | +3.839 | +4.365 | TUBE-C-100*100*3 | 1-2/D-C | P66
PL2*340 | 1.44126 | +3.742 | +3.756 | PL2*340 | 1-2/D | Y6
PL2*340 | 1.44126 | +3.835 | +3.849 | PL2*340 | 1-2/D | Y6
UPF-100*50*4 | 0 | +4.365 | +4.465 | UPF-100*50*4 | 1-2/E-D | S53
TUBE-C-100*100*3 | 5.9974 | +4.024 | +4.425 | TUBE-C-100*100*3 | 1/C | P96
UPF-100*50*4 | 0 | +4.265 | +4.425 | UPF-100*50*4 | 2-3/C-B | S44
7 x L60*6 | 0 | +4.365 | +4.425 | L60*6 | 1-2/D-C | H20
7 x PL2*340 | 1.44126 | +3.835 | +3.849 | PL2*340 | 1-2/D-C | Y6
L60*6 | 0 | +4.365 | +4.425 | L60*6 | 1-2/D | H20
TUBE-C-100*100*3 | 7.80298 | +3.839 | +4.365 | TUBE-C-100*100*3 | 1-2/D | P66
UPF-100*50*4 | 0 | +4.365 | +4.465 | UPF-100*50*4 | 1-3/D | S75
UPF-100*50*4 | 0 | +4.365 | +4.465 | UPF-100*50*4 | 1-2/D | S53
7 x TUBE-C-100*100*3 | 7.80298 | +3.746 | +4.365 | TUBE-C-100*100*3 | 1-2/D-C | P67
TUBE-C-100*100*3 | 5.9974 | +4.024 | +4.425 | TUBE-C-100*100*3 | 1/D | P96
PL2*340 | 1.44126 | +4.020 | +4.034 | PL2*340 | 1-2/D | Y6
UPF-100*50*4 | 0 | +4.365 | +4.465 | UPF-100*50*4 | 1-2/C | S53
7 x PL2*340 | 1.44126 | +4.020 | +4.034 | PL2*340 | 1-2/D-C | Y6
7 x TUBE-C-100*100*3 | 5.9974 | +4.024 | +4.425 | TUBE-C-100*100*3 | 1/D-C | P96
7 x PL2*340 | 1.44126 | +3.742 | +3.756 | PL2*340 | 1-2/D-C | Y6
4 x UPF-100*50*4 | 0 | +4.365 | +4.465 | UPF-100*50*4 | 1-2/D-C | S52
2 x UPF-100*50*4 | 0 | +4.265 | +4.425 | UPF-100*50*4 | 2-3/D-C | S66
TUBE-C-100*100*3 | 6.71458 | +3.387 | +4.265 | TUBE-C-100*100*3 | 2-3/E-D | P83
3 x UPF-100*50*4 | 0 | +4.365 | +4.465 | UPF-100*50*4 | 1-2/D-C | S53
UPF-100*50*4 | 0 | +4.265 | +4.425 | UPF-100*50*4 | 2-3/E-D | S49
2 x UPF-100*50*4 | 0 | +4.265 | +4.425 | UPF-100*50*4 | 2-3/D-C | S67
3 x L60*6 | 0 | +4.269 | +4.361 | L60*6 | 1-2/D-C | H26
2 x UPF-100*50*4 | 0 | +4.265 | +4.365 | UPF-100*50*4 | 1-2/D-C | S62
UPF-100*50*4 | 0 | +4.265 | +4.425 | UPF-100*50*4 | 2-3/E-D | S68
PL2*340 | 1.44126 | +3.835 | +3.849 | PL2*340 | 1-2/C | Y6
L60*6 | 0 | +4.269 | +4.361 | L60*6 | 1-2/C-B | H26
PL2*340 | 1.44126 | +4.020 | +4.034 | PL2*340 | 1-2/C | Y6
PL2*340 | 1.44126 | +3.742 | +3.756 | PL2*340 | 1-2/C | Y6
L60*6 | 0 | +4.365 | +4.425 | L60*6 | 1-2/C | H20
TUBE-C-100*100*3 | 7.80298 | +3.839 | +4.365 | TUBE-C-100*100*3 | 1-2/C | P66
TUBE-C-100*100*3 | 7.80298 | +3.746 | +4.365 | TUBE-C-100*100*3 | 1-2/C | P67
UPF-100*50*4 | 0 | +10.765 | +10.865 | UPF-100*50*4 | /B'> | S51
2 x L60*6 | 0 | +10.769 | +10.961 | L60*6 | /B'> | H21
2 x L60*6 | 0 | +10.769 | +10.861 | L60*6 | /B'> | H26
UPF-100*50*4 | 0 | +10.765 | +10.865 | UPF-100*50*4 | /B'> | S61
3 x L60*6 | 0 | +10.769 | +10.961 | L60*6 | /B'> | H27
TUBE-C-100*100*3 | 6.71458 | +10.305 | +10.765 | TUBE-C-100*100*3 | >/B'> | P92
UPF-100*50*4 | 0 | +10.765 | +10.865 | UPF-100*50*4 | /B'> | S50
TUBE-C-100*100*3 | 6.71458 | +10.393 | +10.765 | TUBE-C-100*100*3 | >/B'> | P91
HEA100 | 0 | +10.120 | +10.219 | HEA100 | >/B'> | N60
UPF-100*50*4 | 0 | +10.865 | +10.965 | UPF-100*50*4 | ->/B'> | S84
TUBE-C-100*100*3 | 5.52766 | +10.568 | +10.925 | TUBE-C-100*100*3 | -/B'> | P108
HEA100 | 0 | +10.120 | +10.219 | HEA100 | >/B'> | N56
PL2*340 | 1.44126 | +4.014 | +4.027 | PL2*340 | 1-2/E-D | Y6
TUBE-C-100*100*3 | 5.9974 | +4.018 | +4.325 | TUBE-C-100*100*3 | 1-2/C-B | P94
L60*6 | 0 | +4.269 | +4.361 | L60*6 | 1-2/C | H26
L60*6 | 0 | +4.269 | +4.461 | L60*6 | 1-2/C | H21
2 x UPF-100*50*4 | 0 | +4.265 | +4.365 | UPF-100*50*4 | 1-2/D-C | S63
L60*6 | 0 | +4.269 | +4.461 | L60*6 | 1-2/D | H21
UPF-100*50*4 | 0 | +4.265 | +4.365 | UPF-100*50*4 | 1-2/E-D | S64
L60*6 | 0 | +4.269 | +4.361 | L60*6 | 1-2/D | H26
L60*6 | 0 | +4.269 | +4.361 | L60*6 | 1-2/E-D | H26
UPF-100*50*4 | 0 | +4.265 | +4.365 | UPF-100*50*4 | 1-2/E-D | S42
8 x L70*7 | 0 | +3.499 | +3.679 | L70*7 | 3/E-D | H35
IPEA300 | 2.9432 | +3.418 | +4.036 | IPEA300 | 1-2/E-D | K81
IPEA300 | 7.35863 | +3.059 | +3.708 | IPEA300 | 2-3/E-D | K68
IPEA300 | 7.28937 | +3.059 | +3.708 | IPEA300 | 2-3/E-D | K63
IPEA300 | 2.9432 | +3.418 | +4.036 | IPEA300 | 1-2/D-C | K83
IPEA300 | 7.35277 | +3.059 | +3.708 | IPEA300 | 2-3/C-B | K67
4 x L70*7 | 0 | +3.499 | +3.679 | L70*7 | 3/C-B | H35
IPEA300 | 2.9432 | +3.418 | +4.036 | IPEA300 | 1-2/C | K83
2 x L70*7 | 0 | +3.812 | +3.992 | L70*7 | 1/C | H35
6 x L70*7 | 0 | +3.812 | +3.992 | L70*7 | 1/C-B | H35
IPE240 | 2.27226 | +3.475 | +4.036 | IPE240 | 1-2/C-B | K86
FPL8*210 | 2.13962 | +3.207 | +3.218 | FPL8*210 | 2/D-C | G75
6 x L60*6 | 0 | +3.215 | +3.278 | L60*6 | 2/D-C | H31
FPL8*210 | 2.13962 | +3.207 | +3.218 | FPL8*210 | 2/D-C | G76
FPL8*210 | 2.39039 | +3.207 | +3.218 | FPL8*210 | 2/D-C | G74
FPL8*210 | 2.3904 | +3.207 | +3.218 | FPL8*210 | 2/D-C | G73
FPL8*210 | 2.39039 | +3.207 | +3.218 | FPL8*210 | 2/D-C | G72
FPL8*210 | 2.39039 | +3.207 | +3.218 | FPL8*210 | 2/D-C | G71
FPL8*210 | 2.13962 | +3.207 | +3.218 | FPL8*210 | 2/D | G77
2 x L60*6 | 0 | +3.215 | +3.278 | L60*6 | 2/D | H31
FPL8*210 | 2.13961 | +3.207 | +3.218 | FPL8*210 | 2/D | G78
3 x L60*6 | 0 | +3.215 | +3.278 | L60*6 | 2/E-D | H31
FPL8*210 | 2.39039 | +3.207 | +3.218 | FPL8*210 | 2/E-D | G70
FPL8*210 | 2.36213 | +3.207 | +3.218 | FPL8*210 | 2/E-D | G81
