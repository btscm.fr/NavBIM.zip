Properties of the parts of a building model (IFC2X3), part 7 of 32

# IfcBeam: L60*6 (913)
Name | Material | Center of gravity Z (mm) | Center of gravity Y (mm) | Center of gravity X (mm) | Bottom elevation | Top elevation | Part mark | Assembly mark | Phase | Class | Finish | Grade | Name | Net weight (kg) = NetWeight (kg) | Gross weight (kg) = Weight (kg) | Net volume (m3) = NetVolume (m3) | Gross volume (m3) | Gross footprint area (m2) | Net surface area (m2) | Gross area (m2) = OuterSurfaceArea (m2) | Tekla Quantity, Length (mm) = BaseQuantities, Length (mm)
ATTACHE | STEEL/S235JR | 10915 | 66427.2 | 26001.8 | +10.869 | +10.961 | H26 | H26 | 2 | 2007 | GALVANISE | S235JR | ATTACHE | 0.493985 | 0.49904 | 0.000062928 | 0.000063572 | 0.000684 | 0.023448 | 0.021436 | 92
ATTACHE | STEEL/S235JR | 10865 | 66427.2 | 26036.2 | +10.769 | +10.961 | H21 | H21 | 2 | 2007 | GALVANISE | S235JR | ATTACHE | 1.03092 | 1.04148 | 0.000131328 | 0.000132672 | 0.000684 | 0.047448 | 0.044736 | 192
ATTACHE | STEEL/S235JR | 10865 | 66427.2 | 28864.2 | +10.769 | +10.961 | H25 | H25 | 2 | 2007 | GALVANISE | S235JR | ATTACHE | 1.03092 | 1.04148 | 0.000131328 | 0.000132672 | 0.000684 | 0.047448 | 0.044736 | 192
ATTACHE | STEEL/S235JR | 10865 | 66427.2 | 31692.2 | +10.769 | +10.961 | H25 | H25 | 2 | 2007 | GALVANISE | S235JR | ATTACHE | 1.03092 | 1.04148 | 0.000131328 | 0.000132672 | 0.000684 | 0.047448 | 0.044736 | 192
ATTACHE | STEEL/S235JR | 10882.2 | 63767.2 | 28847 | +10.865 | +10.925 | H24 | H24 | 2 | 2007 | GALVANISE | S235JR | ATTACHE | 1.12757 | 1.13911 | 0.00014364 | 0.00014511 | 0.00126 | 0.051768 | 0.04893 | 210
ATTACHE | STEEL/S235JR | 10882.2 | 63767.2 | 20360 | +10.865 | +10.925 | 428 | P95 | 2 | 2007 | GALVANISE | S235JR | ATTACHE | 1.12757 | 1.13911 | 0.00014364 | 0.00014511 | 0.00126 | 0.051768 | 0.04893 | 210
ATTACHE | STEEL/S235JR | 10882.2 | 63767.2 | 23191 | +10.865 | +10.925 | H24 | H24 | 2 | 2007 | GALVANISE | S235JR | ATTACHE | 1.12757 | 1.13911 | 0.00014364 | 0.00014511 | 0.00126 | 0.051768 | 0.04893 | 210
ATTACHE | STEEL/S235JR | 10882.2 | 61002.2 | 28847 | +10.865 | +10.925 | H24 | H24 | 2 | 2007 | GALVANISE | S235JR | ATTACHE | 1.12757 | 1.13911 | 0.00014364 | 0.00014511 | 0.00126 | 0.051768 | 0.04893 | 210
ATTACHE | STEEL/S235JR | 10882.2 | 61002.2 | 23191 | +10.865 | +10.925 | H24 | H24 | 2 | 2007 | GALVANISE | S235JR | ATTACHE | 1.12757 | 1.13911 | 0.00014364 | 0.00014511 | 0.00126 | 0.051768 | 0.04893 | 210
ATTACHE | STEEL/S235JR | 10882.2 | 61002.2 | 26019 | +10.865 | +10.925 | H20 | H20 | 2 | 2007 | GALVANISE | S235JR | ATTACHE | 1.12757 | 1.13911 | 0.00014364 | 0.00014511 | 0.00126 | 0.051768 | 0.04893 | 210
ATTACHE | STEEL/S235JR | 10882.2 | 61002.2 | 31675 | +10.865 | +10.925 | H24 | H24 | 2 | 2007 | GALVANISE | S235JR | ATTACHE | 1.12757 | 1.13911 | 0.00014364 | 0.00014511 | 0.00126 | 0.051768 | 0.04893 | 210
ATTACHE | STEEL/S235JR | 10882.2 | 58237.2 | 28847 | +10.865 | +10.925 | H24 | H24 | 2 | 2007 | GALVANISE | S235JR | ATTACHE | 1.12757 | 1.13911 | 0.00014364 | 0.00014511 | 0.00126 | 0.051768 | 0.04893 | 210
ATTACHE | STEEL/S235JR | 10882.2 | 58237.2 | 23191 | +10.865 | +10.925 | H24 | H24 | 2 | 2007 | GALVANISE | S235JR | ATTACHE | 1.12757 | 1.13911 | 0.00014364 | 0.00014511 | 0.00126 | 0.051768 | 0.04893 | 210
ATTACHE | STEEL/S235JR | 10882.2 | 58237.2 | 26019 | +10.865 | +10.925 | H20 | H20 | 2 | 2007 | GALVANISE | S235JR | ATTACHE | 1.12757 | 1.13911 | 0.00014364 | 0.00014511 | 0.00126 | 0.051768 | 0.04893 | 210
ATTACHE | STEEL/S235JR | 10882.2 | 58237.2 | 31675 | +10.865 | +10.925 | H24 | H24 | 2 | 2007 | GALVANISE | S235JR | ATTACHE | 1.12757 | 1.13911 | 0.00014364 | 0.00014511 | 0.00126 | 0.051768 | 0.04893 | 210
ATTACHE | STEEL/S235JR | 10882.2 | 55472.2 | 28847 | +10.865 | +10.925 | H24 | H24 | 2 | 2007 | GALVANISE | S235JR | ATTACHE | 1.12757 | 1.13911 | 0.00014364 | 0.00014511 | 0.00126 | 0.051768 | 0.04893 | 210
ATTACHE | STEEL/S235JR | 10882.2 | 55472.2 | 23191 | +10.865 | +10.925 | H24 | H24 | 2 | 2007 | GALVANISE | S235JR | ATTACHE | 1.12757 | 1.13911 | 0.00014364 | 0.00014511 | 0.00126 | 0.051768 | 0.04893 | 210
ATTACHE | STEEL/S235JR | 10882.2 | 55472.2 | 26019 | +10.865 | +10.925 | H20 | H20 | 2 | 2007 | GALVANISE | S235JR | ATTACHE | 1.12757 | 1.13911 | 0.00014364 | 0.00014511 | 0.00126 | 0.051768 | 0.04893 | 210
ATTACHE | STEEL/S235JR | 10882.2 | 55472.2 | 31675 | +10.865 | +10.925 | H24 | H24 | 2 | 2007 | GALVANISE | S235JR | ATTACHE | 1.12757 | 1.13911 | 0.00014364 | 0.00014511 | 0.00126 | 0.051768 | 0.04893 | 210
ATTACHE | STEEL/S235JR | 10882.2 | 52707.2 | 28847 | +10.865 | +10.925 | H24 | H24 | 2 | 2007 | GALVANISE | S235JR | ATTACHE | 1.12757 | 1.13911 | 0.00014364 | 0.00014511 | 0.00126 | 0.051768 | 0.04893 | 210
ATTACHE | STEEL/S235JR | 10882.2 | 52707.2 | 23191 | +10.865 | +10.925 | H24 | H24 | 2 | 2007 | GALVANISE | S235JR | ATTACHE | 1.12757 | 1.13911 | 0.00014364 | 0.00014511 | 0.00126 | 0.051768 | 0.04893 | 210
ATTACHE | STEEL/S235JR | 10882.2 | 52707.2 | 26019 | +10.865 | +10.925 | H20 | H20 | 2 | 2007 | GALVANISE | S235JR | ATTACHE | 1.12757 | 1.13911 | 0.00014364 | 0.00014511 | 0.00126 | 0.051768 | 0.04893 | 210
ATTACHE | STEEL/S235JR | 10882.2 | 52707.2 | 31675 | +10.865 | +10.925 | H24 | H24 | 2 | 2007 | GALVANISE | S235JR | ATTACHE | 1.12757 | 1.13911 | 0.00014364 | 0.00014511 | 0.00126 | 0.051768 | 0.04893 | 210
ATTACHE | STEEL/S235JR | 10865 | 62384.7 | 28864.2 | +10.769 | +10.961 | H25 | H25 | 2 | 2007 | GALVANISE | S235JR | ATTACHE | 1.03092 | 1.04148 | 0.000131328 | 0.000132672 | 0.000684 | 0.047448 | 0.044736 | 192
ATTACHE | STEEL/S235JR | 10915 | 62384.7 | 26001.8 | +10.869 | +10.961 | H26 | H26 | 2 | 2007 | GALVANISE | S235JR | ATTACHE | 0.493985 | 0.49904 | 0.000062928 | 0.000063572 | 0.000684 | 0.023448 | 0.021436 | 92
ATTACHE | STEEL/S235JR | 10782.2 | 50520 | 28864.2 | +10.765 | +10.825 | H24 | H24 | 2 | 2007 | GALVANISE | S235JR | ATTACHE | 1.12757 | 1.13911 | 0.00014364 | 0.00014511 | 0.00126 | 0.051768 | 0.04893 | 210
ATTACHE | STEEL/S235JR | 10865 | 62384.7 | 31692.2 | +10.769 | +10.961 | H25 | H25 | 2 | 2007 | GALVANISE | S235JR | ATTACHE | 1.03092 | 1.04148 | 0.000131328 | 0.000132672 | 0.000684 | 0.047448 | 0.044736 | 192
ATTACHE | STEEL/S235JR | 10865 | 51342.8 | 23173.8 | +10.769 | +10.961 | H25 | H25 | 2 | 2007 | GALVANISE | S235JR | ATTACHE | 1.03092 | 1.04148 | 0.000131328 | 0.000132672 | 0.000684 | 0.047448 | 0.044736 | 192
ATTACHE | STEEL/S235JR | 10865 | 62384.7 | 26036.2 | +10.769 | +10.961 | H21 | H21 | 2 | 2007 | GALVANISE | S235JR | ATTACHE | 1.03092 | 1.04148 | 0.000131328 | 0.000132672 | 0.000684 | 0.047448 | 0.044736 | 192
ATTACHE | STEEL/S235JR | 10865 | 62384.7 | 20652.2 | +10.769 | +10.961 | H25 | H25 | 2 | 2007 | GALVANISE | S235JR | ATTACHE | 1.03092 | 1.04148 | 0.000131328 | 0.000132672 | 0.000684 | 0.047448 | 0.044736 | 192
ATTACHE | STEEL/S235JR | 10782.2 | 50520 | 31692.2 | +10.765 | +10.825 | H24 | H24 | 2 | 2007 | GALVANISE | S235JR | ATTACHE | 1.12757 | 1.13911 | 0.00014364 | 0.00014511 | 0.00126 | 0.051768 | 0.04893 | 210
CSV | STEEL/E24-2 | 10156.2 | 59604.5 | 27793.6 | +10.066 | +10.222 | C1 | C1 | 2 | 2004 | GRENAILLE-PEINT | E24-2 | CSV | 21.8156 | 22.0172 | 0.00277906 | 0.00280474 | 0 | 0.976478 | 0.945737 | 4058.96
CSV | STEEL/E24-2 | 10058 | 59585.8 | 30960.3 | +9.967 | +10.124 | C3 | C3 | 2 | 2004 | GRENAILLE-PEINT | E24-2 | CSV | 21.9499 | 22.1529 | 0.00279617 | 0.00282202 | 0 | 0.98248 | 0.951564 | 4083.97
CSV | STEEL/E24-2 | 10058 | 56854.2 | 30960.3 | +9.967 | +10.124 | C3 | C3 | 2 | 2004 | GRENAILLE-PEINT | E24-2 | CSV | 21.9499 | 22.1529 | 0.00279617 | 0.00282202 | 0 | 0.98248 | 0.951564 | 4083.97
CSV | STEEL/E24-2 | 10156.2 | 56835.5 | 27793.6 | +10.066 | +10.222 | C1 | C1 | 2 | 2004 | GRENAILLE-PEINT | E24-2 | CSV | 21.8156 | 22.0172 | 0.00277906 | 0.00280474 | 0 | 0.976478 | 0.945737 | 4058.96
CSV | STEEL/E24-2 | 10256.4 | 65134.5 | 24560.1 | +10.166 | +10.322 | C1 | C1 | 2 | 2004 | GRENAILLE-PEINT | E24-2 | CSV | 21.8156 | 22.0172 | 0.00277906 | 0.00280474 | 0 | 0.976478 | 0.945737 | 4058.96
CSV | STEEL/E24-2 | 10156.2 | 65134.5 | 27793.6 | +10.066 | +10.222 | C1 | C1 | 2 | 2004 | GRENAILLE-PEINT | E24-2 | CSV | 21.8156 | 22.0172 | 0.00277906 | 0.00280474 | 0 | 0.976478 | 0.945737 | 4058.96
CSV | STEEL/E24-2 | 10156.2 | 62365.5 | 27793.6 | +10.066 | +10.222 | C1 | C1 | 2 | 2004 | GRENAILLE-PEINT | E24-2 | CSV | 21.8156 | 22.0172 | 0.00277906 | 0.00280474 | 0 | 0.976478 | 0.945737 | 4058.96
CSV | STEEL/E24-2 | 10059.1 | 65134.5 | 30927.6 | +9.969 | +10.124 | C1 | C1 | 2 | 2004 | GRENAILLE-PEINT | E24-2 | CSV | 21.8156 | 22.0172 | 0.00277906 | 0.00280474 | 0 | 0.976478 | 0.945737 | 4058.96
CSV | STEEL/E24-2 | 10058 | 62384.2 | 30960.3 | +9.967 | +10.124 | C3 | C3 | 2 | 2004 | GRENAILLE-PEINT | E24-2 | CSV | 21.9499 | 22.1529 | 0.00279617 | 0.00282202 | 0 | 0.98248 | 0.951564 | 4083.97
CSV | STEEL/E24-2 | 10354.6 | 54055.8 | 21393.3 | +10.264 | +10.420 | C3 | C3 | 2 | 2004 | GRENAILLE-PEINT | E24-2 | CSV | 21.9499 | 22.1529 | 0.00279617 | 0.00282202 | 0 | 0.98248 | 0.951564 | 4083.97
CSV | STEEL/E24-2 | 10256.4 | 54074.5 | 24560.1 | +10.166 | +10.322 | C1 | C1 | 2 | 2004 | GRENAILLE-PEINT | E24-2 | CSV | 21.8156 | 22.0172 | 0.00277906 | 0.00280474 | 0 | 0.976478 | 0.945737 | 4058.96
CSV | STEEL/E24-2 | 10156.2 | 54074.5 | 27793.6 | +10.066 | +10.222 | C1 | C1 | 2 | 2004 | GRENAILLE-PEINT | E24-2 | CSV | 21.8156 | 22.0172 | 0.00277906 | 0.00280474 | 0 | 0.976478 | 0.945737 | 4058.96
CSV | STEEL/E24-2 | 10058 | 54055.8 | 30960.3 | +9.967 | +10.124 | C3 | C3 | 2 | 2004 | GRENAILLE-PEINT | E24-2 | CSV | 21.9499 | 22.1529 | 0.00279617 | 0.00282202 | 0 | 0.98248 | 0.951564 | 4083.97
CSV | STEEL/E24-2 | 10352.7 | 51330.5 | 21454.9 | +10.263 | +10.417 | C2 | C2 | 2 | 2004 | GRENAILLE-PEINT | E24-2 | CSV | 21.4061 | 21.6035 | 0.00272689 | 0.00275204 | 0 | 0.958172 | 0.927966 | 3982.68
CSV | STEEL/E24-2 | 10256.5 | 51305.5 | 24560.1 | +10.166 | +10.322 | C1 | C1 | 2 | 2004 | GRENAILLE-PEINT | E24-2 | CSV | 21.8157 | 22.0172 | 0.00277906 | 0.00280474 | 0 | 0.976478 | 0.945737 | 4058.96
CSV | STEEL/E24-2 | 10156.2 | 51305.5 | 27793.6 | +10.066 | +10.222 | C1 | C1 | 2 | 2004 | GRENAILLE-PEINT | E24-2 | CSV | 21.8157 | 22.0172 | 0.00277906 | 0.00280474 | 0 | 0.976478 | 0.945737 | 4058.96
ATTACHE | STEEL/S235JR | 4365 | 44404.7 | 3060.54 | +4.269 | +4.461 | H25 | H25 | 2 | 2007 | GALVANISE | S235JR | ATTACHE | 1.03092 | 1.04148 | 0.000131328 | 0.000132672 | 0.000684 | 0.047448 | 0.044736 | 192
ATTACHE | STEEL/S235JR | 4382.21 | 45783.9 | 3043.33 | +4.365 | +4.425 | H24 | H24 | 2 | 2007 | GALVANISE | S235JR | ATTACHE | 1.12757 | 1.13911 | 0.00014364 | 0.00014511 | 0.00126 | 0.051768 | 0.04893 | 210
ATTACHE | STEEL/S235JR | 4365 | 41646.4 | 3060.54 | +4.269 | +4.461 | H25 | H25 | 2 | 2007 | GALVANISE | S235JR | ATTACHE | 1.03092 | 1.04148 | 0.000131328 | 0.000132672 | 0.000684 | 0.047448 | 0.044736 | 192
ATTACHE | STEEL/S235JR | 4365 | 38932.8 | 3060.54 | +4.269 | +4.461 | H25 | H25 | 2 | 2007 | GALVANISE | S235JR | ATTACHE | 1.03092 | 1.04148 | 0.000131328 | 0.000132672 | 0.000684 | 0.047448 | 0.044736 | 192
ATTACHE | STEEL/S235JR | 4382.21 | 43025.5 | 3043.33 | +4.365 | +4.425 | H24 | H24 | 2 | 2007 | GALVANISE | S235JR | ATTACHE | 1.12757 | 1.13911 | 0.00014364 | 0.00014511 | 0.00126 | 0.051768 | 0.04893 | 210
ATTACHE | STEEL/S235JR | 4365 | 36264.1 | 3060.54 | +4.269 | +4.461 | H25 | H25 | 2 | 2007 | GALVANISE | S235JR | ATTACHE | 1.03092 | 1.04148 | 0.000131328 | 0.000132672 | 0.000684 | 0.047448 | 0.044736 | 192
ATTACHE | STEEL/S235JR | 4365 | 33595.3 | 3060.54 | +4.269 | +4.461 | H25 | H25 | 2 | 2007 | GALVANISE | S235JR | ATTACHE | 1.03092 | 1.04148 | 0.000131328 | 0.000132672 | 0.000684 | 0.047448 | 0.044736 | 192
ATTACHE | STEEL/S235JR | 4365 | 30926.6 | 3060.54 | +4.269 | +4.461 | H25 | H25 | 2 | 2007 | GALVANISE | S235JR | ATTACHE | 1.03092 | 1.04148 | 0.000131328 | 0.000132672 | 0.000684 | 0.047448 | 0.044736 | 192
ATTACHE | STEEL/S235JR | 4382.21 | 40267.2 | 3043.33 | +4.365 | +4.425 | H24 | H24 | 2 | 2007 | GALVANISE | S235JR | ATTACHE | 1.12757 | 1.13911 | 0.00014364 | 0.00014511 | 0.00126 | 0.051768 | 0.04893 | 210
ATTACHE | STEEL/S235JR | 4365 | 28326.6 | 3060.54 | +4.269 | +4.461 | H25 | H25 | 2 | 2007 | GALVANISE | S235JR | ATTACHE | 1.03092 | 1.04148 | 0.000131328 | 0.000132672 | 0.000684 | 0.047448 | 0.044736 | 192
ATTACHE | STEEL/S235JR | 4382.21 | 37598.5 | 3043.33 | +4.365 | +4.425 | H24 | H24 | 2 | 2007 | GALVANISE | S235JR | ATTACHE | 1.12757 | 1.13911 | 0.00014364 | 0.00014511 | 0.00126 | 0.051768 | 0.04893 | 210
ATTACHE | STEEL/S235JR | 4365 | 25795.3 | 3060.54 | +4.269 | +4.461 | H25 | H25 | 2 | 2007 | GALVANISE | S235JR | ATTACHE | 1.03092 | 1.04148 | 0.000131328 | 0.000132672 | 0.000684 | 0.047448 | 0.044736 | 192
ATTACHE | STEEL/S235JR | 4382.21 | 34929.7 | 3043.33 | +4.365 | +4.425 | H24 | H24 | 2 | 2007 | GALVANISE | S235JR | ATTACHE | 1.12757 | 1.13911 | 0.00014364 | 0.00014511 | 0.00126 | 0.051768 | 0.04893 | 210
ATTACHE | STEEL/S235JR | 4382.21 | 32261 | 3043.33 | +4.365 | +4.425 | H24 | H24 | 2 | 2007 | GALVANISE | S235JR | ATTACHE | 1.12757 | 1.13911 | 0.00014364 | 0.00014511 | 0.00126 | 0.051768 | 0.04893 | 210
ATTACHE | STEEL/S235JR | 4365 | 23264.1 | 3060.54 | +4.269 | +4.461 | H25 | H25 | 2 | 2007 | GALVANISE | S235JR | ATTACHE | 1.03092 | 1.04148 | 0.000131328 | 0.000132672 | 0.000684 | 0.047448 | 0.044736 | 192
ATTACHE | STEEL/S235JR | 4382.21 | 29592.2 | 3043.33 | +4.365 | +4.425 | H24 | H24 | 2 | 2007 | GALVANISE | S235JR | ATTACHE | 1.12757 | 1.13911 | 0.00014364 | 0.00014511 | 0.00126 | 0.051768 | 0.04893 | 210
ATTACHE | STEEL/S235JR | 4382.21 | 27061 | 3043.33 | +4.365 | +4.425 | H24 | H24 | 2 | 2007 | GALVANISE | S235JR | ATTACHE | 1.12757 | 1.13911 | 0.00014364 | 0.00014511 | 0.00126 | 0.051768 | 0.04893 | 210
ATTACHE | STEEL/S235JR | 4365 | 20732.8 | 3060.54 | +4.269 | +4.461 | H25 | H25 | 2 | 2007 | GALVANISE | S235JR | ATTACHE | 1.03092 | 1.04148 | 0.000131328 | 0.000132672 | 0.000684 | 0.047448 | 0.044736 | 192
ATTACHE | STEEL/S235JR | 4382.21 | 24529.7 | 3043.33 | +4.365 | +4.425 | H24 | H24 | 2 | 2007 | GALVANISE | S235JR | ATTACHE | 1.12757 | 1.13911 | 0.00014364 | 0.00014511 | 0.00126 | 0.051768 | 0.04893 | 210
ATTACHE | STEEL/S235JR | 4382.21 | 21998.5 | 3043.33 | +4.365 | +4.425 | H24 | H24 | 2 | 2007 | GALVANISE | S235JR | ATTACHE | 1.12757 | 1.13911 | 0.00014364 | 0.00014511 | 0.00126 | 0.051768 | 0.04893 | 210
ATTACHE | STEEL/S235JR | 4365 | 18402.2 | 3060.54 | +4.269 | +4.461 | H25 | H25 | 2 | 2007 | GALVANISE | S235JR | ATTACHE | 1.03092 | 1.04148 | 0.000131328 | 0.000132672 | 0.000684 | 0.047448 | 0.044736 | 192
ATTACHE | STEEL/S235JR | 4382.21 | 19467.2 | 3043.33 | +4.365 | +4.425 | H24 | H24 | 2 | 2007 | GALVANISE | S235JR | ATTACHE | 1.12757 | 1.13911 | 0.00014364 | 0.00014511 | 0.00126 | 0.051768 | 0.04893 | 210
ATTACHE | STEEL/S235JR | 4365 | 16272.2 | 3060.54 | +4.269 | +4.461 | H25 | H25 | 2 | 2007 | GALVANISE | S235JR | ATTACHE | 1.03092 | 1.04148 | 0.000131328 | 0.000132672 | 0.000684 | 0.047448 | 0.044736 | 192
ATTACHE | STEEL/S235JR | 4382.21 | 17337.2 | 3043.33 | +4.365 | +4.425 | H24 | H24 | 2 | 2007 | GALVANISE | S235JR | ATTACHE | 1.12757 | 1.13911 | 0.00014364 | 0.00014511 | 0.00126 | 0.051768 | 0.04893 | 210
ATTACHE | STEEL/S235JR | 4382.21 | 15207.2 | 3043.33 | +4.365 | +4.425 | H24 | H24 | 2 | 2007 | GALVANISE | S235JR | ATTACHE | 1.12757 | 1.13911 | 0.00014364 | 0.00014511 | 0.00126 | 0.051768 | 0.04893 | 210
ATTACHE | STEEL/S235JR | 4365 | 12077.2 | 3060.54 | +4.269 | +4.461 | H25 | H25 | 2 | 2007 | GALVANISE | S235JR | ATTACHE | 1.03092 | 1.04148 | 0.000131328 | 0.000132672 | 0.000684 | 0.047448 | 0.044736 | 192
ATTACHE | STEEL/S235JR | 4365 | 10147.2 | 3060.54 | +4.269 | +4.461 | H25 | H25 | 2 | 2007 | GALVANISE | S235JR | ATTACHE | 1.03092 | 1.04148 | 0.000131328 | 0.000132672 | 0.000684 | 0.047448 | 0.044736 | 192
ATTACHE | STEEL/S235JR | 4365 | 14142.2 | 3060.54 | +4.269 | +4.461 | H25 | H25 | 2 | 2007 | GALVANISE | S235JR | ATTACHE | 1.03092 | 1.04148 | 0.000131328 | 0.000132672 | 0.000684 | 0.047448 | 0.044736 | 192
ATTACHE | STEEL/S235JR | 4365 | 11077.2 | 3060.54 | +4.269 | +4.461 | H25 | H25 | 2 | 2007 | GALVANISE | S235JR | ATTACHE | 1.03092 | 1.04148 | 0.000131328 | 0.000132672 | 0.000684 | 0.047448 | 0.044736 | 192
ATTACHE | STEEL/S235JR | 4282.21 | 10930 | 3060.54 | +4.265 | +4.325 | H24 | H24 | 2 | 2007 | GALVANISE | S235JR | ATTACHE | 1.12757 | 1.13911 | 0.00014364 | 0.00014511 | 0.00126 | 0.051768 | 0.04893 | 210
ATTACHE | STEEL/S235JR | 4282.21 | 48525 | 3060.54 | +4.265 | +4.325 | H24 | H24 | 2 | 2007 | GALVANISE | S235JR | ATTACHE | 1.12757 | 1.13911 | 0.00014364 | 0.00014511 | 0.00126 | 0.051768 | 0.04893 | 210
ATTACHE | STEEL/S235JR | 4382.21 | 13077.2 | 3043.33 | +4.365 | +4.425 | H24 | H24 | 2 | 2007 | GALVANISE | S235JR | ATTACHE | 1.12757 | 1.13911 | 0.00014364 | 0.00014511 | 0.00126 | 0.051768 | 0.04893 | 210
ATTACHE | STEEL/S235JR | 4282.21 | 17320 | 10422.2 | +4.265 | +4.325 | H24 | H24 | 2 | 2007 | GALVANISE | S235JR | ATTACHE | 1.12757 | 1.13911 | 0.00014364 | 0.00014511 | 0.00126 | 0.051768 | 0.04893 | 210
ATTACHE | STEEL/S235JR | 4282.21 | 15190 | 10422.2 | +4.265 | +4.325 | H20 | H20 | 2 | 2007 | GALVANISE | S235JR | ATTACHE | 1.12757 | 1.13911 | 0.00014364 | 0.00014511 | 0.00126 | 0.051768 | 0.04893 | 210
ATTACHE | STEEL/S235JR | 4282.21 | 21981.2 | 10422.2 | +4.265 | +4.325 | H24 | H24 | 2 | 2007 | GALVANISE | S235JR | ATTACHE | 1.12757 | 1.13911 | 0.00014364 | 0.00014511 | 0.00126 | 0.051768 | 0.04893 | 210
ATTACHE | STEEL/S235JR | 4282.21 | 27043.8 | 10422.2 | +4.265 | +4.325 | H24 | H24 | 2 | 2007 | GALVANISE | S235JR | ATTACHE | 1.12757 | 1.13911 | 0.00014364 | 0.00014511 | 0.00126 | 0.051768 | 0.04893 | 210
ATTACHE | STEEL/S235JR | 4282.21 | 32243.8 | 10422.2 | +4.265 | +4.325 | H24 | H24 | 2 | 2007 | GALVANISE | S235JR | ATTACHE | 1.12757 | 1.13911 | 0.00014364 | 0.00014511 | 0.00126 | 0.051768 | 0.04893 | 210
ATTACHE | STEEL/S235JR | 4282.21 | 37581.2 | 10422.2 | +4.265 | +4.325 | H24 | H24 | 2 | 2007 | GALVANISE | S235JR | ATTACHE | 1.12757 | 1.13911 | 0.00014364 | 0.00014511 | 0.00126 | 0.051768 | 0.04893 | 210
ATTACHE | STEEL/S235JR | 4282.21 | 43008.3 | 10422.2 | +4.265 | +4.325 | H24 | H24 | 2 | 2007 | GALVANISE | S235JR | ATTACHE | 1.12757 | 1.13911 | 0.00014364 | 0.00014511 | 0.00126 | 0.051768 | 0.04893 | 210
ATTACHE | STEEL/S235JR | 4382.21 | 13077.2 | 10380 | +4.365 | +4.425 | 429 | S49 | 2 | 2007 | GALVANISE | S235JR | ATTACHE | 0.53694 | 0.542435 | 0.0000684 | 0.0000691 | 0.0006 | 0.025368 | 0.0233 | 100
ATTACHE | STEEL/S235JR | 4382.21 | 15207.2 | 10380 | +4.365 | +4.425 | 429 | S68 | 2 | 2007 | GALVANISE | S235JR | ATTACHE | 0.53694 | 0.542435 | 0.0000684 | 0.0000691 | 0.0006 | 0.025368 | 0.0233 | 100
ATTACHE | STEEL/S235JR | 4382.21 | 17337.2 | 10380 | +4.365 | +4.425 | 429 | S68 | 2 | 2007 | GALVANISE | S235JR | ATTACHE | 0.53694 | 0.542435 | 0.0000684 | 0.0000691 | 0.0006 | 0.025368 | 0.0233 | 100
ATTACHE | STEEL/S235JR | 4382.21 | 27061 | 10380 | +4.365 | +4.425 | 429 | S67 | 2 | 2007 | GALVANISE | S235JR | ATTACHE | 0.53694 | 0.542435 | 0.0000684 | 0.0000691 | 0.0006 | 0.025368 | 0.0233 | 100
ATTACHE | STEEL/S235JR | 4382.21 | 32261 | 10380 | +4.365 | +4.425 | 429 | S66 | 2 | 2007 | GALVANISE | S235JR | ATTACHE | 0.53694 | 0.542435 | 0.0000684 | 0.0000691 | 0.0006 | 0.025368 | 0.0233 | 100
ATTACHE | STEEL/S235JR | 4382.21 | 37598.5 | 10380 | +4.365 | +4.425 | 429 | S66 | 2 | 2007 | GALVANISE | S235JR | ATTACHE | 0.53694 | 0.542435 | 0.0000684 | 0.0000691 | 0.0006 | 0.025368 | 0.0233 | 100
ATTACHE | STEEL/S235JR | 4382.21 | 43025.5 | 10380 | +4.365 | +4.425 | 429 | S65 | 2 | 2007 | GALVANISE | S235JR | ATTACHE | 0.53694 | 0.542435 | 0.0000684 | 0.0000691 | 0.0006 | 0.025368 | 0.0233 | 100
ATTACHE | STEEL/S235JR | 4282.21 | 19450 | 10422.2 | +4.265 | +4.325 | H20 | H20 | 2 | 2007 | GALVANISE | S235JR | ATTACHE | 1.12757 | 1.13911 | 0.00014364 | 0.00014511 | 0.00126 | 0.051768 | 0.04893 | 210
ATTACHE | STEEL/S235JR | 4382.21 | 19467.2 | 10380 | +4.365 | +4.425 | 429 | S67 | 2 | 2007 | GALVANISE | S235JR | ATTACHE | 0.53694 | 0.542435 | 0.0000684 | 0.0000691 | 0.0006 | 0.025368 | 0.0233 | 100
ATTACHE | STEEL/S235JR | 4282.21 | 24512.5 | 10422.2 | +4.265 | +4.325 | H20 | H20 | 2 | 2007 | GALVANISE | S235JR | ATTACHE | 1.12757 | 1.13911 | 0.00014364 | 0.00014511 | 0.00126 | 0.051768 | 0.04893 | 210
ATTACHE | STEEL/S235JR | 4382.21 | 24529.7 | 10380 | +4.365 | +4.425 | 429 | S67 | 2 | 2007 | GALVANISE | S235JR | ATTACHE | 0.53694 | 0.542435 | 0.0000684 | 0.0000691 | 0.0006 | 0.025368 | 0.0233 | 100
ATTACHE | STEEL/S235JR | 4282.21 | 29575 | 10422.2 | +4.265 | +4.325 | H20 | H20 | 2 | 2007 | GALVANISE | S235JR | ATTACHE | 1.12757 | 1.13911 | 0.00014364 | 0.00014511 | 0.00126 | 0.051768 | 0.04893 | 210
ATTACHE | STEEL/S235JR | 4382.21 | 29592.2 | 10380 | +4.365 | +4.425 | 429 | S66 | 2 | 2007 | GALVANISE | S235JR | ATTACHE | 0.53694 | 0.542435 | 0.0000684 | 0.0000691 | 0.0006 | 0.025368 | 0.0233 | 100
ATTACHE | STEEL/S235JR | 4282.21 | 34912.5 | 10422.2 | +4.265 | +4.325 | H20 | H20 | 2 | 2007 | GALVANISE | S235JR | ATTACHE | 1.12757 | 1.13911 | 0.00014364 | 0.00014511 | 0.00126 | 0.051768 | 0.04893 | 210
ATTACHE | STEEL/S235JR | 4382.21 | 34929.7 | 10380 | +4.365 | +4.425 | 429 | S66 | 2 | 2007 | GALVANISE | S235JR | ATTACHE | 0.53694 | 0.542435 | 0.0000684 | 0.0000691 | 0.0006 | 0.025368 | 0.0233 | 100
ATTACHE | STEEL/S235JR | 4282.21 | 45766.7 | 10422.2 | +4.265 | +4.325 | H20 | H20 | 2 | 2007 | GALVANISE | S235JR | ATTACHE | 1.12757 | 1.13911 | 0.00014364 | 0.00014511 | 0.00126 | 0.051768 | 0.04893 | 210
ATTACHE | STEEL/S235JR | 4382.21 | 45783.9 | 10380 | +4.365 | +4.425 | 429 | S44 | 2 | 2007 | GALVANISE | S235JR | ATTACHE | 0.53694 | 0.542435 | 0.0000684 | 0.0000691 | 0.0006 | 0.025368 | 0.0233 | 100
ATTACHE | STEEL/S235JR | 4365 | 14142.2 | 10422.2 | +4.269 | +4.461 | H25 | H25 | 2 | 2007 | GALVANISE | S235JR | ATTACHE | 1.03092 | 1.04148 | 0.000131328 | 0.000132672 | 0.000684 | 0.047448 | 0.044736 | 192
ATTACHE | STEEL/S235JR | 4365 | 16272.2 | 10422.2 | +4.269 | +4.461 | H25 | H25 | 2 | 2007 | GALVANISE | S235JR | ATTACHE | 1.03092 | 1.04148 | 0.000131328 | 0.000132672 | 0.000684 | 0.047448 | 0.044736 | 192
ATTACHE | STEEL/S235JR | 4365 | 18402.2 | 10422.2 | +4.269 | +4.461 | H25 | H25 | 2 | 2007 | GALVANISE | S235JR | ATTACHE | 1.03092 | 1.04148 | 0.000131328 | 0.000132672 | 0.000684 | 0.047448 | 0.044736 | 192
ATTACHE | STEEL/S235JR | 4365 | 20732.8 | 10422.2 | +4.269 | +4.461 | H25 | H25 | 2 | 2007 | GALVANISE | S235JR | ATTACHE | 1.03092 | 1.04148 | 0.000131328 | 0.000132672 | 0.000684 | 0.047448 | 0.044736 | 192
ATTACHE | STEEL/S235JR | 4365 | 23264.1 | 10422.2 | +4.269 | +4.461 | H25 | H25 | 2 | 2007 | GALVANISE | S235JR | ATTACHE | 1.03092 | 1.04148 | 0.000131328 | 0.000132672 | 0.000684 | 0.047448 | 0.044736 | 192
ATTACHE | STEEL/S235JR | 4382.21 | 21998.5 | 10380 | +4.365 | +4.425 | 429 | S67 | 2 | 2007 | GALVANISE | S235JR | ATTACHE | 0.53694 | 0.542435 | 0.0000684 | 0.0000691 | 0.0006 | 0.025368 | 0.0233 | 100
ATTACHE | STEEL/S235JR | 4365 | 25795.3 | 10422.2 | +4.269 | +4.461 | H25 | H25 | 2 | 2007 | GALVANISE | S235JR | ATTACHE | 1.03092 | 1.04148 | 0.000131328 | 0.000132672 | 0.000684 | 0.047448 | 0.044736 | 192
ATTACHE | STEEL/S235JR | 4365 | 28326.6 | 10422.2 | +4.269 | +4.461 | H25 | H25 | 2 | 2007 | GALVANISE | S235JR | ATTACHE | 1.03092 | 1.04148 | 0.000131328 | 0.000132672 | 0.000684 | 0.047448 | 0.044736 | 192
ATTACHE | STEEL/S235JR | 4365 | 30926.6 | 10422.2 | +4.269 | +4.461 | H25 | H25 | 2 | 2007 | GALVANISE | S235JR | ATTACHE | 1.03092 | 1.04148 | 0.000131328 | 0.000132672 | 0.000684 | 0.047448 | 0.044736 | 192
ATTACHE | STEEL/S235JR | 4365 | 33595.3 | 10422.2 | +4.269 | +4.461 | H25 | H25 | 2 | 2007 | GALVANISE | S235JR | ATTACHE | 1.03092 | 1.04148 | 0.000131328 | 0.000132672 | 0.000684 | 0.047448 | 0.044736 | 192
ATTACHE | STEEL/S235JR | 4365 | 36264.1 | 10422.2 | +4.269 | +4.461 | H25 | H25 | 2 | 2007 | GALVANISE | S235JR | ATTACHE | 1.03092 | 1.04148 | 0.000131328 | 0.000132672 | 0.000684 | 0.047448 | 0.044736 | 192
ATTACHE | STEEL/S235JR | 4365 | 38932.8 | 10422.2 | +4.269 | +4.461 | H25 | H25 | 2 | 2007 | GALVANISE | S235JR | ATTACHE | 1.03092 | 1.04148 | 0.000131328 | 0.000132672 | 0.000684 | 0.047448 | 0.044736 | 192
ATTACHE | STEEL/S235JR | 4282.21 | 40250 | 10422.2 | +4.265 | +4.325 | H20 | H20 | 2 | 2007 | GALVANISE | S235JR | ATTACHE | 1.12757 | 1.13911 | 0.00014364 | 0.00014511 | 0.00126 | 0.051768 | 0.04893 | 210
ATTACHE | STEEL/S235JR | 4382.21 | 40267.2 | 10380 | +4.365 | +4.425 | 429 | S65 | 2 | 2007 | GALVANISE | S235JR | ATTACHE | 0.53694 | 0.542435 | 0.0000684 | 0.0000691 | 0.0006 | 0.025368 | 0.0233 | 100
ATTACHE | STEEL/S235JR | 4365 | 41646.4 | 10422.2 | +4.269 | +4.461 | H25 | H25 | 2 | 2007 | GALVANISE | S235JR | ATTACHE | 1.03092 | 1.04148 | 0.000131328 | 0.000132672 | 0.000684 | 0.047448 | 0.044736 | 192
ATTACHE | STEEL/S235JR | 4365 | 44404.7 | 10422.2 | +4.269 | +4.461 | H25 | H25 | 2 | 2007 | GALVANISE | S235JR | ATTACHE | 1.03092 | 1.04148 | 0.000131328 | 0.000132672 | 0.000684 | 0.047448 | 0.044736 | 192
ATTACHE | STEEL/S235JR | 4415 | 47068.9 | -347.789 | +4.369 | +4.461 | H26 | H26 | 2 | 2007 | GALVANISE | S235JR | ATTACHE | 0.493985 | 0.49904 | 0.000062928 | 0.000063572 | 0.000684 | 0.023448 | 0.021436 | 92
ATTACHE | STEEL/S235JR | 4365 | 47068.9 | 3060.54 | +4.269 | +4.461 | H25 | H25 | 2 | 2007 | GALVANISE | S235JR | ATTACHE | 1.03092 | 1.04148 | 0.000131328 | 0.000132672 | 0.000684 | 0.047448 | 0.044736 | 192
ATTACHE | STEEL/S235JR | 4365 | 47068.9 | 10422.2 | +4.269 | +4.461 | H25 | H25 | 2 | 2007 | GALVANISE | S235JR | ATTACHE | 1.03092 | 1.04148 | 0.000131328 | 0.000132672 | 0.000684 | 0.047448 | 0.044736 | 192
ATTACHE | STEEL/S235JR | 4415 | 45783.9 | -347.789 | +4.369 | +4.461 | H26 | H26 | 2 | 2007 | GALVANISE | S235JR | ATTACHE | 0.493985 | 0.49904 | 0.000062928 | 0.000063572 | 0.000684 | 0.023448 | 0.021436 | 92
ATTACHE | STEEL/S235JR | 4415 | 44404.7 | -347.789 | +4.369 | +4.461 | H26 | H26 | 2 | 2007 | GALVANISE | S235JR | ATTACHE | 0.493985 | 0.49904 | 0.000062928 | 0.000063572 | 0.000684 | 0.023448 | 0.021436 | 92
ATTACHE | STEEL/S235JR | 4415 | 43025.5 | -347.789 | +4.369 | +4.461 | H26 | H26 | 2 | 2007 | GALVANISE | S235JR | ATTACHE | 0.493985 | 0.49904 | 0.000062928 | 0.000063572 | 0.000684 | 0.023448 | 0.021436 | 92
ATTACHE | STEEL/S235JR | 4415 | 41646.4 | -347.789 | +4.369 | +4.461 | H26 | H26 | 2 | 2007 | GALVANISE | S235JR | ATTACHE | 0.493985 | 0.49904 | 0.000062928 | 0.000063572 | 0.000684 | 0.023448 | 0.021436 | 92
ATTACHE | STEEL/S235JR | 4415 | 40267.2 | -347.789 | +4.369 | +4.461 | H26 | H26 | 2 | 2007 | GALVANISE | S235JR | ATTACHE | 0.493985 | 0.49904 | 0.000062928 | 0.000063572 | 0.000684 | 0.023448 | 0.021436 | 92
ATTACHE | STEEL/S235JR | 4415 | 38932.8 | -347.789 | +4.369 | +4.461 | H26 | H26 | 2 | 2007 | GALVANISE | S235JR | ATTACHE | 0.493985 | 0.49904 | 0.000062928 | 0.000063572 | 0.000684 | 0.023448 | 0.021436 | 92
ATTACHE | STEEL/S235JR | 4415 | 37598.5 | -347.789 | +4.369 | +4.461 | H26 | H26 | 2 | 2007 | GALVANISE | S235JR | ATTACHE | 0.493985 | 0.49904 | 0.000062928 | 0.000063572 | 0.000684 | 0.023448 | 0.021436 | 92
ATTACHE | STEEL/S235JR | 4415 | 36264.1 | -347.789 | +4.369 | +4.461 | H26 | H26 | 2 | 2007 | GALVANISE | S235JR | ATTACHE | 0.493985 | 0.49904 | 0.000062928 | 0.000063572 | 0.000684 | 0.023448 | 0.021436 | 92
ATTACHE | STEEL/S235JR | 4415 | 34929.7 | -347.789 | +4.369 | +4.461 | H26 | H26 | 2 | 2007 | GALVANISE | S235JR | ATTACHE | 0.493985 | 0.49904 | 0.000062928 | 0.000063572 | 0.000684 | 0.023448 | 0.021436 | 92
ATTACHE | STEEL/S235JR | 4415 | 33595.3 | -347.789 | +4.369 | +4.461 | H26 | H26 | 2 | 2007 | GALVANISE | S235JR | ATTACHE | 0.493985 | 0.49904 | 0.000062928 | 0.000063572 | 0.000684 | 0.023448 | 0.021436 | 92
ATTACHE | STEEL/S235JR | 4415 | 32260.9 | -347.789 | +4.369 | +4.461 | H26 | H26 | 2 | 2007 | GALVANISE | S235JR | ATTACHE | 0.493985 | 0.49904 | 0.000062928 | 0.000063572 | 0.000684 | 0.023448 | 0.021436 | 92
ATTACHE | STEEL/S235JR | 4415 | 30926.6 | -347.789 | +4.369 | +4.461 | H26 | H26 | 2 | 2007 | GALVANISE | S235JR | ATTACHE | 0.493985 | 0.49904 | 0.000062928 | 0.000063572 | 0.000684 | 0.023448 | 0.021436 | 92
ATTACHE | STEEL/S235JR | 4415 | 29592.2 | -347.789 | +4.369 | +4.461 | H26 | H26 | 2 | 2007 | GALVANISE | S235JR | ATTACHE | 0.493985 | 0.49904 | 0.000062928 | 0.000063572 | 0.000684 | 0.023448 | 0.021436 | 92
ATTACHE | STEEL/S235JR | 4415 | 28326.6 | -347.789 | +4.369 | +4.461 | H26 | H26 | 2 | 2007 | GALVANISE | S235JR | ATTACHE | 0.493985 | 0.49904 | 0.000062928 | 0.000063572 | 0.000684 | 0.023448 | 0.021436 | 92
ATTACHE | STEEL/S235JR | 4415 | 27060.9 | -347.789 | +4.369 | +4.461 | H26 | H26 | 2 | 2007 | GALVANISE | S235JR | ATTACHE | 0.493985 | 0.49904 | 0.000062928 | 0.000063572 | 0.000684 | 0.023448 | 0.021436 | 92
ATTACHE | STEEL/S235JR | 4415 | 25795.3 | -347.789 | +4.369 | +4.461 | H26 | H26 | 2 | 2007 | GALVANISE | S235JR | ATTACHE | 0.493985 | 0.49904 | 0.000062928 | 0.000063572 | 0.000684 | 0.023448 | 0.021436 | 92
ATTACHE | STEEL/S235JR | 4415 | 24529.7 | -347.789 | +4.369 | +4.461 | H26 | H26 | 2 | 2007 | GALVANISE | S235JR | ATTACHE | 0.493985 | 0.49904 | 0.000062928 | 0.000063572 | 0.000684 | 0.023448 | 0.021436 | 92
ATTACHE | STEEL/S235JR | 4415 | 23264 | -347.789 | +4.369 | +4.461 | H26 | H26 | 2 | 2007 | GALVANISE | S235JR | ATTACHE | 0.493985 | 0.49904 | 0.000062928 | 0.000063572 | 0.000684 | 0.023448 | 0.021436 | 92
ATTACHE | STEEL/S235JR | 4415 | 21998.4 | -347.789 | +4.369 | +4.461 | H26 | H26 | 2 | 2007 | GALVANISE | S235JR | ATTACHE | 0.493985 | 0.49904 | 0.000062928 | 0.000063572 | 0.000684 | 0.023448 | 0.021436 | 92
ATTACHE | STEEL/S235JR | 4415 | 20732.8 | -347.789 | +4.369 | +4.461 | H26 | H26 | 2 | 2007 | GALVANISE | S235JR | ATTACHE | 0.493985 | 0.49904 | 0.000062928 | 0.000063572 | 0.000684 | 0.023448 | 0.021436 | 92
ATTACHE | STEEL/S235JR | 4415 | 19467.1 | -347.789 | +4.369 | +4.461 | H26 | H26 | 2 | 2007 | GALVANISE | S235JR | ATTACHE | 0.493985 | 0.49904 | 0.000062928 | 0.000063572 | 0.000684 | 0.023448 | 0.021436 | 92
ATTACHE | STEEL/S235JR | 4415 | 18402.1 | -347.789 | +4.369 | +4.461 | H26 | H26 | 2 | 2007 | GALVANISE | S235JR | ATTACHE | 0.493985 | 0.49904 | 0.000062928 | 0.000063572 | 0.000684 | 0.023448 | 0.021436 | 92
ATTACHE | STEEL/S235JR | 4415 | 17337.1 | -347.789 | +4.369 | +4.461 | H26 | H26 | 2 | 2007 | GALVANISE | S235JR | ATTACHE | 0.493985 | 0.49904 | 0.000062928 | 0.000063572 | 0.000684 | 0.023448 | 0.021436 | 92
ATTACHE | STEEL/S235JR | 4415 | 16272.1 | -347.789 | +4.369 | +4.461 | H26 | H26 | 2 | 2007 | GALVANISE | S235JR | ATTACHE | 0.493985 | 0.49904 | 0.000062928 | 0.000063572 | 0.000684 | 0.023448 | 0.021436 | 92
ATTACHE | STEEL/S235JR | 4415 | 15207.1 | -347.789 | +4.369 | +4.461 | H26 | H26 | 2 | 2007 | GALVANISE | S235JR | ATTACHE | 0.493985 | 0.49904 | 0.000062928 | 0.000063572 | 0.000684 | 0.023448 | 0.021436 | 92
ATTACHE | STEEL/S235JR | 4415 | 14142.1 | -347.789 | +4.369 | +4.461 | H26 | H26 | 2 | 2007 | GALVANISE | S235JR | ATTACHE | 0.493985 | 0.49904 | 0.000062928 | 0.000063572 | 0.000684 | 0.023448 | 0.021436 | 92
ATTACHE | STEEL/S235JR | 4415 | 13077.1 | -347.789 | +4.369 | +4.461 | H26 | H26 | 2 | 2007 | GALVANISE | S235JR | ATTACHE | 0.493985 | 0.49904 | 0.000062928 | 0.000063572 | 0.000684 | 0.023448 | 0.021436 | 92
ATTACHE | STEEL/S235JR | 4415 | 11077.2 | -347.789 | +4.369 | +4.461 | H26 | H26 | 2 | 2007 | GALVANISE | S235JR | ATTACHE | 0.493985 | 0.49904 | 0.000062928 | 0.000063572 | 0.000684 | 0.023448 | 0.021436 | 92
ATTACHE | STEEL/S235JR | 4415 | 12077.2 | -347.789 | +4.369 | +4.461 | H26 | H26 | 2 | 2007 | GALVANISE | S235JR | ATTACHE | 0.493985 | 0.49904 | 0.000062928 | 0.000063572 | 0.000684 | 0.023448 | 0.021436 | 92
ATTACHE | STEEL/S235JR | 4415 | 10147.2 | -347.789 | +4.369 | +4.461 | H26 | H26 | 2 | 2007 | GALVANISE | S235JR | ATTACHE | 0.493985 | 0.49904 | 0.000062928 | 0.000063572 | 0.000684 | 0.023448 | 0.021436 | 92
ATTACHE | STEEL/S235JR | 4365 | 47068.9 | 602.211 | +4.269 | +4.461 | H25 | H25 | 2 | 2007 | GALVANISE | S235JR | ATTACHE | 1.03092 | 1.04148 | 0.000131328 | 0.000132672 | 0.000684 | 0.047448 | 0.044736 | 192
ATTACHE | STEEL/S235JR | 4365 | 47068.9 | 8357.21 | +4.269 | +4.461 | H25 | H25 | 2 | 2007 | GALVANISE | S235JR | ATTACHE | 1.03092 | 1.04148 | 0.000131328 | 0.000132672 | 0.000684 | 0.047448 | 0.044736 | 192
ATTACHE | STEEL/S235JR | 4365 | 47068.9 | 5708.88 | +4.269 | +4.461 | H21 | H21 | 2 | 2007 | GALVANISE | S235JR | ATTACHE | 1.03092 | 1.04148 | 0.000131328 | 0.000132672 | 0.000684 | 0.047448 | 0.044736 | 192
ATTACHE | STEEL/S235JR | 4415 | 47068.9 | 5674.46 | +4.369 | +4.461 | H26 | H26 | 2 | 2007 | GALVANISE | S235JR | ATTACHE | 0.493985 | 0.49904 | 0.000062928 | 0.000063572 | 0.000684 | 0.023448 | 0.021436 | 92
ATTACHE | STEEL/E24-2 | 4254.21 | 2317.79 | 44202.5 | +4.237 | +4.297 | H17 | H17 | 4 | 4001 | GRENAILLE-PEINT | E24-2 | ATTACHE | 1.42289 | 1.43745 | 0.00018126 | 0.000183115 | 0.00159 | 0.064968 | 0.061745 | 265
MONTANT | STEEL/E24-2 | 3993.5 | 2352.21 | 44082.2 | +3.605 | +4.382 | M7 | M7 | 4 | 4001 | GRENAILLE-PEINT | E24-2 | MONTANT | 4.17202 | 4.21472 | 0.000531468 | 0.000536907 | 0.000684 | 0.187848 | 0.181041 | 777
ATTACHE | STEEL/E24-2 | 3922.79 | 2317.79 | 44202.5 | +3.880 | +3.940 | H18 | H18 | 4 | 4001 | GRENAILLE-PEINT | E24-2 | ATTACHE | 1.42289 | 1.43745 | 0.00018126 | 0.000183115 | 0.0159 | 0.064968 | 0.061745 | 265
ATTACHE | STEEL/E24-2 | 3922.79 | 4869.29 | 44202.5 | +3.880 | +3.940 | H18 | H18 | 4 | 4001 | GRENAILLE-PEINT | E24-2 | ATTACHE | 1.42289 | 1.43745 | 0.00018126 | 0.000183115 | 0.0159 | 0.064968 | 0.061745 | 265
ATTACHE | STEEL/E24-2 | 4254.21 | 4869.29 | 44202.5 | +4.237 | +4.297 | H17 | H17 | 4 | 4001 | GRENAILLE-PEINT | E24-2 | ATTACHE | 1.42289 | 1.43745 | 0.00018126 | 0.000183115 | 0.00159 | 0.064968 | 0.061745 | 265
MONTANT | STEEL/E24-2 | 3993.5 | 4903.71 | 44082.2 | +3.605 | +4.382 | M7 | M7 | 4 | 4001 | GRENAILLE-PEINT | E24-2 | MONTANT | 4.17202 | 4.21472 | 0.000531468 | 0.000536907 | 0.000684 | 0.187848 | 0.181041 | 777
MONTANT | STEEL/E24-2 | 3958.5 | 7497.21 | 44082.2 | +3.605 | +4.312 | M8 | M8 | 4 | 4001 | GRENAILLE-PEINT | E24-2 | MONTANT | 3.79617 | 3.83502 | 0.000483588 | 0.000488537 | 0.000684 | 0.171048 | 0.164731 | 707
ATTACHE | STEEL/E24-2 | 4254.21 | 2806.29 | 44202.5 | +4.237 | +4.297 | H17 | H17 | 4 | 4001 | GRENAILLE-PEINT | E24-2 | ATTACHE | 1.42289 | 1.43745 | 0.00018126 | 0.000183115 | 0.00159 | 0.064968 | 0.061745 | 265
ATTACHE | STEEL/E24-2 | 3922.79 | 2806.29 | 44202.5 | +3.880 | +3.940 | H18 | H18 | 4 | 4001 | GRENAILLE-PEINT | E24-2 | ATTACHE | 1.42289 | 1.43745 | 0.00018126 | 0.000183115 | 0.0159 | 0.064968 | 0.061745 | 265
MONTANT | STEEL/E24-2 | 3993.5 | 2840.71 | 44082.2 | +3.605 | +4.382 | M11 | M11 | 4 | 4001 | GRENAILLE-PEINT | E24-2 | MONTANT | 4.17202 | 4.21472 | 0.000531468 | 0.000536907 | 0.000684 | 0.187848 | 0.181041 | 777
ATTACHE | STEEL/E24-2 | 3922.79 | 7462.79 | 44202.5 | +3.880 | +3.940 | H18 | H18 | 4 | 4001 | GRENAILLE-PEINT | E24-2 | ATTACHE | 1.42289 | 1.43745 | 0.00018126 | 0.000183115 | 0.0159 | 0.064968 | 0.061745 | 265
ATTACHE | STEEL/E24-2 | 4254.21 | 7462.79 | 44202.5 | +4.237 | +4.297 | H17 | H17 | 4 | 4001 | GRENAILLE-PEINT | E24-2 | ATTACHE | 1.42289 | 1.43745 | 0.00018126 | 0.000183115 | 0.00159 | 0.064968 | 0.061745 | 265
ATTACHE | STEEL/E24-2 | 4254.21 | 5356.29 | 44202.5 | +4.237 | +4.297 | H17 | H17 | 4 | 4001 | GRENAILLE-PEINT | E24-2 | ATTACHE | 1.42289 | 1.43745 | 0.00018126 | 0.000183115 | 0.00159 | 0.064968 | 0.061745 | 265
ATTACHE | STEEL/E24-2 | 3922.79 | 5356.29 | 44202.5 | +3.880 | +3.940 | H18 | H18 | 4 | 4001 | GRENAILLE-PEINT | E24-2 | ATTACHE | 1.42289 | 1.43745 | 0.00018126 | 0.000183115 | 0.0159 | 0.064968 | 0.061745 | 265
MONTANT | STEEL/E24-2 | 3958.5 | 5390.71 | 44082.2 | +3.605 | +4.312 | M8 | M8 | 4 | 4001 | GRENAILLE-PEINT | E24-2 | MONTANT | 3.79617 | 3.83502 | 0.000483588 | 0.000488537 | 0.000684 | 0.171048 | 0.164731 | 707
MONTANT | STEEL/E24-2 | 3687.21 | 2815.5 | 44047.8 | +3.670 | +3.730 | M9 | M9 | 4 | 4001 | GRENAILLE-PEINT | E24-2 | MONTANT | 0.730237 | 0.73771 | 0.0000930238 | 0.0000939758 | 0.000815998 | 0.0340079 | 0.0316879 | 136
ATTACHE | STEEL/E24-2 | 3922.79 | 12139.3 | 44202.5 | +3.880 | +3.940 | H18 | H18 | 4 | 4001 | GRENAILLE-PEINT | E24-2 | ATTACHE | 1.42289 | 1.43745 | 0.00018126 | 0.000183115 | 0.0159 | 0.064968 | 0.061745 | 265
ATTACHE | STEEL/E24-2 | 4254.21 | 12139.3 | 44202.5 | +4.237 | +4.297 | H17 | H17 | 4 | 4001 | GRENAILLE-PEINT | E24-2 | ATTACHE | 1.42289 | 1.43745 | 0.00018126 | 0.000183115 | 0.00159 | 0.064968 | 0.061745 | 265
MONTANT | STEEL/E24-2 | 3993.5 | 12173.7 | 44082.2 | +3.605 | +4.382 | M7 | M7 | 4 | 4001 | GRENAILLE-PEINT | E24-2 | MONTANT | 4.17202 | 4.21472 | 0.000531468 | 0.000536907 | 0.000684 | 0.187848 | 0.181041 | 777
MONTANT | STEEL/E24-2 | 3993.5 | 10300.7 | 44082.2 | +3.605 | +4.382 | M7 | M7 | 4 | 4001 | GRENAILLE-PEINT | E24-2 | MONTANT | 4.17202 | 4.21472 | 0.000531468 | 0.000536907 | 0.000684 | 0.187848 | 0.181041 | 777
ATTACHE | STEEL/E24-2 | 4254.21 | 10266.3 | 44202.5 | +4.237 | +4.297 | H17 | H17 | 4 | 4001 | GRENAILLE-PEINT | E24-2 | ATTACHE | 1.42289 | 1.43745 | 0.00018126 | 0.000183115 | 0.00159 | 0.064968 | 0.061745 | 265
ATTACHE | STEEL/E24-2 | 3922.79 | 10266.3 | 44202.5 | +3.880 | +3.940 | H18 | H18 | 4 | 4001 | GRENAILLE-PEINT | E24-2 | ATTACHE | 1.42289 | 1.43745 | 0.00018126 | 0.000183115 | 0.0159 | 0.064968 | 0.061745 | 265
ATTACHE | STEEL/E24-2 | 3922.79 | 9779.29 | 44202.5 | +3.880 | +3.940 | H18 | H18 | 4 | 4001 | GRENAILLE-PEINT | E24-2 | ATTACHE | 1.42289 | 1.43745 | 0.00018126 | 0.000183115 | 0.0159 | 0.064968 | 0.061745 | 265
ATTACHE | STEEL/E24-2 | 4254.21 | 9779.29 | 44202.5 | +4.237 | +4.297 | H17 | H17 | 4 | 4001 | GRENAILLE-PEINT | E24-2 | ATTACHE | 1.42289 | 1.43745 | 0.00018126 | 0.000183115 | 0.00159 | 0.064968 | 0.061745 | 265
MONTANT | STEEL/E24-2 | 3993.5 | 9813.71 | 44082.2 | +3.605 | +4.382 | M7 | M7 | 4 | 4001 | GRENAILLE-PEINT | E24-2 | MONTANT | 4.17202 | 4.21472 | 0.000531468 | 0.000536907 | 0.000684 | 0.187848 | 0.181041 | 777
ATTACHE | STEEL/E24-2 | 4254.21 | 7847.79 | 44202.5 | +4.237 | +4.297 | H17 | H17 | 4 | 4001 | GRENAILLE-PEINT | E24-2 | ATTACHE | 1.42289 | 1.43745 | 0.00018126 | 0.000183115 | 0.00159 | 0.064968 | 0.061745 | 265
ATTACHE | STEEL/E24-2 | 3922.79 | 7847.79 | 44202.5 | +3.880 | +3.940 | H18 | H18 | 4 | 4001 | GRENAILLE-PEINT | E24-2 | ATTACHE | 1.42289 | 1.43745 | 0.00018126 | 0.000183115 | 0.0159 | 0.064968 | 0.061745 | 265
MONTANT | STEEL/E24-2 | 3993.5 | 7882.21 | 44082.2 | +3.605 | +4.382 | M11 | M11 | 4 | 4001 | GRENAILLE-PEINT | E24-2 | MONTANT | 4.17202 | 4.21472 | 0.000531468 | 0.000536907 | 0.000684 | 0.187848 | 0.181041 | 777
ATTACHE | STEEL/E24-2 | 4254.21 | 14499.3 | 44202.5 | +4.237 | +4.297 | H17 | H17 | 4 | 4001 | GRENAILLE-PEINT | E24-2 | ATTACHE | 1.42289 | 1.43745 | 0.00018126 | 0.000183115 | 0.00159 | 0.064968 | 0.061745 | 265
MONTANT | STEEL/E24-2 | 3993.5 | 14533.7 | 44082.2 | +3.605 | +4.382 | M7 | M7 | 4 | 4001 | GRENAILLE-PEINT | E24-2 | MONTANT | 4.17202 | 4.21472 | 0.000531468 | 0.000536907 | 0.000684 | 0.187848 | 0.181041 | 777
ATTACHE | STEEL/E24-2 | 3922.79 | 14499.3 | 44202.5 | +3.880 | +3.940 | H18 | H18 | 4 | 4001 | GRENAILLE-PEINT | E24-2 | ATTACHE | 1.42289 | 1.43745 | 0.00018126 | 0.000183115 | 0.0159 | 0.064968 | 0.061745 | 265
ATTACHE | STEEL/E24-2 | 3922.79 | 14986.3 | 44202.5 | +3.880 | +3.940 | H18 | H18 | 4 | 4001 | GRENAILLE-PEINT | E24-2 | ATTACHE | 1.42289 | 1.43745 | 0.00018126 | 0.000183115 | 0.0159 | 0.064968 | 0.061745 | 265
MONTANT | STEEL/E24-2 | 3993.5 | 15020.7 | 44082.2 | +3.605 | +4.382 | M7 | M7 | 4 | 4001 | GRENAILLE-PEINT | E24-2 | MONTANT | 4.17202 | 4.21472 | 0.000531468 | 0.000536907 | 0.000684 | 0.187848 | 0.181041 | 777
ATTACHE | STEEL/E24-2 | 4254.21 | 14986.3 | 44202.5 | +4.237 | +4.297 | H17 | H17 | 4 | 4001 | GRENAILLE-PEINT | E24-2 | ATTACHE | 1.42289 | 1.43745 | 0.00018126 | 0.000183115 | 0.00159 | 0.064968 | 0.061745 | 265
ATTACHE | STEEL/E24-2 | 4254.21 | 16859.3 | 44202.5 | +4.237 | +4.297 | H17 | H17 | 4 | 4001 | GRENAILLE-PEINT | E24-2 | ATTACHE | 1.42289 | 1.43745 | 0.00018126 | 0.000183115 | 0.00159 | 0.064968 | 0.061745 | 265
MONTANT | STEEL/E24-2 | 3993.5 | 16893.7 | 44082.2 | +3.605 | +4.382 | M7 | M7 | 4 | 4001 | GRENAILLE-PEINT | E24-2 | MONTANT | 4.17202 | 4.21472 | 0.000531468 | 0.000536907 | 0.000684 | 0.187848 | 0.181041 | 777
ATTACHE | STEEL/E24-2 | 3922.79 | 16859.3 | 44202.5 | +3.880 | +3.940 | H18 | H18 | 4 | 4001 | GRENAILLE-PEINT | E24-2 | ATTACHE | 1.42289 | 1.43745 | 0.00018126 | 0.000183115 | 0.0159 | 0.064968 | 0.061745 | 265
ATTACHE | STEEL/E24-2 | 3922.79 | 17346.3 | 44202.5 | +3.880 | +3.940 | H18 | H18 | 4 | 4001 | GRENAILLE-PEINT | E24-2 | ATTACHE | 1.42289 | 1.43745 | 0.00018126 | 0.000183115 | 0.0159 | 0.064968 | 0.061745 | 265
MONTANT | STEEL/E24-2 | 3993.5 | 17380.7 | 44082.2 | +3.605 | +4.382 | M11 | M11 | 4 | 4001 | GRENAILLE-PEINT | E24-2 | MONTANT | 4.17202 | 4.21472 | 0.000531468 | 0.000536907 | 0.000684 | 0.187848 | 0.181041 | 777
ATTACHE | STEEL/E24-2 | 4254.21 | 17346.3 | 44202.5 | +4.237 | +4.297 | H17 | H17 | 4 | 4001 | GRENAILLE-PEINT | E24-2 | ATTACHE | 1.42289 | 1.43745 | 0.00018126 | 0.000183115 | 0.00159 | 0.064968 | 0.061745 | 265
ATTACHE | STEEL/E24-2 | 5575.79 | 26185.8 | 55877.5 | +5.533 | +5.593 | H17 | H17 | 4 | 4001 | GRENAILLE-PEINT | E24-2 | ATTACHE | 1.42289 | 1.43745 | 0.00018126 | 0.000183115 | 0.0159 | 0.064968 | 0.061745 | 265
MONTANT | STEEL/E24-2 | 4744 | 26785.8 | 55757.2 | +3.880 | +5.608 | 408 | M6 | 4 | 4001 | GRENAILLE-PEINT | E24-2 | MONTANT | 9.27832 | 9.37328 | 0.00118195 | 0.00119405 | 0.000684 | 0.416088 | 0.402624 | 1728
ATTACHE | STEEL/E24-2 | 4254.21 | 26751.3 | 55877.5 | +4.237 | +4.297 | H17 | H17 | 4 | 4001 | GRENAILLE-PEINT | E24-2 | ATTACHE | 1.42289 | 1.43745 | 0.00018126 | 0.000183115 | 0.00159 | 0.064968 | 0.061745 | 265
ATTACHE | STEEL/E24-2 | 3922.79 | 26751.3 | 55877.5 | +3.880 | +3.940 | H18 | H18 | 4 | 4001 | GRENAILLE-PEINT | E24-2 | ATTACHE | 1.42289 | 1.43745 | 0.00018126 | 0.000183115 | 0.0159 | 0.064968 | 0.061745 | 265
ATTACHE | STEEL/E24-2 | 3922.79 | 26185.8 | 55877.5 | +3.880 | +3.940 | H17 | H17 | 4 | 4001 | GRENAILLE-PEINT | E24-2 | ATTACHE | 1.42289 | 1.43745 | 0.00018126 | 0.000183115 | 0.0159 | 0.064968 | 0.061745 | 265
ATTACHE | STEEL/E24-2 | 4254.21 | 26185.8 | 55877.5 | +4.237 | +4.297 | H18 | H18 | 4 | 4001 | GRENAILLE-PEINT | E24-2 | ATTACHE | 1.42289 | 1.43745 | 0.00018126 | 0.000183115 | 0.00159 | 0.064968 | 0.061745 | 265
ATTACHE | STEEL/E24-2 | 5575.79 | 26751.3 | 55877.5 | +5.533 | +5.593 | H18 | H18 | 4 | 4001 | GRENAILLE-PEINT | E24-2 | ATTACHE | 1.42289 | 1.43745 | 0.00018126 | 0.000183115 | 0.0159 | 0.064968 | 0.061745 | 265
MONTANT | STEEL/E24-2 | 5407.21 | 26468.6 | 55757.2 | +5.390 | +5.450 | 404 | M6 | 4 | 4001 | GRENAILLE-PEINT | E24-2 | MONTANT | 3.22164 | 3.25461 | 0.0004104 | 0.0004146 | 0.0036 | 0.145368 | 0.1398 | 600
MONTANT | STEEL/E24-2 | 4772.79 | 26468.6 | 55757.2 | +4.730 | +4.790 | 404 | M6 | 4 | 4001 | GRENAILLE-PEINT | E24-2 | MONTANT | 3.22164 | 3.25461 | 0.0004104 | 0.0004146 | 0.036 | 0.145368 | 0.1398 | 600
ATTACHE | STEEL/E24-2 | 5575.79 | 24037.2 | 55917.5 | +5.533 | +5.593 | H13 | H13 | 4 | 4001 | GRENAILLE-PEINT | E24-2 | ATTACHE | 1.85244 | 1.8714 | 0.00023598 | 0.000238395 | 0.0207 | 0.084168 | 0.080385 | 345
ATTACHE | STEEL/E24-2 | 3922.79 | 24037.2 | 55850 | +3.880 | +3.940 | H14 | H14 | 4 | 4001 | GRENAILLE-PEINT | E24-2 | ATTACHE | 1.7719 | 1.79004 | 0.00022572 | 0.00022803 | 0.0198 | 0.080568 | 0.07689 | 330
ATTACHE | STEEL/E24-2 | 4254.21 | 24037.2 | 55850 | +4.237 | +4.297 | H15 | H15 | 4 | 4001 | GRENAILLE-PEINT | E24-2 | ATTACHE | 1.7719 | 1.79004 | 0.00022572 | 0.00022803 | 0.00198 | 0.080568 | 0.07689 | 330
LIEN | STEEL/E24-2 | 3207.79 | 15132.8 | 4870 | +3.165 | +3.225 | L14 | L14 | 6 | 6001 | GRENAILLE-PEINT | E24-2 | LIEN | 15.0343 | 15.1882 | 0.0019152 | 0.0019348 | 0.168 | 0.673368 | 0.6524 | 2800
LIEN | STEEL/E24-2 | 3207.79 | 17262.8 | 1982.5 | +3.165 | +3.225 | L16 | L16 | 6 | 6001 | GRENAILLE-PEINT | E24-2 | LIEN | 14.5779 | 14.7271 | 0.00185706 | 0.00187606 | 0.1629 | 0.652968 | 0.632595 | 2715
BRACON | STEEL/E24-2 | 3451.32 | 17352.2 | 934.41 | +3.231 | +3.690 | W1 | W1 | 6 | 6001 | GRENAILLE-PEINT | E24-2 | BRACON | 3.15957 | 3.1919 | 0.000402492 | 0.000406612 | 0 | 0.142593 | 0.137106 | 588.439
BRACON | STEEL/E24-2 | 3451.32 | 19482.2 | 934.41 | +3.231 | +3.690 | W1 | W1 | 6 | 6001 | GRENAILLE-PEINT | E24-2 | BRACON | 3.15957 | 3.1919 | 0.000402492 | 0.000406612 | 0 | 0.142593 | 0.137106 | 588.439
LIEN | STEEL/E24-2 | 3207.79 | 19392.8 | 1982.5 | +3.165 | +3.225 | L16 | L16 | 6 | 6001 | GRENAILLE-PEINT | E24-2 | LIEN | 14.5779 | 14.7271 | 0.00185706 | 0.00187606 | 0.1629 | 0.652968 | 0.632595 | 2715
BRACON | STEEL/E24-2 | 3451.32 | 22013.5 | 934.41 | +3.231 | +3.690 | W1 | W1 | 6 | 6001 | GRENAILLE-PEINT | E24-2 | BRACON | 3.15957 | 3.1919 | 0.000402492 | 0.000406612 | 0 | 0.142593 | 0.137106 | 588.439
LIEN | STEEL/E24-2 | 3207.79 | 21924 | 1982.5 | +3.165 | +3.225 | L16 | L16 | 6 | 6001 | GRENAILLE-PEINT | E24-2 | LIEN | 14.5779 | 14.7271 | 0.00185706 | 0.00187606 | 0.1629 | 0.652968 | 0.632595 | 2715
BRACON | STEEL/E24-2 | 3451.32 | 24544.7 | 934.41 | +3.231 | +3.690 | W1 | W1 | 6 | 6001 | GRENAILLE-PEINT | E24-2 | BRACON | 3.15957 | 3.1919 | 0.000402492 | 0.000406612 | 0 | 0.142593 | 0.137106 | 588.439
BRACON | STEEL/E24-2 | 3451.32 | 29607.2 | 934.41 | +3.231 | +3.690 | W1 | W1 | 6 | 6001 | GRENAILLE-PEINT | E24-2 | BRACON | 3.15957 | 3.1919 | 0.000402492 | 0.000406612 | 0 | 0.142593 | 0.137106 | 588.439
BRACON | STEEL/E24-2 | 3451.32 | 27076 | 934.41 | +3.231 | +3.690 | W1 | W1 | 6 | 6001 | GRENAILLE-PEINT | E24-2 | BRACON | 3.15957 | 3.1919 | 0.000402492 | 0.000406612 | 0 | 0.142593 | 0.137106 | 588.439
BRACON | STEEL/E24-2 | 3451.32 | 32276 | 934.41 | +3.231 | +3.690 | W1 | W1 | 6 | 6001 | GRENAILLE-PEINT | E24-2 | BRACON | 3.15957 | 3.1919 | 0.000402492 | 0.000406612 | 0 | 0.142593 | 0.137106 | 588.439
ATTACHE | STEEL/E24-2 | 3550.18 | 20622.8 | 79090 | +3.533 | +3.593 | 398 | L40 | 7 | 7001 | GRENAILLE-PEINT | E24-2 | ATTACHE | 0.429552 | 0.433948 | 0.00005472 | 0.00005528 | 0.00048 | 0.020568 | 0.01864 | 80

# IfcBeam: L60*80*7, LISSE
In: Undefined
Description: L60*80*7; Material: STEEL/S235JR
Tekla Common - Center of gravity Z: 4991.97 mm; Center of gravity Y: 13680.5 mm; Center of gravity X: 71856.5 mm; Bottom elevation: +4.096; Top elevation: +5.888; Part mark: 893; Assembly mark: P123; Phase: 1; Class: 1011; Finish: GRENAILLE-PEINT; Grade: S235JR; Profile: L60*80*7; Name: LISSE; sets with these values: 2
Tekla Quantity - Net weight: 13.0971 kg; Gross weight: 13.0971 kg; Weight: 13.0971 kg; Net volume: 0.00166842 m3; Gross volume: 0.00166842 m3; Gross footprint area: 0.000931 m2; Area per tons: 38.4545 m2; Net surface area: 0.503642 m2; Gross area: 0.503642 m2; Height: 60 mm; Width: 80 mm; Length: 1792.07 mm; sets with these values: 2
BaseQuantities - Length: 1792.07 mm; OuterSurfaceArea: 0.503642 m2; NetVolume: 0.00166842 m3; NetWeight: 13.0971 kg

# IfcBeam: L70*50*6 (6)
In: Undefined
Description: L70*50*6; Material: STEEL/E24-2
Tekla Common - Center of gravity Z: 3170 mm; Bottom elevation: +3.020; Top elevation: +3.320; Part mark: H92; Assembly mark: H92; Phase: 2; Class: 2003; Finish: GRENAILLE-PEINT; Grade: E24-2; Profile: L70*50*6; Name: ATTACHE; sets with these values: 2
Tekla Quantity - Net weight: 1.61081 kg; Gross weight: 1.62023 kg; Weight: 1.62023 kg; Net volume: 0.000205199 m3; Gross volume: 0.000206399 m3; Gross footprint area: 0.000684 m2; Area per tons: 42.5863 m2; Net surface area: 0.0733677 m2; Gross area: 0.0689997 m2; Height: 70 mm; Width: 50 mm; Length: 299.999 mm; sets with these values: 2
BaseQuantities - Length: 299.999 mm; OuterSurfaceArea: 0.0689997 m2; NetVolume: 0.000205199 m3; NetWeight: 1.61081 kg
Name | Center of gravity Y (mm) | Center of gravity X (mm)
ATTACHE | 11052 | 8508.05
ATTACHE | 17454.6 | 5431.97
ATTACHE | 32393.4 | 2472.27
ATTACHE | 27190.4 | 2900.55
ATTACHE | 22122.6 | 3923.29
ATTACHE | 13186.7 | 7340.42

# IfcBeam: L70*7 (412)
In: Undefined
Description: L70*7
Tekla Common - Profile: L70*7; sets with these values: 2
Tekla Quantity - Area per tons: 36.8614 m2; Height: 70 mm; Width: 70 mm; sets with these values: 2
Name | Material | Center of gravity Z (mm) | Center of gravity Y (mm) | Center of gravity X (mm) | Bottom elevation | Top elevation | Part mark | Assembly mark | Phase | Class | Finish | Grade | Name | Net weight (kg) = NetWeight (kg) | Gross weight (kg) = Weight (kg) | Net volume (m3) = NetVolume (m3) | Gross volume (m3) | Gross footprint area (m2) | Net surface area (m2) | Gross area (m2) = OuterSurfaceArea (m2) | Tekla Quantity, Length (mm) = BaseQuantities, Length (mm)
ATTACHE | STEEL/E24-2 | 1669.92 | 19560.1 | 74310 | +1.620 | +1.690 | H43 | H43 | 7 | 7001 | GRENAILLE-PEINT | E24-2 | ATTACHE | 1.82709 | 1.84475 | 0.00023275 | 0.000235 | 0.0175 | 0.071862 | 0.068 | 250
ATTACHE | STEEL/E24-2 | 129.921 | 19560.1 | 74310 | +0.080 | +0.150 | H43 | H43 | 7 | 7001 | GRENAILLE-PEINT | E24-2 | ATTACHE | 1.82709 | 1.84475 | 0.00023275 | 0.000235 | 0.0175 | 0.071862 | 0.068 | 250
ATTACHE | STEEL/E24-2 | 82.1015 | 19562.9 | 78225.8 | +0.030 | +0.100 | 670 | P132 | 7 | 7001 | GRENAILLE-PEINT | E24-2 | ATTACHE | 1.34641 | 1.60493 | 0.000171517 | 0.00020445 | 0.0144225 | 0.0538505 | 0.05916 | 217.5
ATTACHE | STEEL/E24-2 | 1732.1 | 19562.9 | 78225.8 | +1.680 | +1.750 | 670 | P132 | 7 | 7001 | GRENAILLE-PEINT | E24-2 | ATTACHE | 1.34641 | 1.60493 | 0.000171517 | 0.00020445 | 0.0144225 | 0.0538505 | 0.05916 | 217.5
ATTACHE | STEEL/E24-2 | 3098.08 | 19562.9 | 78225.8 | +3.046 | +3.116 | 670 | P132 | 7 | 7001 | GRENAILLE-PEINT | E24-2 | ATTACHE | 1.34641 | 1.60493 | 0.000171517 | 0.00020445 | 0.0144225 | 0.0538505 | 0.05916 | 217.5
 | STEEL/E24-2 | 3468.43 | 24452.4 | 3214.92 | +3.438 | +3.498 | 668 | S88 | 6 | 6001 | GRENAILLE-PEINT | E24-2 |  | 0.438501 | 0.44274 | 0.00005586 | 0.0000564 | 0.000931 | 0.018662 | 0.01632 | 60
 | STEEL/E24-2 | 3675.64 | 15184.9 | 1116.61 | +3.624 | +3.697 | 669 | H42 | 6 | 6001 | GRENAILLE-PEINT | E24-2 |  | 0.584668 | 0.59032 | 0.00007448 | 0.0000752 | 0 | 0.024262 | 0.02176 | 80
 | STEEL/E24-2 | 3468.43 | 15129.9 | 629.921 | +3.438 | +3.498 | 668 | S8 | 6 | 6001 | GRENAILLE-PEINT | E24-2 |  | 0.438501 | 0.44274 | 0.00005586 | 0.0000564 | 0.000931 | 0.018662 | 0.01632 | 60
 | STEEL/E24-2 | 3140.08 | 14801.6 | 629.921 | +3.120 | +3.190 | 668 | L87 | 6 | 6001 | GRENAILLE-PEINT | E24-2 |  | 0.438501 | 0.44274 | 0.00005586 | 0.0000564 | 0.00042 | 0.018662 | 0.01632 | 60
 | STEEL/E24-2 | 3270 | 15184.9 | 710.079 | +3.240 | +3.300 | 668 | S8 | 6 | 6001 | GRENAILLE-PEINT | E24-2 |  | 0.438501 | 0.44274 | 0.00005586 | 0.0000564 | 0.000931 | 0.018662 | 0.01632 | 60
 | STEEL/E24-2 | 3675.64 | 10924.9 | 1116.61 | +3.624 | +3.697 | 669 | H42 | 6 | 6001 | GRENAILLE-PEINT | E24-2 |  | 0.584668 | 0.59032 | 0.00007448 | 0.0000752 | 0 | 0.024262 | 0.02176 | 80
 | STEEL/E24-2 | 3270 | 10924.9 | 710.079 | +3.240 | +3.300 | 668 | S8 | 6 | 6001 | GRENAILLE-PEINT | E24-2 |  | 0.438501 | 0.44274 | 0.00005586 | 0.0000564 | 0.000931 | 0.018662 | 0.01632 | 60
ATTACHE | STEEL/E24-2 | 3209.92 | 10910.1 | 3467.5 | +3.160 | +3.230 | H40 | H40 | 6 | 6001 | GRENAILLE-PEINT | E24-2 | ATTACHE | 1.49821 | 1.51269 | 0.000190855 | 0.0001927 | 0.01435 | 0.059262 | 0.05576 | 205
ATTACHE | STEEL/E24-2 | 3209.92 | 13040.1 | 3467.5 | +3.160 | +3.230 | H40 | H40 | 6 | 6001 | GRENAILLE-PEINT | E24-2 | ATTACHE | 1.49821 | 1.51269 | 0.000190855 | 0.0001927 | 0.01435 | 0.059262 | 0.05576 | 205
 | STEEL/E24-2 | 3675.64 | 13054.9 | 1116.61 | +3.624 | +3.697 | 669 | H42 | 6 | 6001 | GRENAILLE-PEINT | E24-2 |  | 0.584668 | 0.59032 | 0.00007448 | 0.0000752 | 0 | 0.024262 | 0.02176 | 80
 | STEEL/E24-2 | 3270 | 13054.9 | 710.079 | +3.240 | +3.300 | 668 | S7 | 6 | 6001 | GRENAILLE-PEINT | E24-2 |  | 0.438501 | 0.44274 | 0.00005586 | 0.0000564 | 0.000931 | 0.018662 | 0.01632 | 60
 | STEEL/E24-2 | 3140.08 | 13448.4 | 629.921 | +3.120 | +3.190 | 668 | L87 | 6 | 6001 | GRENAILLE-PEINT | E24-2 |  | 0.438501 | 0.44274 | 0.00005586 | 0.0000564 | 0.00042 | 0.018662 | 0.01632 | 60
 | STEEL/E24-2 | 3468.43 | 10869.9 | 629.921 | +3.438 | +3.498 | 668 | S8 | 6 | 6001 | GRENAILLE-PEINT | E24-2 |  | 0.438501 | 0.44274 | 0.00005586 | 0.0000564 | 0.000931 | 0.018662 | 0.01632 | 60
 | STEEL/E24-2 | 3140.08 | 10541.6 | 629.921 | +3.120 | +3.190 | 668 | L87 | 6 | 6001 | GRENAILLE-PEINT | E24-2 |  | 0.438501 | 0.44274 | 0.00005586 | 0.0000564 | 0.00042 | 0.018662 | 0.01632 | 60
 | STEEL/E24-2 | 3140.08 | 13448.4 | 3294.92 | +3.120 | +3.190 | 668 | L86 | 6 | 6001 | GRENAILLE-PEINT | E24-2 |  | 0.438501 | 0.44274 | 0.00005586 | 0.0000564 | 0.00042 | 0.018662 | 0.01632 | 60
 | STEEL/E24-2 | 3468.43 | 10869.9 | 3294.92 | +3.438 | +3.498 | 668 | S6 | 6 | 6001 | GRENAILLE-PEINT | E24-2 |  | 0.438501 | 0.44274 | 0.00005586 | 0.0000564 | 0.000931 | 0.018662 | 0.01632 | 60
 | STEEL/E24-2 | 3140.08 | 10541.6 | 3294.92 | +3.120 | +3.190 | 668 | L86 | 6 | 6001 | GRENAILLE-PEINT | E24-2 |  | 0.438501 | 0.44274 | 0.00005586 | 0.0000564 | 0.00042 | 0.018662 | 0.01632 | 60
ATTACHE | STEEL/E24-2 | 4258.08 | 27859.9 | 54410 | +4.238 | +4.308 | 673 | L19 | 4 | 4001 | GRENAILLE-PEINT | E24-2 | ATTACHE | 0.438501 | 0.44274 | 0.0000558601 | 0.0000564001 | 0.00042 | 0.018662 | 0.01632 | 60.0001
ATTACHE | STEEL/E24-2 | 5572.92 | 27859.9 | 55947.5 | +5.523 | +5.593 | H41 | H41 | 4 | 4001 | GRENAILLE-PEINT | E24-2 | ATTACHE | 2.08288 | 2.10302 | 0.000265335 | 0.0002679 | 0.01995 | 0.081662 | 0.07752 | 285
CV | STEEL/E24-2 | 4738.93 | 49740.1 | 28042.6 | +4.685 | +4.763 | 675 | W6 | 3 | 3003 | GRENAILLE-PEINT | E24-2 | CV | 0.511584 | 0.51653 | 0.00006517 | 0.0000658 | 0 | 0.021462 | 0.01904 | 70
CV | STEEL/E24-2 | 4489.76 | 49740.1 | 30082.6 | +4.436 | +4.514 | 675 | W6 | 3 | 3003 | GRENAILLE-PEINT | E24-2 | CV | 0.511584 | 0.51653 | 0.00006517 | 0.0000658 | 0 | 0.021462 | 0.01904 | 70
CV | STEEL/E24-2 | 4240.59 | 49740.1 | 32122.6 | +4.187 | +4.265 | 675 | W6 | 3 | 3003 | GRENAILLE-PEINT | E24-2 | CV | 0.511584 | 0.51653 | 0.00006517 | 0.0000658 | 0 | 0.021462 | 0.01904 | 70
LISSE | STEEL/E24-2 | 3352.84 | -773.824 | 43214.3 | +3.330 | +3.405 | 664 | L80 | 3 | 3003 | GRENAILLE-PEINT | E24-2 | LISSE | 14.364 | 14.5029 | 0.00182981 | 0.0018475 | 0 | 0.552181 | 0.534596 | 1965.43
LISSE | STEEL/E24-2 | 3357.66 | -1014.91 | 41263.4 | +3.335 | +3.410 | 661 | L80 | 3 | 3003 | GRENAILLE-PEINT | E24-2 | LISSE | 14.0801 | 14.2162 | 0.00179365 | 0.00181099 | 0 | 0.541304 | 0.52403 | 1926.58
LISSE | STEEL/E24-2 | 3362 | -1232.14 | 39329.2 | +3.340 | +3.414 | 661 | L80 | 3 | 3003 | GRENAILLE-PEINT | E24-2 | LISSE | 14.0801 | 14.2162 | 0.00179365 | 0.00181098 | 0 | 0.541304 | 0.52403 | 1926.58
LISSE | STEEL/E24-2 | 3365.92 | -1428.1 | 37392.8 | +3.344 | +3.418 | 661 | L80 | 3 | 3003 | GRENAILLE-PEINT | E24-2 | LISSE | 14.0801 | 14.2162 | 0.00179364 | 0.00181098 | 0 | 0.541304 | 0.524029 | 1926.58
LISSE | STEEL/E24-2 | 3369.42 | -1602.75 | 35454.3 | +3.348 | +3.421 | 661 | L80 | 3 | 3003 | GRENAILLE-PEINT | E24-2 | LISSE | 14.0801 | 14.2162 | 0.00179364 | 0.00181098 | 0 | 0.541304 | 0.524029 | 1926.58
LISSE | STEEL/E24-2 | 3372.5 | -1756.76 | 33504.1 | +3.351 | +3.424 | 663 | L80 | 3 | 3003 | GRENAILLE-PEINT | E24-2 | LISSE | 14.225 | 14.3626 | 0.00181211 | 0.00182962 | 0 | 0.546857 | 0.529423 | 1946.41
LISSE | STEEL/E24-2 | 3375.15 | -1889.43 | 31550 | +3.354 | +3.426 | 662 | L115 | 3 | 3003 | GRENAILLE-PEINT | E24-2 | LISSE | 14.1145 | 14.251 | 0.00179803 | 0.00181541 | 0 | 0.542623 | 0.525311 | 1931.29
LISSE | STEEL/E24-2 | 3377.36 | -1999.93 | 29604.5 | +3.356 | +3.428 | 661 | L115 | 3 | 3003 | GRENAILLE-PEINT | E24-2 | LISSE | 14.0801 | 14.2162 | 0.00179364 | 0.00181098 | 0 | 0.541303 | 0.524029 | 1926.58
LISSE | STEEL/E24-2 | 3379.14 | -2088.93 | 27659.9 | +3.358 | +3.430 | 661 | L115 | 3 | 3003 | GRENAILLE-PEINT | E24-2 | LISSE | 14.0836 | 14.2198 | 0.00179409 | 0.00181143 | 0 | 0.541438 | 0.52416 | 1927.06
LISSE | STEEL/E24-2 | 3380.49 | -2156.54 | 25714.5 | +3.360 | +3.431 | 660 | L115 | 3 | 3003 | GRENAILLE-PEINT | E24-2 | LISSE | 14.0801 | 14.2162 | 0.00179364 | 0.00181098 | 0 | 0.541303 | 0.524029 | 1926.58
LISSE | STEEL/E24-2 | 3381.42 | -2202.74 | 23769 | +3.361 | +3.432 | 660 | L115 | 3 | 3003 | GRENAILLE-PEINT | E24-2 | LISSE | 14.076 | 14.2121 | 0.00179312 | 0.00181045 | 0 | 0.541146 | 0.523876 | 1926.02
LISSE | STEEL/E24-2 | 3381.92 | -2228.12 | 21743.1 | +3.362 | +3.432 | 659 | L115 | 3 | 3003 | GRENAILLE-PEINT | E24-2 | LISSE | 15.2494 | 15.3968 | 0.0019426 | 0.00196138 | 0 | 0.586103 | 0.567548 | 2086.58
SOLIVE | STEEL/S235JR | 5760 | 162.081 | 20485.1 | +5.705 | +5.815 | 655 | S2 | 2 | 2007 | GALVANISE | S235JR | SOLIVE | 0.803918 | 0.81169 | 0.00010241 | 0.0001034 | 0.000931 | 0.032662 | 0.02992 | 110
SOLIVE | STEEL/S235JR | 5760 | 5036.58 | 20485.1 | +5.705 | +5.815 | 655 | S1 | 2 | 2007 | GALVANISE | S235JR | SOLIVE | 0.803918 | 0.81169 | 0.00010241 | 0.0001034 | 0.000931 | 0.032662 | 0.02992 | 110
SOLIVE | STEEL/S235JR | 5760 | 4876.42 | 20485.1 | +5.705 | +5.815 | 655 | S1 | 2 | 2007 | GALVANISE | S235JR | SOLIVE | 0.803918 | 0.81169 | 0.00010241 | 0.0001034 | 0.000931 | 0.032662 | 0.02992 | 110
SOLIVE | STEEL/S235JR | 5760 | 9946.58 | 20485.1 | +5.705 | +5.815 | 655 | S1 | 2 | 2007 | GALVANISE | S235JR | SOLIVE | 0.803918 | 0.81169 | 0.00010241 | 0.0001034 | 0.000931 | 0.032662 | 0.02992 | 110
SOLIVE | STEEL/S235JR | 5760 | 9786.42 | 20485.1 | +5.705 | +5.815 | 655 | S1 | 2 | 2007 | GALVANISE | S235JR | SOLIVE | 0.803918 | 0.81169 | 0.00010241 | 0.0001034 | 0.000931 | 0.032662 | 0.02992 | 110
SOLIVE | STEEL/S235JR | 5760 | 12593.6 | 20485.1 | +5.705 | +5.815 | 655 | S1 | 2 | 2007 | GALVANISE | S235JR | SOLIVE | 0.803918 | 0.81169 | 0.00010241 | 0.0001034 | 0.000931 | 0.032662 | 0.02992 | 110
SOLIVE | STEEL/S235JR | 5760 | 12433.4 | 20485.1 | +5.705 | +5.815 | 655 | S1 | 2 | 2007 | GALVANISE | S235JR | SOLIVE | 0.803918 | 0.81169 | 0.00010241 | 0.0001034 | 0.000931 | 0.032662 | 0.02992 | 110
SOLIVE | STEEL/S235JR | 5760 | 17153.4 | 20485.1 | +5.705 | +5.815 | 655 | S1 | 2 | 2007 | GALVANISE | S235JR | SOLIVE | 0.803918 | 0.81169 | 0.00010241 | 0.0001034 | 0.000931 | 0.032662 | 0.02992 | 110
SOLIVE | STEEL/S235JR | 5760 | 17313.6 | 20485.1 | +5.705 | +5.815 | 655 | S1 | 2 | 2007 | GALVANISE | S235JR | SOLIVE | 0.803918 | 0.81169 | 0.00010241 | 0.0001034 | 0.000931 | 0.032662 | 0.02992 | 110
SOLIVE | STEEL/S235JR | 5760 | 21986.6 | 20485.1 | +5.705 | +5.815 | 655 | S1 | 2 | 2007 | GALVANISE | S235JR | SOLIVE | 0.803918 | 0.81169 | 0.00010241 | 0.0001034 | 0.000931 | 0.032662 | 0.02992 | 110
SOLIVE | STEEL/S235JR | 5760 | 21826.4 | 20485.1 | +5.705 | +5.815 | 655 | S1 | 2 | 2007 | GALVANISE | S235JR | SOLIVE | 0.803918 | 0.81169 | 0.00010241 | 0.0001034 | 0.000931 | 0.032662 | 0.02992 | 110
SOLIVE | STEEL/S235JR | 5760 | 27026.4 | 20485.1 | +5.705 | +5.815 | 655 | S1 | 2 | 2007 | GALVANISE | S235JR | SOLIVE | 0.803918 | 0.81169 | 0.00010241 | 0.0001034 | 0.000931 | 0.032662 | 0.02992 | 110
SOLIVE | STEEL/S235JR | 5760 | 27186.6 | 20485.1 | +5.705 | +5.815 | 655 | S1 | 2 | 2007 | GALVANISE | S235JR | SOLIVE | 0.803918 | 0.81169 | 0.00010241 | 0.0001034 | 0.000931 | 0.032662 | 0.02992 | 110
SOLIVE | STEEL/S235JR | 5760 | 32386.6 | 20485.1 | +5.705 | +5.815 | 655 | S1 | 2 | 2007 | GALVANISE | S235JR | SOLIVE | 0.803918 | 0.81169 | 0.00010241 | 0.0001034 | 0.000931 | 0.032662 | 0.02992 | 110
SOLIVE | STEEL/S235JR | 5760 | 32226.4 | 20485.1 | +5.705 | +5.815 | 655 | S1 | 2 | 2007 | GALVANISE | S235JR | SOLIVE | 0.803918 | 0.81169 | 0.00010241 | 0.0001034 | 0.000931 | 0.032662 | 0.02992 | 110
