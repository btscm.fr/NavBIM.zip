Properties of the parts of a building model (IFC2X3), part 12 of 32

# IfcBeam: PL20*110, CALAGE
BaseQuantities - Length: 210 mm; OuterSurfaceArea: 0.059 m2; NetVolume: 0.000462 m3; NetWeight: 3.6267 kg

# IfcBeam: PL20*160 (36)
In: Undefined
Description: PL20*160; Material: STEEL/E36-3
Tekla Common - Finish: GRENAILLE-PEINT; Grade: E36-3; Profile: PL20*160; Name: PLATINE; sets with these values: 2
Tekla Quantity - Gross footprint area: 0.0032 m2; Height: 160 mm; Width: 20 mm; sets with these values: 2
Name | BaseQuantities, Length (mm) = Tekla Quantity, Length (mm) | OuterSurfaceArea (m2) = Net surface area (m2) = Gross area (m2) | NetVolume (m3) = Net volume (m3) = Gross volume (m3) | NetWeight (kg) = Net weight (kg) = Gross weight (kg) = Weight (kg) | Center of gravity Z (mm) | Center of gravity Y (mm) | Center of gravity X (mm) | Bottom elevation | Top elevation | Part mark | Assembly mark | Phase | Class | Area per tons (m2)
PLATINE | 440 | 0.1648 | 0.001408 | 11.0528 | 4088.5 | 19434.9 | 20850 | +3.868 | +4.308 | 315 | N49 | 2 | 2006 | 14.9102
PLATINE | 440 | 0.1648 | 0.001408 | 11.0528 | 4088.5 | 40234.9 | 20850 | +3.868 | +4.308 | 315 | N44 | 2 | 2006 | 14.9102
PLATINE | 320 | 0.1216 | 0.001024 | 8.0384 | 5741.5 | 7664.3 | 20850 | +5.581 | +5.901 | 308 | N49 | 2 | 2006 | 15.1274
PLATINE | 320 | 0.1216 | 0.001024 | 8.0384 | 5741.5 | 285 | 67550 | +5.581 | +5.901 | 308 | N14 | 1 | 1006 | 15.1274
PLATINE | 450 | 0.1684 | 0.00144 | 11.304 | 4088.5 | 285 | 67550 | +3.863 | +4.313 | 314 | N14 | 1 | 1006 | 14.8974
PLATINE | 450 | 0.1684 | 0.00144 | 11.304 | 4088.5 | 7635.7 | 67550 | +3.863 | +4.313 | 314 | N14 | 1 | 1006 | 14.8974
PLATINE | 440 | 0.1648 | 0.001408 | 11.0528 | 4088.5 | 19434.9 | 67550 | +3.868 | +4.308 | 315 | N12 | 1 | 1006 | 14.9102
PLATINE | 440 | 0.1648 | 0.001408 | 11.0528 | 4088.5 | 40234.9 | 67550 | +3.869 | +4.309 | 309 | N7 | 1 | 1006 | 14.9102
PLATINE | 450 | 0.1684 | 0.00144 | 11.304 | 4088.5 | 61035.7 | 67550 | +3.864 | +4.314 | 314 | N13 | 1 | 1006 | 14.8974
PLATINE | 320 | 0.1216 | 0.001024 | 8.0384 | 5741.5 | 61064.3 | 67550 | +5.582 | +5.902 | 308 | N17 | 1 | 1006 | 15.1274
PLATINE | 320 | 0.1216 | 0.001024 | 8.0384 | 5741.5 | 7664.3 | 67550 | +5.581 | +5.901 | 308 | N12 | 1 | 1006 | 15.1274
PLATINE | 320 | 0.1216 | 0.001024 | 8.0384 | 5741.5 | 285 | 55875 | +5.581 | +5.901 | 308 | N16 | 1 | 1006 | 15.1274
PLATINE | 450 | 0.1684 | 0.00144 | 11.304 | 4088.5 | 285 | 55875 | +3.863 | +4.313 | 314 | N16 | 1 | 1006 | 14.8974
PLATINE | 450 | 0.1684 | 0.00144 | 11.304 | 4088.5 | 7635.7 | 55875 | +3.863 | +4.313 | 314 | N16 | 1 | 1006 | 14.8974
PLATINE | 440 | 0.1648 | 0.001408 | 11.0528 | 4088.5 | 19434.9 | 55875 | +3.868 | +4.308 | 315 | N47 | 1 | 1006 | 14.9102
PLATINE | 440 | 0.1648 | 0.001408 | 11.0528 | 4088.5 | 40234.9 | 55875 | +3.869 | +4.309 | 315 | N8 | 1 | 1006 | 14.9102
PLATINE | 450 | 0.1684 | 0.00144 | 11.304 | 4088.5 | 61035.7 | 55875 | +3.864 | +4.314 | 314 | N13 | 1 | 1006 | 14.8974
PLATINE | 320 | 0.1216 | 0.001024 | 8.0384 | 5741.5 | 61064.3 | 55875 | +5.582 | +5.902 | 308 | N38 | 1 | 1006 | 15.1274
PLATINE | 320 | 0.1216 | 0.001024 | 8.0384 | 5741.5 | 7664.3 | 55875 | +5.581 | +5.901 | 308 | N47 | 1 | 1006 | 15.1274
PLATINE | 440 | 0.1648 | 0.001408 | 11.0528 | 4088.5 | 19434.9 | 32525 | +3.868 | +4.308 | 315 | N48 | 3 | 3006 | 14.9102
PLATINE | 440 | 0.1648 | 0.001408 | 11.0528 | 4088.5 | 40234.9 | 32525 | +3.869 | +4.309 | 315 | N40 | 3 | 3006 | 14.9102
PLATINE | 320 | 0.1216 | 0.001024 | 8.0384 | 5741.5 | 7664.3 | 32525 | +5.581 | +5.901 | 308 | N48 | 3 | 3006 | 15.1274
PLATINE | 320 | 0.1216 | 0.001024 | 8.0384 | 5741.5 | 82 | 32525 | +5.581 | +5.901 | 307 | N15 | 3 | 3006 | 15.1274
PLATINE | 450 | 0.1684 | 0.00144 | 11.304 | 4088.5 | 82 | 32525 | +3.863 | +4.313 | 313 | N15 | 3 | 3006 | 14.8974
PLATINE | 450 | 0.1684 | 0.00144 | 11.304 | 4088.5 | 7635.7 | 32525 | +3.863 | +4.313 | 314 | N15 | 3 | 3006 | 14.8974
PLATINE | 450 | 0.1684 | 0.00144 | 11.304 | 4088.5 | 285 | 44200 | +3.863 | +4.313 | 314 | N16 | 1 | 1006 | 14.8974
PLATINE | 450 | 0.1684 | 0.00144 | 11.304 | 4088.5 | 7635.7 | 20850 | +3.863 | +4.313 | 314 | N18 | 2 | 2006 | 14.8974
PLATINE | 450 | 0.1684 | 0.00144 | 11.304 | 4088.5 | 82 | 20850 | +3.863 | +4.313 | 313 | N18 | 2 | 2006 | 14.8974
PLATINE | 320 | 0.1216 | 0.001024 | 8.0384 | 5741.5 | 82 | 20850 | +5.581 | +5.901 | 307 | N18 | 2 | 2006 | 15.1274
PLATINE | 320 | 0.1216 | 0.001024 | 8.0384 | 5741.5 | 285 | 44200 | +5.581 | +5.901 | 308 | N16 | 1 | 1006 | 15.1274
PLATINE | 450 | 0.1684 | 0.00144 | 11.304 | 4088.5 | 7635.7 | 44200 | +3.863 | +4.313 | 314 | N16 | 1 | 1006 | 14.8974
PLATINE | 440 | 0.1648 | 0.001408 | 11.0528 | 4088.5 | 19434.9 | 44200 | +3.868 | +4.308 | 315 | N47 | 1 | 1006 | 14.9102
PLATINE | 440 | 0.1648 | 0.001408 | 11.0528 | 4088.5 | 40234.9 | 44200 | +3.869 | +4.309 | 315 | N8 | 1 | 1006 | 14.9102
PLATINE | 450 | 0.1684 | 0.00144 | 11.304 | 4088.5 | 61035.7 | 44200 | +3.864 | +4.314 | 314 | N42 | 1 | 1006 | 14.8974
PLATINE | 320 | 0.1216 | 0.001024 | 8.0384 | 5741.5 | 61064.3 | 44200 | +5.582 | +5.902 | 308 | N39 | 1 | 1006 | 15.1274
PLATINE | 320 | 0.1216 | 0.001024 | 8.0384 | 5741.5 | 7664.3 | 44200 | +5.581 | +5.901 | 308 | N47 | 1 | 1006 | 15.1274

# IfcBeam: PL20*200, PLATINE
In: Undefined
Description: PL20*200; Material: STEEL/E24-2
Tekla Common - Center of gravity Z: 4210.45 mm; Center of gravity Y: 61050 mm; Center of gravity X: 44055 mm; Bottom elevation: +3.999; Top elevation: +4.422; Part mark: 304; Assembly mark: K1; Phase: 3; Class: 3005; Finish: GRENAILLE-PEINT; Grade: E24-2; Profile: PL20*200; Name: PLATINE; sets with these values: 2
Tekla Quantity - Net weight: 13.2813 kg; Gross weight: 13.2813 kg; Weight: 13.2813 kg; Net volume: 0.00169189 m3; Gross volume: 0.00169189 m3; Gross footprint area: 0.004 m2; Area per tons: 14.6151 m2; Net surface area: 0.194108 m2; Gross area: 0.194108 m2; Height: 200 mm; Width: 20 mm; Length: 422.973 mm; sets with these values: 2
BaseQuantities - Length: 422.973 mm; OuterSurfaceArea: 0.194108 m2; NetVolume: 0.00169189 m3; NetWeight: 13.2813 kg

# IfcBeam: PL20*300, PLATINE
In: Undefined
Description: PL20*300; Material: STEEL/E24-2
Tekla Common - Center of gravity Z: 5593.09 mm; Center of gravity Y: 61050 mm; Center of gravity X: 32735 mm; Bottom elevation: +5.393; Top elevation: +5.793; Part mark: 305; Assembly mark: H76; Phase: 3; Class: 3005; Finish: GRENAILLE-PEINT; Grade: E24-2; Profile: PL20*300; Name: PLATINE; sets with these values: 2
Tekla Quantity - Net weight: 18.84 kg; Gross weight: 18.84 kg; Weight: 18.84 kg; Net volume: 0.0024 m3; Gross volume: 0.0024 m3; Gross footprint area: 0.006 m2; Area per tons: 14.2251 m2; Net surface area: 0.268 m2; Gross area: 0.268 m2; Height: 300 mm; Width: 20 mm; Length: 400 mm; sets with these values: 2
BaseQuantities - Length: 400 mm; OuterSurfaceArea: 0.268 m2; NetVolume: 0.0024 m3; NetWeight: 18.84 kg

# IfcBeam: PL200*20 (2)
In: Undefined
Description: PL200*20; Material: STEEL/E24-2
Tekla Common - Center of gravity Z: -390 mm; Center of gravity X: 20300 mm; Bottom elevation: -0.400; Top elevation: -0.380; Part mark: 312; Assembly mark: H78; Phase: 2; Class: 2002; Finish: GRENAILLE-PEINT; Grade: E24-2; Profile: PL200*20; Name: ATTACHE; sets with these values: 2
Tekla Quantity - Net weight: 15.5744 kg; Gross weight: 15.5744 kg; Weight: 15.5744 kg; Net volume: 0.001984 m3; Gross volume: 0.001984 m3; Gross footprint area: 0.0992 m2; Area per tons: 14.5264 m2; Net surface area: 0.22624 m2; Gross area: 0.22624 m2; Height: 200 mm; Width: 20 mm; Length: 496 mm; sets with these values: 2
BaseQuantities - Length: 496 mm; OuterSurfaceArea: 0.22624 m2; NetVolume: 0.001984 m3; NetWeight: 15.5744 kg
Name | Center of gravity Y (mm)
ATTACHE | 10930
ATTACHE | 48525

# IfcBeam: PL200*300, CHEMIN_CABLES
In: Undefined
Description: PL200*300; Material: STEEL/E24-2
Tekla Common - Center of gravity Z: 3372.96 mm; Center of gravity Y: 20013.7 mm; Center of gravity X: 78895 mm; Bottom elevation: +3.273; Top elevation: +3.473; Part mark: Z13; Assembly mark: Z13; Phase: 7; Class: 6; Grade: E24-2; Profile: PL200*300; Name: CHEMIN_CABLES; sets with these values: 2
Tekla Quantity - Net weight: 3053.94 kg; Gross weight: 3053.94 kg; Weight: 3053.94 kg; Net volume: 0.389036 m3; Gross volume: 0.389036 m3; Gross footprint area: 1.94518 m2; Area per tons: 2.16244 m2; Net surface area: 6.60394 m2; Gross area: 6.60394 m2; Height: 300 mm; Width: 200 mm; Length: 6483.94 mm; sets with these values: 2
BaseQuantities - Length: 6483.94 mm; OuterSurfaceArea: 6.60394 m2; NetVolume: 0.389036 m3; NetWeight: 3053.94 kg

# IfcBeam: PL200*6
In: Undefined
Description: PL200*6; Material: STEEL/S235JR
Tekla Common - Center of gravity Z: 5891 mm; Center of gravity Y: 13550 mm; Center of gravity X: 71814 mm; Bottom elevation: +5.888; Top elevation: +5.894; Part mark: 352; Assembly mark: P123; Phase: 1; Class: 1011; Finish: GRENAILLE-PEINT; Grade: S235JR; Profile: PL200*6; sets with these values: 2
Tekla Quantity - Net weight: 1.07388 kg; Gross weight: 1.07388 kg; Weight: 1.07388 kg; Net volume: 0.0001368 m3; Gross volume: 0.0001368 m3; Gross footprint area: 0.0228 m2; Area per tons: 45.9716 m2; Net surface area: 0.049368 m2; Gross area: 0.049368 m2; Height: 200 mm; Width: 6 mm; Length: 114 mm; sets with these values: 2
BaseQuantities - Length: 114 mm; OuterSurfaceArea: 0.049368 m2; NetVolume: 0.0001368 m3; NetWeight: 1.07388 kg

# IfcBeam: PL210*10 (3)
In: Undefined
Description: PL210*10; Material: STEEL/E24-2
Tekla Common - Center of gravity Z: 5955 mm; Center of gravity Y: 49895 mm; Bottom elevation: +5.950; Top elevation: +5.960; Part mark: 224; Phase: 3; Class: 3003; Finish: GRENAILLE-PEINT; Grade: E24-2; Profile: PL210*10; Name: LISSE; sets with these values: 2
Tekla Quantity - Net weight: 3.46185 kg; Gross weight: 3.46185 kg; Weight: 3.46185 kg; Net volume: 0.000441 m3; Gross volume: 0.000441 m3; Gross footprint area: 0.0441 m2; Area per tons: 27.9042 m2; Net surface area: 0.0966 m2; Gross area: 0.0966 m2; Height: 210 mm; Width: 10 mm; Length: 210 mm; sets with these values: 2
BaseQuantities - Length: 210 mm; OuterSurfaceArea: 0.0966 m2; NetVolume: 0.000441 m3; NetWeight: 3.46185 kg
Name | Center of gravity X (mm) | Assembly mark
LISSE | 28045 | L2
LISSE | 30085 | L1
LISSE | 32125 | L3

# IfcBeam: PL210*6 (11)
In: Undefined
Description: PL210*6
Tekla Common - Phase: 1; Finish: GRENAILLE-PEINT; Profile: PL210*6; sets with these values: 2
Tekla Quantity - Height: 210 mm; Width: 6 mm; sets with these values: 2
Name | Material | Center of gravity Z (mm) | Center of gravity Y (mm) | Center of gravity X (mm) | Bottom elevation | Top elevation | Part mark | Assembly mark | Class | Grade | Net weight (kg) = Gross weight (kg) = Weight (kg) = NetWeight (kg) | Net volume (m3) = Gross volume (m3) = NetVolume (m3) | Gross footprint area (m2) | Area per tons (m2) | Net surface area (m2) = Gross area (m2) = OuterSurfaceArea (m2) | Tekla Quantity, Length (mm) = BaseQuantities, Length (mm)
 | STEEL/E24-2 | 5891 | 14730 | 71815 | +5.888 | +5.894 | 326 | M4 | 1007 | E24-2 | 1.02866 | 0.00013104 | 0.02184 | 46.1258 | 0.047448 | 104
 | STEEL/S235JR | 5897 | 14730 | 71812 | +5.894 | +5.900 | 342 | L10 | 1003 | S235JR | 1.14736 | 0.00014616 | 0.02436 | 45.8724 | 0.052632 | 116
 | STEEL/E24-2 | 5891 | 19450 | 71815 | +5.888 | +5.894 | 326 | M1 | 1007 | E24-2 | 1.02866 | 0.00013104 | 0.02184 | 46.1258 | 0.047448 | 104
 | STEEL/E24-2 | 5891 | 22050 | 71815 | +5.888 | +5.894 | 326 | M2 | 1007 | E24-2 | 1.02866 | 0.00013104 | 0.02184 | 46.1258 | 0.047448 | 104
 | STEEL/E24-2 | 5891 | 24650 | 71815 | +5.888 | +5.894 | 326 | M3 | 1007 | E24-2 | 1.02866 | 0.00013104 | 0.02184 | 46.1258 | 0.047448 | 104
 | STEEL/S235JR | 5897 | 19450 | 71812 | +5.894 | +5.900 | 342 | L9 | 1003 | S235JR | 1.14736 | 0.00014616 | 0.02436 | 45.8724 | 0.052632 | 116
 | STEEL/S235JR | 5897 | 24650 | 71812 | +5.894 | +5.900 | 342 | L8 | 1003 | S235JR | 1.14736 | 0.00014616 | 0.02436 | 45.8724 | 0.052632 | 116
 | STEEL/E24-2 | 5891 | 17090 | 71815 | +5.888 | +5.894 | 326 | M4 | 1007 | E24-2 | 1.02866 | 0.00013104 | 0.02184 | 46.1258 | 0.047448 | 104
 | STEEL/E24-2 | 5827 | 13502 | 75520 | +5.824 | +5.830 | 326 | M5 | 1007 | E24-2 | 1.02866 | 0.00013104 | 0.02184 | 46.1258 | 0.047448 | 104
 | STEEL/E24-2 | 5891 | 26050 | 71815 | +5.888 | +5.894 | 326 | M14 | 1007 | E24-2 | 1.02866 | 0.00013104 | 0.02184 | 46.1258 | 0.047448 | 104
 | STEEL/S235JR | 5897 | 26050 | 71812 | +5.894 | +5.900 | 342 | L8 | 1003 | S235JR | 1.14736 | 0.00014616 | 0.02436 | 45.8724 | 0.052632 | 116

# IfcBeam: PL220*20 (5)
In: Undefined
Description: PL220*20; Material: STEEL/S235JR
Tekla Common - Center of gravity Z: 10482.8 mm; Center of gravity X: 19820 mm; Bottom elevation: +10.261; Top elevation: +10.704; Part mark: 311; Phase: 2; Class: 2005; Finish: GRENAILLE-PEINT; Grade: S235JR; Profile: PL220*20; Name: PLAT; sets with these values: 2
Tekla Quantity - Net weight: 15.3089 kg; Gross weight: 15.3089 kg; Weight: 15.3089 kg; Net volume: 0.00195017 m3; Gross volume: 0.00195017 m3; Gross footprint area: 0.0044 m2; Area per tons: 14.4718 m2; Net surface area: 0.221546 m2; Gross area: 0.221546 m2; Height: 220 mm; Width: 20 mm; Length: 443.221 mm; sets with these values: 2
BaseQuantities - Length: 443.221 mm; OuterSurfaceArea: 0.221546 m2; NetVolume: 0.00195017 m3; NetWeight: 15.3089 kg
Name | Center of gravity Y (mm) | Assembly mark
PLAT | 63750 | K36
PLAT | 52690 | K35
PLAT | 58220 | K34
PLAT | 55455 | K33
PLAT | 60985 | K33

# IfcBeam: PL220*5 (183)
In: Undefined
Description: PL220*5; Material: STEEL/S235JR
Tekla Common - Finish: GALVANISE; Grade: S235JR; Profile: PL220*5; Name: COLLERETTE; sets with these values: 2
Tekla Quantity - Net weight: 3.925 kg; Gross weight: 3.925 kg; Weight: 3.925 kg; Net volume: 0.0005 m3; Gross volume: 0.0005 m3; Gross footprint area: 0.0484 m2; Area per tons: 52.0764 m2; Net surface area: 0.2044 m2; Gross area: 0.2044 m2; Height: 220 mm; Width: 65 mm; Length: 220 mm; sets with these values: 2
BaseQuantities - Length: 220 mm; OuterSurfaceArea: 0.2044 m2; NetVolume: 0.0005 m3; NetWeight: 3.925 kg
Name | Center of gravity Z (mm) | Center of gravity Y (mm) | Center of gravity X (mm) | Bottom elevation | Top elevation | Part mark | Assembly mark | Phase | Class
COLLERETTE | 10845.7 | 50520 | 20360 | +10.800 | +10.865 | 1199 | P108 | 2 | 2007
COLLERETTE | 10745.7 | 50630 | 23191 | +10.700 | +10.765 | 1199 | P107 | 2 | 2007
COLLERETTE | 10845.7 | 52690 | 20360 | +10.800 | +10.865 | 1198 | P95 | 2 | 2007
COLLERETTE | 10845.7 | 55455 | 20360 | +10.800 | +10.865 | 1198 | P95 | 2 | 2007
COLLERETTE | 10845.7 | 58220 | 20360 | +10.800 | +10.865 | 1198 | P95 | 2 | 2007
COLLERETTE | 10845.7 | 60985 | 20360 | +10.800 | +10.865 | 1198 | P95 | 2 | 2007
COLLERETTE | 4078.32 | 40250 | 5691.66 | +4.033 | +4.098 | 1196 | P66 | 2 | 2007
COLLERETTE | 4345.73 | 40250 | 395 | +4.300 | +4.365 | 1198 | P96 | 2 | 2007
COLLERETTE | 3985.62 | 40250 | 8340 | +3.940 | +4.005 | 1196 | P67 | 2 | 2007
COLLERETTE | 4078.32 | 37581.3 | 5691.66 | +4.033 | +4.098 | 1196 | P66 | 2 | 2007
COLLERETTE | 4345.73 | 37581.2 | 395 | +4.300 | +4.365 | 1198 | P96 | 2 | 2007
COLLERETTE | 3985.62 | 37581.2 | 8340 | +3.940 | +4.005 | 1196 | P67 | 2 | 2007
COLLERETTE | 4078.32 | 34912.5 | 5691.66 | +4.033 | +4.098 | 1196 | P66 | 2 | 2007
COLLERETTE | 3624.54 | 11385 | 10405 | +3.579 | +3.644 | 1196 | P83 | 2 | 2007
COLLERETTE | 4345.73 | 34912.5 | 395 | +4.300 | +4.365 | 1198 | P96 | 2 | 2007
COLLERETTE | 3985.62 | 34912.5 | 8340 | +3.940 | +4.005 | 1196 | P67 | 2 | 2007
COLLERETTE | 3985.62 | 32243.8 | 8340 | +3.940 | +4.005 | 1196 | P67 | 2 | 2007
COLLERETTE | 4345.73 | 32243.7 | 395 | +4.300 | +4.365 | 1198 | P96 | 2 | 2007
COLLERETTE | 4078.32 | 32243.8 | 5691.66 | +4.033 | +4.098 | 1196 | P66 | 2 | 2007
COLLERETTE | 3985.62 | 29575 | 8340 | +3.940 | +4.005 | 1196 | P67 | 2 | 2007
COLLERETTE | 4078.32 | 29575 | 5691.66 | +4.033 | +4.098 | 1196 | P66 | 2 | 2007
COLLERETTE | 4345.73 | 29575 | 395 | +4.300 | +4.365 | 1198 | P96 | 2 | 2007
COLLERETTE | 3985.62 | 27043.8 | 8340 | +3.940 | +4.005 | 1196 | P67 | 2 | 2007
COLLERETTE | 4078.32 | 27043.8 | 5691.66 | +4.033 | +4.098 | 1196 | P66 | 2 | 2007
COLLERETTE | 4345.73 | 27043.7 | 395 | +4.300 | +4.365 | 1198 | P96 | 2 | 2007
COLLERETTE | 3985.62 | 24512.5 | 8340 | +3.940 | +4.005 | 1196 | P67 | 2 | 2007
COLLERETTE | 4078.32 | 24512.5 | 5691.66 | +4.033 | +4.098 | 1196 | P66 | 2 | 2007
COLLERETTE | 4345.73 | 24512.5 | 395 | +4.300 | +4.365 | 1198 | P96 | 2 | 2007
COLLERETTE | 4345.73 | 21981.2 | 395 | +4.300 | +4.365 | 1198 | P96 | 2 | 2007
COLLERETTE | 4078.32 | 21981.3 | 5691.66 | +4.033 | +4.098 | 1196 | P66 | 2 | 2007
COLLERETTE | 3985.62 | 21981.2 | 8340 | +3.940 | +4.005 | 1196 | P67 | 2 | 2007
COLLERETTE | 4345.73 | 19450 | 395 | +4.300 | +4.365 | 1198 | P96 | 2 | 2007
COLLERETTE | 4078.32 | 19450 | 5691.66 | +4.033 | +4.098 | 1196 | P66 | 2 | 2007
COLLERETTE | 3985.62 | 19450 | 8340 | +3.940 | +4.005 | 1196 | P67 | 2 | 2007
COLLERETTE | 4345.73 | 17320 | 395 | +4.300 | +4.365 | 1198 | P96 | 2 | 2007
COLLERETTE | 4078.32 | 17320 | 5691.66 | +4.033 | +4.098 | 1196 | P66 | 2 | 2007
COLLERETTE | 3985.62 | 17320 | 8340 | +3.940 | +4.005 | 1196 | P67 | 2 | 2007
COLLERETTE | 4345.73 | 15190 | 395 | +4.300 | +4.365 | 1198 | P96 | 2 | 2007
COLLERETTE | 4078.32 | 15190 | 5691.66 | +4.033 | +4.098 | 1196 | P66 | 2 | 2007
COLLERETTE | 3985.62 | 15190 | 8340 | +3.940 | +4.005 | 1196 | P67 | 2 | 2007
COLLERETTE | 4078.32 | 13060 | 5691.66 | +4.033 | +4.098 | 1196 | P66 | 2 | 2007
COLLERETTE | 4078.32 | 10930 | 5691.66 | +4.033 | +4.098 | 1196 | P78 | 2 | 2007
COLLERETTE | 4245.73 | 10930 | 585 | +4.200 | +4.265 | 1198 | P94 | 2 | 2007
COLLERETTE | 4345.73 | 13060 | 395 | +4.300 | +4.365 | 1198 | P96 | 2 | 2007
COLLERETTE | 3985.62 | 10930 | 8340 | +3.940 | +4.005 | 1196 | P79 | 2 | 2007
COLLERETTE | 3985.62 | 13060 | 8340 | +3.940 | +4.005 | 1196 | P67 | 2 | 2007
COLLERETTE | 4156.53 | 18227 | 77004 | +4.111 | +4.176 | 1196 | P56 | 1 | 1008
COLLERETTE | 4127.35 | 18227 | 77945 | +4.082 | +4.147 | 1196 | P57 | 1 | 1008
COLLERETTE | 4254.95 | 20847 | 73830 | +4.209 | +4.274 | 1196 | P54 | 1 | 1008
COLLERETTE | 5730.73 | 32660 | 70902 | +5.685 | +5.750 | 1198 | P103 | 1 | 1008
COLLERETTE | 5830.73 | 31395 | 72658.7 | +5.785 | +5.850 | 1198 | P104 | 1 | 1008
COLLERETTE | 5830.73 | 30545 | 72658.7 | +5.785 | +5.850 | 1198 | P97 | 1 | 1008
COLLERETTE | 5730.73 | 19950 | 70902 | +5.685 | +5.750 | 1198 | P103 | 1 | 1008
COLLERETTE | 5730.73 | 24650 | 70902 | +5.685 | +5.750 | 1196 | P74 | 1 | 1008
COLLERETTE | 5730.73 | 18660 | 68125 | +5.685 | +5.750 | 1198 | P102 | 1 | 1008
COLLERETTE | 5667.89 | 18660 | 70600 | +5.622 | +5.687 | 1196 | P87 | 1 | 1008
COLLERETTE | 5667.89 | 17090 | 70600 | +5.622 | +5.687 | 1196 | P71 | 1 | 1008
COLLERETTE | 5730.73 | 17090 | 68125 | +5.685 | +5.750 | 1196 | P73 | 1 | 1008
COLLERETTE | 5667.89 | 14730 | 70600 | +5.622 | +5.687 | 1196 | P71 | 1 | 1008
COLLERETTE | 5730.73 | 14730 | 68125 | +5.685 | +5.750 | 1196 | P73 | 1 | 1008
COLLERETTE | 5437.72 | 10010 | 78025 | +5.392 | +5.457 | 1196 | P68 | 1 | 1008
COLLERETTE | 5514.44 | 10010 | 75550 | +5.469 | +5.534 | 1196 | P69 | 1 | 1008
COLLERETTE | 5591.17 | 10010 | 73075 | +5.545 | +5.610 | 1196 | P70 | 1 | 1008
COLLERETTE | 5667.89 | 10010 | 70600 | +5.622 | +5.687 | 1196 | P71 | 1 | 1008
COLLERETTE | 5730.73 | 10010 | 68125 | +5.685 | +5.750 | 1196 | P73 | 1 | 1008
COLLERETTE | 5730.73 | 7650 | 68125 | +5.685 | +5.750 | 1196 | P73 | 1 | 1008
COLLERETTE | 5667.89 | 7650 | 70600 | +5.622 | +5.687 | 1196 | P71 | 1 | 1008
COLLERETTE | 5591.17 | 7650 | 73075 | +5.545 | +5.610 | 1196 | P70 | 1 | 1008
COLLERETTE | 5830.73 | 26895 | 72658.7 | +5.785 | +5.850 | 1198 | P104 | 1 | 1008
COLLERETTE | 5437.72 | 7650 | 78025 | +5.392 | +5.457 | 1196 | P68 | 1 | 1008
COLLERETTE | 5514.44 | 7650 | 75550 | +5.469 | +5.534 | 1196 | P69 | 1 | 1008
COLLERETTE | 5730.73 | 12370 | 68125 | +5.685 | +5.750 | 1196 | P73 | 1 | 1008
COLLERETTE | 5437.72 | 2550 | 78025 | +5.392 | +5.457 | 1196 | P68 | 1 | 1008
COLLERETTE | 5514.44 | 2550 | 75550 | +5.469 | +5.534 | 1196 | P69 | 1 | 1008
COLLERETTE | 5591.17 | 2550 | 73075 | +5.545 | +5.610 | 1196 | P70 | 1 | 1008
COLLERETTE | 5667.89 | 2550 | 70600 | +5.622 | +5.687 | 1196 | P71 | 1 | 1008
COLLERETTE | 5730.73 | 2550 | 68125 | +5.685 | +5.750 | 1196 | P73 | 1 | 1008
COLLERETTE | 5437.72 | 5100 | 78025 | +5.392 | +5.457 | 1196 | P68 | 1 | 1008
COLLERETTE | 5514.44 | 5100 | 75550 | +5.469 | +5.534 | 1196 | P69 | 1 | 1008
COLLERETTE | 5591.17 | 5100 | 73075 | +5.545 | +5.610 | 1196 | P70 | 1 | 1008
COLLERETTE | 5667.89 | 5100 | 70600 | +5.622 | +5.687 | 1196 | P71 | 1 | 1008
COLLERETTE | 5730.73 | 5100 | 68125 | +5.685 | +5.750 | 1196 | P73 | 1 | 1008
COLLERETTE | 5667.89 | 12370 | 70600 | +5.622 | +5.687 | 1196 | P71 | 1 | 1008
COLLERETTE | 5591.17 | 12370 | 73075 | +5.545 | +5.610 | 1196 | P80 | 1 | 1008
COLLERETTE | 5514.44 | 12370 | 75550 | +5.469 | +5.534 | 1196 | P81 | 1 | 1008
COLLERETTE | 5437.72 | 12370 | 78025 | +5.392 | +5.457 | 1196 | P82 | 1 | 1008
COLLERETTE | 5730.73 | 650 | 68125 | +5.685 | +5.750 | 1198 | P102 | 1 | 1008
COLLERETTE | 5667.89 | 650 | 70600 | +5.622 | +5.687 | 1196 | P87 | 1 | 1008
COLLERETTE | 5591.17 | 650 | 73075 | +5.545 | +5.610 | 1196 | P88 | 1 | 1008
COLLERETTE | 5514.44 | 650 | 75550 | +5.469 | +5.534 | 1196 | P89 | 1 | 1008
COLLERETTE | 5437.72 | 650 | 78025 | +5.392 | +5.457 | 1196 | P90 | 1 | 1008
COLLERETTE | 5730.73 | 22050 | 70902 | +5.685 | +5.750 | 1196 | P74 | 1 | 1008
COLLERETTE | 5730.73 | 26545 | 70902 | +5.685 | +5.750 | 1196 | P75 | 1 | 1008
COLLERETTE | 5830.73 | 29145 | 72658.7 | +5.785 | +5.850 | 1198 | P97 | 1 | 1008
COLLERETTE | 5830.73 | 27745 | 72658.7 | +5.785 | +5.850 | 1198 | P97 | 1 | 1008
COLLERETTE | 5830.73 | 31395 | 75358.7 | +5.785 | +5.850 | 1198 | P105 | 1 | 1008
COLLERETTE | 5830.73 | 30545 | 75358.7 | +5.785 | +5.850 | 1198 | P98 | 1 | 1008
COLLERETTE | 5830.73 | 27745 | 75358.7 | +5.785 | +5.850 | 1198 | P98 | 1 | 1008
COLLERETTE | 5830.73 | 26895 | 75358.7 | +5.785 | +5.850 | 1198 | P105 | 1 | 1008
COLLERETTE | 5830.73 | 29145 | 75358.7 | +5.785 | +5.850 | 1198 | P98 | 1 | 1008
COLLERETTE | 5730.73 | 26895 | 78045 | +5.685 | +5.750 | 1198 | P106 | 1 | 1008
COLLERETTE | 5730.73 | 27745 | 78045 | +5.685 | +5.750 | 1198 | P99 | 1 | 1008
COLLERETTE | 5730.73 | 29145 | 78045 | +5.685 | +5.750 | 1198 | P99 | 1 | 1008
COLLERETTE | 5730.73 | 30545 | 78045 | +5.685 | +5.750 | 1198 | P99 | 1 | 1008
COLLERETTE | 5730.73 | 31395 | 78045 | +5.685 | +5.750 | 1198 | P106 | 1 | 1008
COLLERETTE | 4193.12 | 20847 | 75824 | +4.147 | +4.212 | 1196 | P55 | 1 | 1008
COLLERETTE | 4156.53 | 22320 | 77004 | +4.111 | +4.176 | 1196 | P56 | 1 | 1008
COLLERETTE | 4127.35 | 22320 | 77945 | +4.082 | +4.147 | 1196 | P57 | 1 | 1008
COLLERETTE | 4193.12 | 19800 | 75824 | +4.147 | +4.212 | 1196 | P60 | 1 | 1008
COLLERETTE | 4254.95 | 19800 | 73830 | +4.209 | +4.274 | 1196 | P58 | 1 | 1008
COLLERETTE | 4193.12 | 15633.3 | 75824 | +4.147 | +4.212 | 1196 | P61 | 1 | 1008
COLLERETTE | 4254.95 | 15633.3 | 73830 | +4.209 | +4.274 | 1196 | P59 | 1 | 1008
COLLERETTE | 4254.95 | 24940 | 73830 | +4.209 | +4.274 | 1196 | P54 | 1 | 1008
COLLERETTE | 4193.12 | 24940 | 75824 | +4.147 | +4.212 | 1196 | P55 | 1 | 1008
COLLERETTE | 4078.32 | 43008.3 | 5691.66 | +4.033 | +4.098 | 1196 | P66 | 2 | 2007
COLLERETTE | 4345.73 | 43008.3 | 395 | +4.300 | +4.365 | 1198 | P96 | 2 | 2007
COLLERETTE | 3985.62 | 43008.3 | 8340 | +3.940 | +4.005 | 1196 | P67 | 2 | 2007
COLLERETTE | 4078.32 | 45766.7 | 5691.66 | +4.033 | +4.098 | 1196 | P66 | 2 | 2007
COLLERETTE | 3624.54 | 13060 | 10405 | +3.579 | +3.644 | 1196 | P76 | 2 | 2007
COLLERETTE | 4345.73 | 45766.7 | 395 | +4.300 | +4.365 | 1198 | P96 | 2 | 2007
COLLERETTE | 3985.62 | 45766.7 | 8340 | +3.940 | +4.005 | 1196 | P67 | 2 | 2007
COLLERETTE | 3985.62 | 48525 | 8340 | +3.940 | +4.005 | 1196 | P79 | 2 | 2007
COLLERETTE | 4078.32 | 48525 | 5691.66 | +4.033 | +4.098 | 1196 | P78 | 2 | 2007
COLLERETTE | 4245.73 | 48525 | 585 | +4.200 | +4.265 | 1198 | P94 | 2 | 2007
COLLERETTE | 10484.6 | 65970 | 31675 | +10.439 | +10.504 | 1196 | P86 | 2 | 2007
COLLERETTE | 10572.3 | 65970 | 28847 | +10.527 | +10.592 | 1196 | P85 | 2 | 2007
COLLERETTE | 10659.9 | 65970 | 26019 | +10.614 | +10.679 | 1196 | P84 | 2 | 2007
COLLERETTE | 10845.7 | 65970 | 20360 | +10.800 | +10.865 | 1198 | P101 | 2 | 2007
COLLERETTE | 10745.7 | 65860 | 23191 | +10.700 | +10.765 | 1198 | P100 | 2 | 2007
COLLERETTE | 10484.6 | 63750 | 31675 | +10.439 | +10.504 | 1196 | P63 | 2 | 2007
COLLERETTE | 10659.9 | 63750 | 26019 | +10.614 | +10.679 | 1196 | P64 | 2 | 2007
COLLERETTE | 10845.7 | 63750 | 20360 | +10.800 | +10.865 | 1198 | P95 | 2 | 2007
COLLERETTE | 10572.3 | 63750 | 28847 | +10.527 | +10.592 | 1196 | P65 | 2 | 2007
COLLERETTE | 10745.7 | 63750 | 23191 | +10.700 | +10.765 | 1196 | P72 | 2 | 2007
COLLERETTE | 10572.3 | 60985 | 28847 | +10.527 | +10.592 | 1196 | P65 | 2 | 2007
COLLERETTE | 10745.7 | 60985 | 23191 | +10.700 | +10.765 | 1196 | P72 | 2 | 2007
COLLERETTE | 10659.9 | 60985 | 26019 | +10.614 | +10.679 | 1196 | P64 | 2 | 2007
COLLERETTE | 10484.6 | 60985 | 31675 | +10.439 | +10.504 | 1196 | P63 | 2 | 2007
COLLERETTE | 10572.3 | 58220 | 28847 | +10.527 | +10.592 | 1196 | P65 | 2 | 2007
COLLERETTE | 10745.7 | 58220 | 23191 | +10.700 | +10.765 | 1196 | P72 | 2 | 2007
COLLERETTE | 10659.9 | 58220 | 26019 | +10.614 | +10.679 | 1196 | P64 | 2 | 2007
COLLERETTE | 10484.6 | 58220 | 31675 | +10.439 | +10.504 | 1196 | P63 | 2 | 2007
COLLERETTE | 10572.3 | 55455 | 28847 | +10.527 | +10.592 | 1196 | P65 | 2 | 2007
COLLERETTE | 10745.7 | 55455 | 23191 | +10.700 | +10.765 | 1196 | P72 | 2 | 2007
COLLERETTE | 10659.9 | 55455 | 26019 | +10.614 | +10.679 | 1196 | P64 | 2 | 2007
COLLERETTE | 10484.6 | 55455 | 31675 | +10.439 | +10.504 | 1196 | P63 | 2 | 2007
COLLERETTE | 10572.3 | 52690 | 28847 | +10.527 | +10.592 | 1196 | P65 | 2 | 2007
COLLERETTE | 10745.7 | 52690 | 23191 | +10.700 | +10.765 | 1196 | P72 | 2 | 2007
COLLERETTE | 10659.9 | 52690 | 26019 | +10.614 | +10.679 | 1196 | P64 | 2 | 2007
COLLERETTE | 10484.6 | 52690 | 31675 | +10.439 | +10.504 | 1196 | P63 | 2 | 2007
COLLERETTE | 10484.6 | 50520 | 31675 | +10.439 | +10.504 | 1197 | P93 | 2 | 2007
COLLERETTE | 10572.3 | 50520 | 28847 | +10.527 | +10.592 | 1197 | P92 | 2 | 2007
COLLERETTE | 10659.9 | 50520 | 26019 | +10.614 | +10.679 | 1197 | P91 | 2 | 2007
COLLERETTE | 4171.02 | 48525 | 3043.33 | +4.125 | +4.190 | 1196 | P77 | 2 | 2007
COLLERETTE | 4171.02 | 45766.7 | 3043.33 | +4.125 | +4.190 | 1196 | P62 | 2 | 2007
COLLERETTE | 4171.02 | 43008.3 | 3043.33 | +4.125 | +4.190 | 1196 | P62 | 2 | 2007
COLLERETTE | 4171.02 | 40250 | 3043.33 | +4.125 | +4.190 | 1196 | P62 | 2 | 2007
COLLERETTE | 4171.02 | 37581.2 | 3043.33 | +4.125 | +4.190 | 1196 | P62 | 2 | 2007
COLLERETTE | 4171.02 | 34912.5 | 3043.33 | +4.125 | +4.190 | 1196 | P62 | 2 | 2007
COLLERETTE | 4171.02 | 32243.8 | 3043.33 | +4.125 | +4.190 | 1196 | P62 | 2 | 2007
COLLERETTE | 4171.02 | 29575 | 3043.33 | +4.125 | +4.190 | 1196 | P62 | 2 | 2007
COLLERETTE | 4171.02 | 27043.8 | 3043.33 | +4.125 | +4.190 | 1196 | P62 | 2 | 2007
COLLERETTE | 4171.02 | 24512.5 | 3043.33 | +4.125 | +4.190 | 1196 | P62 | 2 | 2007
COLLERETTE | 4171.02 | 21981.2 | 3043.33 | +4.125 | +4.190 | 1196 | P62 | 2 | 2007
COLLERETTE | 4171.02 | 19450 | 3043.33 | +4.125 | +4.190 | 1196 | P62 | 2 | 2007
COLLERETTE | 4171.02 | 17320 | 3043.33 | +4.125 | +4.190 | 1196 | P62 | 2 | 2007
COLLERETTE | 4171.02 | 15190 | 3043.33 | +4.125 | +4.190 | 1196 | P62 | 2 | 2007
COLLERETTE | 4171.02 | 13060 | 3043.33 | +4.125 | +4.190 | 1196 | P62 | 2 | 2007
COLLERETTE | 4171.02 | 10930 | 3043.33 | +4.125 | +4.190 | 1196 | P77 | 2 | 2007
COLLERETTE | 3624.54 | 15190 | 10405 | +3.579 | +3.644 | 1196 | P76 | 2 | 2007
COLLERETTE | 3624.54 | 17320 | 10405 | +3.579 | +3.644 | 1196 | P76 | 2 | 2007
COLLERETTE | 3624.54 | 21981.2 | 10405 | +3.579 | +3.644 | 1196 | P76 | 2 | 2007
COLLERETTE | 3624.54 | 27043.8 | 10405 | +3.579 | +3.644 | 1196 | P76 | 2 | 2007
COLLERETTE | 3624.54 | 32243.8 | 10405 | +3.579 | +3.644 | 1196 | P76 | 2 | 2007
COLLERETTE | 3624.54 | 37581.2 | 10405 | +3.579 | +3.644 | 1196 | P76 | 2 | 2007
COLLERETTE | 3624.54 | 43008.3 | 10405 | +3.579 | +3.644 | 1196 | P76 | 2 | 2007
COLLERETTE | 3624.54 | 19450 | 10405 | +3.579 | +3.644 | 1196 | P76 | 2 | 2007
COLLERETTE | 3624.54 | 24512.5 | 10405 | +3.579 | +3.644 | 1196 | P76 | 2 | 2007
COLLERETTE | 3624.54 | 29575 | 10405 | +3.579 | +3.644 | 1196 | P76 | 2 | 2007
COLLERETTE | 3624.54 | 34912.5 | 10405 | +3.579 | +3.644 | 1196 | P76 | 2 | 2007
COLLERETTE | 3624.54 | 45766.7 | 10405 | +3.579 | +3.644 | 1196 | P76 | 2 | 2007
COLLERETTE | 3624.54 | 40250 | 10405 | +3.579 | +3.644 | 1196 | P76 | 2 | 2007
COLLERETTE | 3624.54 | 48065 | 10405 | +3.579 | +3.644 | 1196 | P83 | 2 | 2007

# IfcBeam: PL2270*200, MACONNERIE
In: Undefined
Description: PL2270*200; Material: CONCRETE/BETON COURANT
Tekla Common - Center of gravity Z: 7275 mm; Center of gravity Y: 68137.5 mm; Center of gravity X: 19660 mm; Bottom elevation: +6.140; Top elevation: +8.410; Part mark: Z30; Assembly mark: Z30; Phase: 10; Class: 75; Grade: BETON COURANT; Profile: PL2270*200; Name: MACONNERIE; sets with these values: 2
Tekla Quantity - Net weight: 2702.89 kg; Gross weight: 2702.89 kg; Weight: 2702.89 kg; Net volume: 1.28709 m3; Gross volume: 1.28709 m3; Gross footprint area: 0.567001 m2; Area per tons: 5.51739 m2; Net surface area: 14.9129 m2; Gross area: 14.9129 m2; Height: 2270 mm; Width: 200 mm; Length: 2835 mm; sets with these values: 2
BaseQuantities - Length: 2835 mm; OuterSurfaceArea: 14.9129 m2; NetVolume: 1.28709 m3; NetWeight: 2702.89 kg

# IfcBeam: PL240*10 (7)
In: Undefined
Description: PL240*10; Material: STEEL/E24-2
Tekla Common - Center of gravity Z: 4005 mm; Center of gravity X: 71815 mm; Bottom elevation: +4.000; Top elevation: +4.010; Part mark: 230; Phase: 1; Class: 1007; Finish: GRENAILLE-PEINT; Grade: E24-2; Profile: PL240*10; sets with these values: 2
Tekla Quantity - Net weight: 2.826 kg; Gross weight: 2.826 kg; Weight: 2.826 kg; Net volume: 0.00036 m3; Gross volume: 0.00036 m3; Gross footprint area: 0.036 m2; Area per tons: 28.2378 m2; Net surface area: 0.0798 m2; Gross area: 0.0798 m2; Height: 240 mm; Width: 10 mm; Length: 150 mm; sets with these values: 2
BaseQuantities - Length: 150 mm; OuterSurfaceArea: 0.0798 m2; NetVolume: 0.00036 m3; NetWeight: 2.826 kg
Name | Center of gravity Y (mm) | Assembly mark
 | 24650 | M3
 | 22050 | M2
 | 19450 | M1
 | 17090 | M4
 | 14730 | M4
 | 26050 | M14
 | 26545 | M13

# IfcBeam: PL240*8 (30)
In: Undefined
Description: PL240*8; Material: STEEL/E24-2
Tekla Common - Phase: 6; Class: 6001; Finish: GRENAILLE-PEINT; Grade: E24-2; Profile: PL240*8; sets with these values: 2
Tekla Quantity - Net weight: 1.65792 kg; Gross weight: 1.65792 kg; Weight: 1.65792 kg; Net volume: 0.0002112 m3; Gross volume: 0.0002112 m3; Gross footprint area: 0 m2; Area per tons: 35.2249 m2; Net surface area: 0.0584 m2; Gross area: 0.0584 m2; Height: 240 mm; Width: 8 mm; Length: 110 mm; sets with these values: 2
BaseQuantities - Length: 110 mm; OuterSurfaceArea: 0.0584 m2; NetVolume: 0.0002112 m3; NetWeight: 1.65792 kg
Name | Center of gravity Z (mm) | Center of gravity Y (mm) | Center of gravity X (mm) | Bottom elevation | Top elevation | Part mark | Assembly mark | Name
SUSPENTE | 3520.75 | 24512.5 | 3220.17 | +3.515 | +3.527 | 736 | S88 | SUSPENTE
SUSPENTE | 3716.06 | 15190 | 650.14 | +3.710 | +3.722 | 736 | S8 | SUSPENTE
ATTACHE | 3699.7 | 15190 | 1117.45 | +3.694 | +3.706 | 737 | H42 | ATTACHE
ATTACHE | 3699.7 | 10930 | 1117.45 | +3.694 | +3.706 | 737 | H42 | ATTACHE
ATTACHE | 3699.7 | 13060 | 1117.45 | +3.694 | +3.706 | 737 | H42 | ATTACHE
SUSPENTE | 3716.06 | 10930 | 650.14 | +3.710 | +3.722 | 736 | S8 | SUSPENTE
SUSPENTE | 3622.78 | 10930 | 3315.14 | +3.617 | +3.629 | 736 | S6 | SUSPENTE
SUSPENTE | 3716.06 | 13060 | 650.14 | +3.710 | +3.722 | 736 | S7 | SUSPENTE
SUSPENTE | 3622.78 | 13060 | 3315.14 | +3.617 | +3.629 | 736 | S5 | SUSPENTE
SUSPENTE | 3517.43 | 13060 | 6325.14 | +3.512 | +3.523 | 736 | S3 | SUSPENTE
SUSPENTE | 3517.43 | 10930 | 6325.14 | +3.512 | +3.523 | 736 | S4 | SUSPENTE
SUSPENTE | 3622.78 | 15190 | 3315.14 | +3.617 | +3.629 | 736 | S6 | SUSPENTE
SUSPENTE | 3622.78 | 17320 | 3315.14 | +3.617 | +3.629 | 736 | S5 | SUSPENTE
ATTACHE | 3699.7 | 17320 | 1117.45 | +3.694 | +3.706 | 737 | H42 | ATTACHE
SUSPENTE | 3716.06 | 17320 | 650.14 | +3.710 | +3.722 | 736 | S7 | SUSPENTE
SUSPENTE | 3716.06 | 19450 | 650.14 | +3.710 | +3.722 | 736 | S8 | SUSPENTE
ATTACHE | 3699.7 | 19450 | 1117.45 | +3.694 | +3.706 | 737 | H42 | ATTACHE
SUSPENTE | 3622.78 | 19450 | 3315.14 | +3.617 | +3.629 | 736 | S6 | SUSPENTE
SUSPENTE | 3716.06 | 21981.2 | 650.14 | +3.710 | +3.722 | 736 | S7 | SUSPENTE
ATTACHE | 3699.7 | 21981.2 | 1117.45 | +3.694 | +3.706 | 737 | H42 | ATTACHE
SUSPENTE | 3622.78 | 21981.2 | 3315.14 | +3.617 | +3.629 | 736 | S5 | SUSPENTE
SUSPENTE | 3716.06 | 24512.5 | 650.14 | +3.710 | +3.722 | 736 | S8 | SUSPENTE
ATTACHE | 3699.7 | 24512.5 | 1117.45 | +3.694 | +3.706 | 737 | H42 | ATTACHE
SUSPENTE | 3716.06 | 29575 | 650.14 | +3.710 | +3.722 | 736 | S9 | SUSPENTE
ATTACHE | 3699.7 | 29575 | 1117.45 | +3.694 | +3.706 | 737 | H42 | ATTACHE
SUSPENTE | 3716.06 | 27043.8 | 650.14 | +3.710 | +3.722 | 736 | S10 | SUSPENTE
ATTACHE | 3699.7 | 27043.8 | 1117.45 | +3.694 | +3.706 | 737 | H42 | ATTACHE
SUSPENTE | 3520.75 | 15190 | 6230.17 | +3.515 | +3.527 | 736 | S87 | SUSPENTE
SUSPENTE | 3716.06 | 32243.8 | 650.14 | +3.710 | +3.722 | 736 | S10 | SUSPENTE
ATTACHE | 3699.7 | 32243.8 | 1117.45 | +3.694 | +3.706 | 737 | H42 | ATTACHE

# IfcBeam: PL25*160 (10)
In: Undefined
Description: PL25*160; Material: STEEL/E36-3
Tekla Common - Center of gravity Z: 5635 mm; Bottom elevation: +5.370; Top elevation: +5.900; Finish: GRENAILLE-PEINT; Grade: E36-3; Profile: PL25*160; Name: PLAT; sets with these values: 2
Tekla Quantity - Net weight: 16.642 kg; Gross weight: 16.642 kg; Weight: 16.642 kg; Net volume: 0.00212 m3; Gross volume: 0.00212 m3; Gross footprint area: 0.004 m2; Area per tons: 12.2642 m2; Net surface area: 0.2041 m2; Gross area: 0.2041 m2; Height: 160 mm; Width: 25 mm; Length: 530 mm; sets with these values: 2
BaseQuantities - Length: 530 mm; OuterSurfaceArea: 0.2041 m2; NetVolume: 0.00212 m3; NetWeight: 16.642 kg
Name | Center of gravity Y (mm) | Center of gravity X (mm) | Part mark | Assembly mark | Phase | Class
PLAT | 40267.6 | 20850 | 142 | N46 | 2 | 2006
PLAT | 40267.6 | 32525 | 143 | N43 | 3 | 3003
PLAT | 19467.6 | 20850 | 142 | N45 | 2 | 2006
PLAT | 40267.6 | 67550 | 132 | N6 | 1 | 1006
PLAT | 19467.6 | 67550 | 142 | N11 | 1 | 1006
PLAT | 40267.6 | 55875 | 142 | N41 | 1 | 1006
PLAT | 19467.6 | 55875 | 142 | N10 | 1 | 1006
PLAT | 19467.6 | 32525 | 142 | N9 | 3 | 3006
PLAT | 19467.6 | 44200 | 142 | N10 | 1 | 1006
PLAT | 40267.6 | 44200 | 142 | N41 | 1 | 1006

# IfcBeam: PL25*200 (8)
In: Undefined
Description: PL25*200; Material: STEEL/E24-2
Tekla Common - Finish: GRENAILLE-PEINT; Grade: E24-2; Profile: PL25*200; sets with these values: 2
Tekla Quantity - Net weight: 8.83125 kg; Gross weight: 8.83125 kg; Weight: 8.83125 kg; Net volume: 0.001125 m3; Gross volume: 0.001125 m3; Gross footprint area: 0.045 m2; Area per tons: 12.5973 m2; Net surface area: 0.11125 m2; Gross area: 0.11125 m2; Height: 200 mm; Width: 25 mm; Length: 225 mm; sets with these values: 2
BaseQuantities - Length: 225 mm; OuterSurfaceArea: 0.11125 m2; NetVolume: 0.001125 m3; NetWeight: 8.83125 kg
Name | Center of gravity Z (mm) | Center of gravity Y (mm) | Center of gravity X (mm) | Bottom elevation | Top elevation | Part mark | Assembly mark | Phase | Class | Name
PLATINE | -47.5 | 61050 | 67537.5 | -0.060 | -0.035 | 138 | P37 | 1 | 1001 | PLATINE
PLATINE | -387.5 | 61050 | 55862.5 | -0.400 | -0.375 | 138 | P2 | 1 | 1001 | PLATINE
PLATINE | -387.5 | 61050 | 44187.5 | -0.400 | -0.375 | 138 | P1 | 1 | 1001 | PLATINE
PLAT | -387.5 | 7650 | 67537.5 | -0.400 | -0.375 | 139 | P38 | 1 | 1001 | PLAT
PLATINE | -587.5 | 7650 | 44187.5 | -0.600 | -0.575 | 138 | P3 | 1 | 1001 | PLATINE
PLATINE | -387.5 | 7650 | 32512.5 | -0.400 | -0.375 | 140 | P5 | 3 | 3001 | PLATINE
PLATINE | -387.5 | 7650 | 20837.5 | -0.400 | -0.375 | 140 | P39 | 2 | 2001 | PLATINE
PLAT | -387.5 | 7650 | 55862.5 | -0.400 | -0.375 | 139 | P4 | 1 | 1001 | PLAT

# IfcBeam: PL25*250 (16)
In: Undefined
Description: PL25*250; Material: STEEL/E24-2
Tekla Common - Finish: GRENAILLE-PEINT; Grade: E24-2; Profile: PL25*250; Name: PLATINE; sets with these values: 2
Tekla Quantity - Height: 250 mm; Width: 25 mm; sets with these values: 2
Name | Center of gravity Z (mm) | Center of gravity Y (mm) | Center of gravity X (mm) | Bottom elevation | Top elevation | Part mark | Assembly mark | Phase | Class | Net weight (kg) = Gross weight (kg) = Weight (kg) = NetWeight (kg) | Net volume (m3) = Gross volume (m3) = NetVolume (m3) | Gross footprint area (m2) | Area per tons (m2) | Net surface area (m2) = Gross area (m2) = OuterSurfaceArea (m2) | Tekla Quantity, Length (mm) = BaseQuantities, Length (mm)
PLATINE | -387.5 | 40250 | 67550 | -0.400 | -0.375 | 136 | P33 | 1 | 1001 | 12.2656 | 0.0015625 | 0.0625 | 12.2293 | 0.15 | 250
PLATINE | -387.5 | 40250 | 55875 | -0.400 | -0.375 | 136 | P35 | 1 | 1001 | 12.2656 | 0.0015625 | 0.0625 | 12.2293 | 0.15 | 250
PLATINE | -387.5 | 40250 | 44200 | -0.400 | -0.375 | 136 | P35 | 1 | 1001 | 12.2656 | 0.0015625 | 0.0625 | 12.2293 | 0.15 | 250
PLATINE | -387.5 | 40250 | 32525 | -0.400 | -0.375 | 137 | P31 | 3 | 3001 | 12.2656 | 0.0015625 | 0.0625 | 12.2293 | 0.15 | 250
PLATINE | -387.5 | 19450 | 20850 | -0.400 | -0.375 | 137 | P29 | 2 | 2001 | 12.2656 | 0.0015625 | 0.0625 | 12.2293 | 0.15 | 250
PLATINE | -387.5 | 40250 | 20850 | -0.400 | -0.375 | 137 | P30 | 2 | 2001 | 12.2656 | 0.0015625 | 0.0625 | 12.2293 | 0.15 | 250
PLATINE | -387.5 | 19450 | 55875 | -0.400 | -0.375 | 136 | P36 | 1 | 1001 | 12.2656 | 0.0015625 | 0.0625 | 12.2293 | 0.15 | 250
PLATINE | -47.5 | 69150 | 67550 | -0.060 | -0.035 | 141 | P23 | 1 | 1001 | 13.2469 | 0.0016875 | 0.0675 | 12.1538 | 0.161 | 270
PLATINE | -387.5 | 69150 | 44200 | -0.400 | -0.375 | 141 | P26 | 1 | 1001 | 13.2469 | 0.0016875 | 0.0675 | 12.1538 | 0.161 | 270
PLATINE | -387.5 | 69150 | 55875 | -0.400 | -0.375 | 141 | P27 | 1 | 1001 | 13.2469 | 0.0016875 | 0.0675 | 12.1538 | 0.161 | 270
PLATINE | -387.5 | 0 | 67550 | -0.400 | -0.375 | 141 | P24 | 1 | 1001 | 13.2469 | 0.0016875 | 0.0675 | 12.1538 | 0.161 | 270
PLATINE | -587.5 | 2.84217e-14 | 44200 | -0.600 | -0.575 | 141 | P22 | 1 | 1001 | 13.2469 | 0.0016875 | 0.0675 | 12.1538 | 0.161 | 270
PLATINE | -387.5 | 2.84217e-14 | 55875 | -0.400 | -0.375 | 141 | P25 | 1 | 1001 | 13.2469 | 0.0016875 | 0.0675 | 12.1538 | 0.161 | 270
PLATINE | -387.5 | 19450 | 44200 | -0.400 | -0.375 | 136 | P36 | 1 | 1001 | 12.2656 | 0.0015625 | 0.0625 | 12.2293 | 0.15 | 250
PLATINE | -387.5 | 19450 | 32525 | -0.400 | -0.375 | 137 | P32 | 3 | 3001 | 12.2656 | 0.0015625 | 0.0625 | 12.2293 | 0.15 | 250
PLATINE | -387.5 | 19450 | 67550 | -0.400 | -0.375 | 136 | P28 | 1 | 1001 | 12.2656 | 0.0015625 | 0.0625 | 12.2293 | 0.15 | 250

# IfcBeam: PL250*10 (4)
In: Undefined
Description: PL250*10; Material: STEEL/E24-2
Tekla Common - Part mark: 236; Phase: 4; Class: 4001; Finish: GRENAILLE-PEINT; Grade: E24-2; Profile: PL250*10; Name: ATTACHE; sets with these values: 2
Tekla Quantity - Net weight: 2.355 kg; Gross weight: 2.355 kg; Weight: 2.355 kg; Net volume: 0.0003 m3; Gross volume: 0.0003 m3; Gross footprint area: 0 m2; Area per tons: 28.62 m2; Net surface area: 0.0674 m2; Gross area: 0.0674 m2; Height: 250 mm; Width: 10 mm; Length: 120 mm; sets with these values: 2
BaseQuantities - Length: 120 mm; OuterSurfaceArea: 0.0674 m2; NetVolume: 0.0003 m3; NetWeight: 2.355 kg
Name | Center of gravity Z (mm) | Center of gravity Y (mm) | Center of gravity X (mm) | Bottom elevation | Top elevation | Assembly mark
ATTACHE | 5223.74 | 27250 | 58257.6 | +5.212 | +5.236 | E7
ATTACHE | 4257.48 | 24650 | 54493.6 | +4.245 | +4.270 | E6
ATTACHE | 5223.74 | 24650 | 58257.6 | +5.212 | +5.236 | E7
ATTACHE | 4257.48 | 27250 | 54493.6 | +4.245 | +4.270 | E6

# IfcBeam: PL260*10 (22)
In: Undefined
Description: PL260*10; Material: STEEL/S235JR
Tekla Common - Center of gravity Z: 5741.5 mm; Phase: 2; Grade: S235JR; Profile: PL260*10; Name: PLAT; sets with these values: 2
Tekla Quantity - Gross footprint area: 0.0026 m2; Height: 260 mm; Width: 10 mm; sets with these values: 2
Name | Center of gravity Y (mm) | Center of gravity X (mm) | Bottom elevation | Top elevation | Part mark | Assembly mark | Class | Finish | Net weight (kg) = Gross weight (kg) = Weight (kg) = NetWeight (kg) | Net volume (m3) = Gross volume (m3) = NetVolume (m3) | Area per tons (m2) | Net surface area (m2) = Gross area (m2) = OuterSurfaceArea (m2) | Tekla Quantity, Length (mm) = BaseQuantities, Length (mm)
PLAT | 42706.5 | 20760 | +5.602 | +5.881 | 257 | S1 | 2007 | GALVANISE | 5.68623 | 0.00072436 | 27.3721 | 0.155644 | 278.6
PLAT | 42706.5 | 20770 | +5.597 | +5.886 | 262 | N46 | 2006 | GRENAILLE-PEINT | 5.89033 | 0.00075036 | 27.3404 | 0.161044 | 288.6
PLAT | 37506.5 | 20760 | +5.602 | +5.881 | 257 | S1 | 2007 | GALVANISE | 5.68623 | 0.00072436 | 27.3721 | 0.155644 | 278.6
PLAT | 37506.5 | 20770 | +5.597 | +5.886 | 262 | N44 | 2006 | GRENAILLE-PEINT | 5.89033 | 0.00075036 | 27.3404 | 0.161044 | 288.6
PLAT | 32306.5 | 20760 | +5.602 | +5.881 | 257 | S1 | 2007 | GALVANISE | 5.68623 | 0.00072436 | 27.3721 | 0.155644 | 278.6
PLAT | 32306.5 | 20770 | +5.597 | +5.886 | 262 | N44 | 2006 | GRENAILLE-PEINT | 5.89033 | 0.00075036 | 27.3404 | 0.161044 | 288.6
PLAT | 21906.5 | 20770 | +5.597 | +5.886 | 262 | N45 | 2006 | GRENAILLE-PEINT | 5.89033 | 0.00075036 | 27.3404 | 0.161044 | 288.6
PLAT | 21906.5 | 20760 | +5.602 | +5.881 | 257 | S1 | 2007 | GALVANISE | 5.68623 | 0.00072436 | 27.3721 | 0.155644 | 278.6
PLAT | 12513.5 | 20760 | +5.602 | +5.881 | 257 | S1 | 2007 | GALVANISE | 5.68623 | 0.00072436 | 27.3721 | 0.155644 | 278.6
PLAT | 12513.5 | 20770 | +5.597 | +5.886 | 262 | N49 | 2006 | GRENAILLE-PEINT | 5.89033 | 0.00075036 | 27.3404 | 0.161044 | 288.6
PLAT | 45306.5 | 20760 | +5.602 | +5.881 | 257 | S1 | 2007 | GALVANISE | 5.68623 | 0.00072436 | 27.3721 | 0.155644 | 278.6
PLAT | 45306.5 | 20770 | +5.597 | +5.886 | 262 | N46 | 2006 | GRENAILLE-PEINT | 5.89033 | 0.00075036 | 27.3404 | 0.161044 | 288.6
PLAT | 82.0019 | 20755 | +5.602 | +5.881 | 257 | S2 | 2007 | GALVANISE | 5.68623 | 0.00072436 | 27.3721 | 0.155644 | 278.6
PLAT | 82.0019 | 20765 | +5.597 | +5.886 | 262 | N18 | 2006 | GRENAILLE-PEINT | 5.89033 | 0.00075036 | 27.3404 | 0.161044 | 288.6
PLAT | 27106.5 | 20770 | +5.597 | +5.886 | 262 | N45 | 2006 | GRENAILLE-PEINT | 5.89033 | 0.00075036 | 27.3404 | 0.161044 | 288.6
PLAT | 27106.5 | 20760 | +5.602 | +5.881 | 257 | S1 | 2007 | GALVANISE | 5.68623 | 0.00072436 | 27.3721 | 0.155644 | 278.6
PLAT | 17233.5 | 20770 | +5.597 | +5.886 | 262 | N49 | 2006 | GRENAILLE-PEINT | 5.89033 | 0.00075036 | 27.3404 | 0.161044 | 288.6
PLAT | 17233.5 | 20760 | +5.602 | +5.881 | 257 | S1 | 2007 | GALVANISE | 5.68623 | 0.00072436 | 27.3721 | 0.155644 | 278.6
PLAT | 9866.5 | 20770 | +5.597 | +5.886 | 262 | N49 | 2006 | GRENAILLE-PEINT | 5.89033 | 0.00075036 | 27.3404 | 0.161044 | 288.6
PLAT | 9866.5 | 20760 | +5.602 | +5.881 | 257 | S1 | 2007 | GALVANISE | 5.68623 | 0.00072436 | 27.3721 | 0.155644 | 278.6
PLAT | 4956.5 | 20760 | +5.602 | +5.881 | 257 | S1 | 2007 | GALVANISE | 5.68623 | 0.00072436 | 27.3721 | 0.155644 | 278.6
PLAT | 4956.5 | 20770 | +5.597 | +5.886 | 262 | N18 | 2006 | GRENAILLE-PEINT | 5.89033 | 0.00075036 | 27.3404 | 0.161044 | 288.6

# IfcBeam: PL2600*150 (5)
In: Undefined
Description: PL2600*150; Material: CONCRETE/BETON COURANT
Tekla Common - Bottom elevation: +6.140; Top elevation: +8.740; Phase: 10; Class: 75; Grade: BETON COURANT; Profile: PL2600*150; Name: MACONNERIE; sets with these values: 2
Tekla Quantity - Height: 2600 mm; Width: 150 mm; sets with these values: 2
Name | Center of gravity Z (mm) | Center of gravity Y (mm) | Center of gravity X (mm) | Part mark = Assembly mark | Net weight (kg) = Weight (kg) = NetWeight (kg) | Gross weight (kg) | Net volume (m3) = NetVolume (m3) | Gross volume (m3) | Gross footprint area (m2) | Area per tons (m2) | Net surface area (m2) = OuterSurfaceArea (m2) | Gross area (m2) | Tekla Quantity, Length (mm) = BaseQuantities, Length (mm)
MACONNERIE | 7440 | 64480 | 32040 | Z76 | 1122.03 | 1122.03 | 0.5343 | 0.5343 | 0.2055 | 7.41068 | 8.315 | 8.315 | 1370
MACONNERIE | 7440 | 64312.5 | 31280 | Z75 | 397.215 | 397.215 | 0.18915 | 0.18915 | 0.07275 | 8.67918 | 3.4475 | 3.4475 | 485
MACONNERIE | 7440 | 63995 | 30860 | Z74 | 3054.87 | 3054.87 | 1.4547 | 1.4547 | 0.5595 | 6.97084 | 21.295 | 21.295 | 3730
MACONNERIE | 7525.39 | 62963.2 | 28920 | Z73 | 1721.57 | 2309.58 | 0.819796 | 1.0998 | 0.423 | 7.65964 | 13.1866 | 16.29 | 2820
MACONNERIE | 7470.03 | 61175 | 29708.9 | Z72 | 4884.24 | 5470.92 | 2.32583 | 2.6052 | 1.002 | 7.04819 | 34.425 | 37.52 | 6680

# IfcBeam: PL2600*200 (6)
In: Undefined
Description: PL2600*200; Material: CONCRETE/BETON COURANT
Tekla Common - Center of gravity Z: 7440 mm; Bottom elevation: +6.140; Top elevation: +8.740; Phase: 10; Class: 75; Grade: BETON COURANT; Profile: PL2600*200; Name: MACONNERIE; sets with these values: 2
Tekla Quantity - Height: 2600 mm; Width: 200 mm; sets with these values: 2
Name | Center of gravity Y (mm) | Center of gravity X (mm) | Part mark = Assembly mark | Net weight (kg) = Gross weight (kg) = Weight (kg) = NetWeight (kg) | Net volume (m3) = Gross volume (m3) = NetVolume (m3) | Gross footprint area (m2) | Area per tons (m2) | Net surface area (m2) = Gross area (m2) = OuterSurfaceArea (m2) | Tekla Quantity, Length (mm) = BaseQuantities, Length (mm)
MACONNERIE | 64817.5 | 27745 | Z22 | 3718.26 | 1.7706 | 0.681 | 5.40791 | 20.108 | 3405
MACONNERIE | 64817.5 | 24160 | Z22 | 3718.26 | 1.7706 | 0.681 | 5.40791 | 20.108 | 3405
MACONNERIE | 63215 | 23280 | Z29 | 2140.32 | 1.0192 | 0.392 | 5.61411 | 12.016 | 1960
MACONNERIE | 63937.5 | 22400 | Z28 | 1796.34 | 0.8554 | 0.329 | 5.70716 | 10.252 | 1645
MACONNERIE | 64860 | 21900 | Z27 | 1310.4 | 0.624 | 0.24 | 5.92186 | 7.76 | 1200
MACONNERIE | 64327.5 | 21400 | Z26 | 1381.38 | 0.6578 | 0.253 | 5.88108 | 8.124 | 1265

# IfcBeam: PL2780*200 (3)
In: Undefined
Description: PL2780*200; Material: CONCRETE/BETON COURANT
Tekla Common - Center of gravity Z: 4530 mm; Bottom elevation: +3.140; Top elevation: +5.920; Phase: 10; Class: 75; Grade: BETON COURANT; Profile: PL2780*200; Name: MACONNERIE; sets with these values: 2
Tekla Quantity - Height: 2780 mm; Width: 200 mm; sets with these values: 2
Name | Center of gravity Y (mm) | Center of gravity X (mm) | Part mark = Assembly mark | Net weight (kg) = Gross weight (kg) = Weight (kg) = NetWeight (kg) | Net volume (m3) = Gross volume (m3) = NetVolume (m3) | Gross footprint area (m2) | Area per tons (m2) | Net surface area (m2) = Gross area (m2) = OuterSurfaceArea (m2) | Tekla Quantity, Length (mm) = BaseQuantities, Length (mm)
MACONNERIE | 66620 | 23379.9 | Z32 | 2055.09 | 0.978616 | 0.35202 | 5.64558 | 11.6022 | 1760.1
MACONNERIE | 64895 | 26452.5 | Z31 | 2784.73 | 1.32606 | 0.477 | 5.50381 | 15.3266 | 2385
MACONNERIE | 64407.5 | 24160 | Z33 | 4933.11 | 2.3491 | 0.845 | 5.3299 | 26.293 | 4225

# IfcBeam: PL2800*200, MACONNERIE
In: Undefined
Description: PL2800*200; Material: CONCRETE/BETON COURANT
Tekla Common - Center of gravity Z: 4525.6 mm; Center of gravity Y: 59021.1 mm; Center of gravity X: 27745 mm; Bottom elevation: +3.140; Top elevation: +5.940; Part mark: Z58; Assembly mark: Z58; Phase: 10; Class: 75; Grade: BETON COURANT; Profile: PL2800*200; Name: MACONNERIE; sets with these values: 2
Tekla Quantity - Net weight: 23629.2 kg; Gross weight: 24990 kg; Weight: 23629.2 kg; Net volume: 11.252 m3; Gross volume: 11.9 m3; Gross footprint area: 4.25 m2; Area per tons: 5.27568 m2; Net surface area: 124.66 m2; Gross area: 128.62 m2; Height: 2800 mm; Width: 200 mm; Length: 21250 mm; sets with these values: 2
BaseQuantities - Length: 21250 mm; OuterSurfaceArea: 124.66 m2; NetVolume: 11.252 m3; NetWeight: 23629.2 kg

# IfcBeam: PL2900*150 (8)
In: Undefined
Description: PL2900*150; Material: CONCRETE/BETON COURANT
Tekla Common - Center of gravity Z: 1450 mm; Bottom elevation: -0.000; Top elevation: +2.900; Phase: 10; Class: 75; Grade: BETON COURANT; Profile: PL2900*150; Name: PREFA; sets with these values: 2
Tekla Quantity - Height: 2900 mm; Width: 150 mm; sets with these values: 2
Name | Center of gravity Y (mm) | Center of gravity X (mm) | Part mark = Assembly mark | Net weight (kg) = Weight (kg) = NetWeight (kg) | Gross weight (kg) | Net volume (m3) = Gross volume (m3) = NetVolume (m3) | Gross footprint area (m2) | Area per tons (m2) | Net surface area (m2) = Gross area (m2) = OuterSurfaceArea (m2) | Tekla Quantity, Length (mm) = BaseQuantities, Length (mm)
PREFA | 9875 | 295 | Z68 | 1242.36 | 1242.36 | 0.5916 | 0.204 | 7.37789 | 9.166 | 1360
PREFA | 10325 | 900 | Z70 | 959.175 | 959.175 | 0.45675 | 0.1575 | 7.58464 | 7.275 | 1050
PREFA | 10952 | 766.967 | Z71 | 400.484 | 400.484 | 0.190707 | 0.0657609 | 8.84998 | 3.54428 | 438.406
PREFA | 11085 | 140 | Z70 | 959.175 | 959.175 | 0.45675 | 0.1575 | 7.58464 | 7.275 | 1050
PREFA | 10480 | -310 | Z68 | 1242.36 | 1242.36 | 0.5916 | 0.204 | 7.37789 | 9.166 | 1360
PREFA | 11085 | 8950 | Z69 | 794.745 | 794.745 | 0.37845 | 0.1305 | 7.7723 | 6.177 | 870
PREFA | 10480 | 8590 | Z68 | 1242.36 | 1242.36 | 0.5916 | 0.204 | 7.37789 | 9.166 | 1360
PREFA | 9872.3 | 8979.3 | Z67 | 844.987 | 936.337 | 0.402375 | 0.13875 | 8.05041 | 6.8025 | 1025

# IfcBeam: PL2920*200, MACONNERIE
In: Undefined
Description: PL2920*200; Material: CONCRETE/BETON COURANT
Tekla Common - Center of gravity Z: 1460 mm; Center of gravity Y: 62395 mm; Center of gravity X: 21519.9 mm; Bottom elevation: +0.000; Top elevation: +2.920; Part mark: Z34; Assembly mark: Z34; Phase: 10; Class: 75; Grade: BETON COURANT; Profile: PL2920*200; Name: MACONNERIE; sets with these values: 2
Tekla Quantity - Net weight: 2403.74 kg; Gross weight: 2403.74 kg; Weight: 2403.74 kg; Net volume: 1.14464 m3; Gross volume: 1.14464 m3; Gross footprint area: 0.392 m2; Area per tons: 5.57397 m2; Net surface area: 13.3984 m2; Gross area: 13.3984 m2; Height: 2920 mm; Width: 200 mm; Length: 1960 mm; sets with these values: 2
BaseQuantities - Length: 1960 mm; OuterSurfaceArea: 13.3984 m2; NetVolume: 1.14464 m3; NetWeight: 2403.74 kg

# IfcBeam: PL3*116 (2)
In: Undefined
Description: PL3*116; Material: STEEL/S235JR
Tekla Common - Center of gravity Z: 5890 mm; Center of gravity Y: 13499 mm; Bottom elevation: +5.832; Top elevation: +5.948; Part mark: 1249; Assembly mark: L104; Phase: 1; Class: 1003; Finish: GRENAILLE-PEINT; Grade: S235JR; Profile: PL3*116; Name: TOLE; sets with these values: 2
Tekla Quantity - Net weight: 0.316889 kg; Gross weight: 0.316889 kg; Weight: 0.316889 kg; Net volume: 0.000040368 m3; Gross volume: 0.000040368 m3; Gross footprint area: 0.000348 m2; Area per tons: 89.3184 m2; Net surface area: 0.028304 m2; Gross area: 0.028304 m2; Height: 116 mm; Width: 3 mm; Length: 116 mm; sets with these values: 2
BaseQuantities - Length: 116 mm; OuterSurfaceArea: 0.028304 m2; NetVolume: 0.000040368 m3; NetWeight: 0.316889 kg
Name | Center of gravity X (mm)
TOLE | 71933.5
TOLE | 79036.5

# IfcBeam: PL3*3600 (5)
In: Undefined
Description: PL3*3600; Material: STEEL/S235JR
Tekla Common - Center of gravity Z: 1800 mm; Bottom elevation: -0.000; Top elevation: +3.600; Phase: 5; Class: 5000; Finish: TOLGALVA; Grade: S235JR; Profile: PL3*3600; Name: FEUILLURE; sets with these values: 2
Tekla Quantity - Height: 3600 mm; Width: 3 mm; sets with these values: 2
Name | Center of gravity Y (mm) | Center of gravity X (mm) | Part mark | Assembly mark | Net weight (kg) = Gross weight (kg) = Weight (kg) = NetWeight (kg) | Net volume (m3) = Gross volume (m3) = NetVolume (m3) | Gross footprint area (m2) | Area per tons (m2) | Net surface area (m2) = Gross area (m2) = OuterSurfaceArea (m2) | Tekla Quantity, Length (mm) = BaseQuantities, Length (mm)
FEUILLURE | 11026.5 | 0 | 1237 | F3 | 14.4974 | 0.0018468 | 0.000513 | 86.4864 | 1.25383 | 171
FEUILLURE | 10302 | 882.5 | 1238 | F1 | 24.1623 | 0.003078 | 0.000855 | 85.8904 | 2.07531 | 285
FEUILLURE | 10215 | 816.5 | 1237 | F1 | 14.4974 | 0.0018468 | 0.000513 | 86.4864 | 1.25383 | 171
FEUILLURE | 10302 | 8627.5 | 1239 | F2 | 27.5535 | 0.00351 | 0.000975 | 85.7804 | 2.36355 | 325
FEUILLURE | 10215 | 8713.5 | 1237 | F2 | 14.4974 | 0.0018468 | 0.000513 | 86.4864 | 1.25383 | 171

# IfcBeam: PL3*56 (28)
In: Undefined
Description: PL3*56; Material: STEEL/S235JR
Tekla Common - Finish: GRENAILLE-PEINT; Grade: S235JR; Profile: PL3*56; Name: TOLE; sets with these values: 2
Tekla Quantity - Net weight: 0.0738528 kg; Gross weight: 0.0738528 kg; Weight: 0.0738528 kg; Net volume: 0.000009408 m3; Gross volume: 0.000009408 m3; Area per tons: 94.0249 m2; Net surface area: 0.006944 m2; Gross area: 0.006944 m2; Height: 56 mm; Width: 3 mm; Length: 56 mm; sets with these values: 2
BaseQuantities - Length: 56 mm; OuterSurfaceArea: 0.006944 m2; NetVolume: 0.000009408 m3; NetWeight: 0.0738528 kg
Name | Center of gravity Z (mm) | Center of gravity Y (mm) | Center of gravity X (mm) | Bottom elevation | Top elevation | Part mark | Assembly mark | Phase | Class | Gross footprint area (m2)
TOLE | 3728.79 | 20670 | 78355 | +3.727 | +3.730 | 1251 | P52 | 7 | 7001 | 0.003136
TOLE | 3271.46 | 20670 | 79315 | +3.270 | +3.273 | 1251 | P53 | 7 | 7001 | 0.003136
TOLE | 1720 | 19570 | 75018.5 | +1.692 | +1.748 | 1251 | L41 | 7 | 7001 | 0.000168
TOLE | 180 | 19570 | 75018.5 | +0.152 | +0.208 | 1251 | L41 | 7 | 7001 | 0.000168
TOLE | 180 | 19570 | 74336.5 | +0.152 | +0.208 | 1251 | L41 | 7 | 7001 | 0.000168
TOLE | 1720 | 19570 | 74336.5 | +1.692 | +1.748 | 1251 | L41 | 7 | 7001 | 0.000168
TOLE | 2130 | 20670 | 79273.5 | +2.102 | +2.158 | 1251 | L39 | 7 | 7001 | 0.000168
TOLE | 2130 | 20670 | 78396.5 | +2.102 | +2.158 | 1251 | L39 | 7 | 7001 | 0.000168
TOLE | 3145.98 | 20670 | 79273.5 | +3.118 | +3.174 | 1251 | L38 | 7 | 7001 | 0.000168
TOLE | 3145.98 | 20670 | 78396.5 | +3.118 | +3.174 | 1251 | L38 | 7 | 7001 | 0.000168
TOLE | 3562.96 | 20670 | 79333.5 | +3.535 | +3.591 | 1251 | L40 | 7 | 7001 | 0.000168
TOLE | 3562.96 | 20670 | 78396.5 | +3.535 | +3.591 | 1251 | L40 | 7 | 7001 | 0.000168
TOLE | 4418.5 | 69117 | 44095 | +4.417 | +4.420 | 1251 | L45 | 3 | 3003 | 0.003136
TOLE | 5586.5 | 69117 | 44095 | +5.585 | +5.588 | 1251 | L45 | 3 | 3003 | 0.003136
TOLE | 5586.5 | 69117 | 55770 | +5.585 | +5.588 | 1246 | L44 | 1 | 1003 | 0.003136
TOLE | 4418.5 | 69117 | 55770 | +4.417 | +4.420 | 1246 | L44 | 1 | 1003 | 0.003136
TOLE | 4418.5 | 69117 | 67445 | +4.417 | +4.420 | 1246 | L44 | 1 | 1003 | 0.003136
TOLE | 5586.5 | 69117 | 67445 | +5.585 | +5.588 | 1246 | L44 | 1 | 1003 | 0.003136
TOLE | 5656.5 | 61268.5 | 44095 | +5.655 | +5.658 | 1251 | N39 | 1 | 1006 | 0.003136
TOLE | 4238.5 | 61268.5 | 44095 | +4.237 | +4.240 | 1251 | N39 | 1 | 1006 | 0.003136
TOLE | 4238.5 | 61268.5 | 55770 | +4.237 | +4.240 | 1251 | N38 | 1 | 1006 | 0.003136
TOLE | 5656.5 | 61268.5 | 55770 | +5.655 | +5.658 | 1251 | N38 | 1 | 1006 | 0.003136
TOLE | 4418.5 | 33 | 44095 | +4.417 | +4.420 | 1251 | L43 | 3 | 3003 | 0.003136
TOLE | 5586.5 | 33.0001 | 44095 | +5.585 | +5.588 | 1251 | L43 | 3 | 3003 | 0.003136
TOLE | 5586.5 | 33.0001 | 55770 | +5.585 | +5.588 | 1246 | L42 | 1 | 1003 | 0.003136
TOLE | 4418.5 | 33 | 55770 | +4.417 | +4.420 | 1246 | L42 | 1 | 1003 | 0.003136
TOLE | 4418.5 | 33 | 67445 | +4.417 | +4.420 | 1246 | L42 | 1 | 1003 | 0.003136
TOLE | 5586.5 | 33.0001 | 67445 | +5.585 | +5.588 | 1246 | L42 | 1 | 1003 | 0.003136

# IfcBeam: PL3*66 (10)
In: Undefined
Description: PL3*66; Material: STEEL/S235JR
Tekla Common - Finish: GRENAILLE-PEINT; Grade: S235JR; Profile: PL3*66; Name: TOLE; sets with these values: 2
Tekla Quantity - Gross footprint area: 0.000198 m2; Area per tons: 92.6462 m2; Height: 66 mm; Width: 3 mm; sets with these values: 2
Name | Center of gravity Z (mm) | Center of gravity Y (mm) | Center of gravity X (mm) | Bottom elevation | Top elevation | Part mark | Assembly mark | Phase | Class | Net weight (kg) = Gross weight (kg) = Weight (kg) = NetWeight (kg) | Net volume (m3) = Gross volume (m3) = NetVolume (m3) | Net surface area (m2) = Gross area (m2) = OuterSurfaceArea (m2) | Tekla Quantity, Length (mm) = BaseQuantities, Length (mm)
TOLE | 135 | 20693.5 | 78290 | +0.102 | +0.168 | 1253 | L110 | 7 | 7001 | 0.102584 | 0.000013068 | 0.009504 | 66
TOLE | 135 | 19546.5 | 78290 | +0.102 | +0.168 | 1253 | L110 | 7 | 7001 | 0.102584 | 0.000013068 | 0.009504 | 66
TOLE | 1785 | 20693.5 | 78290 | +1.752 | +1.818 | 1253 | L110 | 7 | 7001 | 0.102584 | 0.000013068 | 0.009504 | 66
TOLE | 1785 | 19546.5 | 78290 | +1.752 | +1.818 | 1253 | L110 | 7 | 7001 | 0.102584 | 0.000013068 | 0.009504 | 66
TOLE | 3150.98 | 19546.5 | 78290 | +3.118 | +3.184 | 1253 | L110 | 7 | 7001 | 0.102584 | 0.000013068 | 0.009504 | 66
TOLE | 3150.98 | 20693.5 | 78290 | +3.118 | +3.184 | 1253 | L110 | 7 | 7001 | 0.102584 | 0.000013068 | 0.009504 | 66
TOLE | 3695.29 | 21853.7 | 78290 | +3.662 | +3.728 | 1253 | L109 | 7 | 7001 | 0.102584 | 0.000013068 | 0.009504 | 66
TOLE | 3695.29 | 19829.6 | 78290 | +3.662 | +3.728 | 1253 | L109 | 7 | 7001 | 0.102584 | 0.000013068 | 0.009504 | 66
TOLE | 5575.89 | 13474 | 75589.6 | +5.543 | +5.609 | 1250 | L105 | 1 | 1003 | 0.102585 | 0.0000130681 | 0.0095041 | 66.0007
TOLE | 5469.29 | 13474 | 79027.6 | +5.436 | +5.502 | 1250 | L105 | 1 | 1003 | 0.102585 | 0.0000130681 | 0.0095041 | 66.0007

# IfcBeam: PL3*76 (20)
In: Undefined
Description: PL3*76; Material: STEEL/E24-2
Tekla Common - Center of gravity Z: 3080 mm; Bottom elevation: +3.042; Top elevation: +3.118; Part mark: 1245; Phase: 6; Class: 6001; Finish: GRENAILLE-PEINT; Grade: E24-2; Profile: PL3*76; Name: TOLE; sets with these values: 2
Tekla Quantity - Net weight: 0.136025 kg; Gross weight: 0.136025 kg; Weight: 0.136025 kg; Net volume: 0.000017328 m3; Gross volume: 0.000017328 m3; Gross footprint area: 0.000228 m2; Area per tons: 91.6303 m2; Net surface area: 0.012464 m2; Gross area: 0.012464 m2; Height: 76 mm; Width: 3 mm; Length: 76 mm; sets with these values: 2
BaseQuantities - Length: 76 mm; OuterSurfaceArea: 0.012464 m2; NetVolume: 0.000017328 m3; NetWeight: 0.136025 kg
Name | Center of gravity Y (mm) | Center of gravity X (mm) | Assembly mark
TOLE | 15063.5 | 6325 | L82
TOLE | 14726.5 | 6245 | S87
TOLE | 10031.5 | 6325 | L82
TOLE | 19456.5 | 3315 | L83
TOLE | 19443.5 | 3315 | L84
TOLE | 15196.5 | 3315 | L84
TOLE | 15183.5 | 3315 | L86
TOLE | 10031.5 | 3315 | L86
TOLE | 23919 | 3235 | S88
TOLE | 24256 | 3315 | L83
TOLE | 33473.5 | 650 | L81
TOLE | 29581.5 | 650 | L81
TOLE | 29568.5 | 650 | L85
TOLE | 24519 | 650 | L85
TOLE | 24506 | 650 | L85
TOLE | 19456.5 | 650 | L85
TOLE | 19443.5 | 650 | L84
TOLE | 15196.5 | 650 | L84
TOLE | 15183.5 | 650 | L87
TOLE | 10331.5 | 650 | L87

# IfcBeam: PL3*86 (10)
In: Undefined
Description: PL3*86; Material: STEEL/S235JR
Tekla Common - Finish: GRENAILLE-PEINT; Grade: S235JR; Profile: PL3*86; Name: TOLE; sets with these values: 2
Tekla Quantity - Net weight: 0.174176 kg; Gross weight: 0.174176 kg; Weight: 0.174176 kg; Net volume: 0.000022188 m3; Gross volume: 0.000022188 m3; Gross footprint area: 0.000258 m2; Area per tons: 90.8507 m2; Net surface area: 0.015824 m2; Gross area: 0.015824 m2; Height: 86 mm; Width: 3 mm; Length: 86 mm; sets with these values: 2
BaseQuantities - Length: 86 mm; OuterSurfaceArea: 0.015824 m2; NetVolume: 0.000022188 m3; NetWeight: 0.174176 kg
Name | Center of gravity Z (mm) | Center of gravity Y (mm) | Center of gravity X (mm) | Bottom elevation | Top elevation | Part mark | Assembly mark | Phase | Class
