Properties of the parts of a building model (IFC2X3), part 1 of 32

# File
Description: ViewDefinition [CoordinationView, QuantityTakeOffAddOnView]
File name: NavBimVILQUIN.ifc
Time: 2011-07-12T17:19:12
Author: PORTCM01/professeur
Organization: Structural Designer
Written by: IFC Database Version:Work
Made in: Tekla Structures 18.1 Build:12518/10.9.2012, IFC Export Version: 309Mar 29 2012

# IfcSite, Undefined
RefElevation: 0 mm

# IfcBuildingStorey, Undefined
In: Undefined
Elevation: 0 mm

# IfcBeam: BLL100*50*2, LISSE
In: Undefined
Description: BLL100*50*2; Material: STEEL/E24-2
Tekla Common - Center of gravity Z: 3587.08 mm; Center of gravity Y: 19574.1 mm; Center of gravity X: 77095.2 mm; Bottom elevation: +3.515; Top elevation: +3.627; Part mark: L121; Assembly mark: L121; Phase: 7; Class: 7001; Finish: GALVA; Grade: E24-2; Profile: BLL100*50*2; Name: LISSE; sets with these values: 2
Tekla Quantity - Net weight: 4.6472 kg; Gross weight: 4.6472 kg; Weight: 4.6472 kg; Net volume: 0.000592 m3; Gross volume: 0.000592 m3; Gross footprint area: 0 m2; Area per tons: 129.237 m2; Net surface area: 0.600592 m2; Gross area: 0.600592 m2; Height: 100 mm; Width: 50 mm; Length: 2000 mm; sets with these values: 2
BaseQuantities - Length: 2000 mm; OuterSurfaceArea: 0.600592 m2; NetVolume: 0.000592 m3; NetWeight: 4.6472 kg

# IfcBeam: BLL300*60*1.5 (2)
In: Undefined
Description: BLL300*60*1.5; Material: STEEL/E24-2
Tekla Common - Bottom elevation: +3.505; Phase: 7; Class: 7001; Finish: GALVA; Grade: E24-2; Profile: BLL300*60*1.5; Name: LISSE; sets with these values: 2
Tekla Quantity - Gross footprint area: 0 m2; Height: 300 mm; Width: 60 mm; sets with these values: 2
Name | Center of gravity Z (mm) | Center of gravity Y (mm) | Center of gravity X (mm) | Top elevation | Part mark = Assembly mark | Net weight (kg) = Weight (kg) = NetWeight (kg) | Gross weight (kg) | Net volume (m3) = NetVolume (m3) | Gross volume (m3) | Area per tons (m2) | Net surface area (m2) = OuterSurfaceArea (m2) | Gross area (m2) | Tekla Quantity, Length (mm) = BaseQuantities, Length (mm)
LISSE | 3606.04 | 19665.6 | 76595.5 | +3.658 | L120 | 12.664 | 12.664 | 0.00161325 | 0.00161325 | 170.647 | 2.16108 | 2.16108 | 3000
LISSE | 3615.5 | 19660.9 | 76286.3 | +3.682 | L119 | 14.4102 | 15.9643 | 0.0018357 | 0.00203367 | 170.782 | 2.461 | 2.72398 | 3781.82

# IfcBeam: BLU300*80*5 (2)
In: Undefined
Description: BLU300*80*5; Material: STEEL/E24-2
Tekla Common - Center of gravity Z: 4615.83 mm; Center of gravity Y: -75 mm; Bottom elevation: +4.600; Top elevation: +4.680; Phase: 1; Class: 1003; Finish: GRENAILLE-PEINT; Grade: E24-2; Profile: BLU300*80*5; Name: LINTEAU; sets with these values: 2
Tekla Quantity - Height: 300 mm; Width: 80 mm; sets with these values: 2
Name | Center of gravity X (mm) | Part mark | Assembly mark | Net weight (kg) = Gross weight (kg) = Weight (kg) = NetWeight (kg) | Net volume (m3) = Gross volume (m3) = NetVolume (m3) | Gross footprint area (m2) | Area per tons (m2) | Net surface area (m2) = Gross area (m2) = OuterSurfaceArea (m2) | Tekla Quantity, Length (mm) = BaseQuantities, Length (mm)
LINTEAU | 76585 | 889 | L5 | 61.6068 | 0.007848 | 0.03488 | 51.5946 | 3.17858 | 3488
LINTEAU | 72400 | 888 | L4 | 49.243 | 0.006273 | 0.02788 | 51.613 | 2.54158 | 2788

# IfcBeam: FPL255*8 (4)
In: Undefined
Description: FPL255*8; Material: STEEL/E24-2
Tekla Common - Center of gravity Y: -57.5 mm; Phase: 1; Class: 1003; Finish: GRENAILLE-PEINT; Grade: E24-2; Profile: FPL255*8; Name: ATTACHE; sets with these values: 2
Tekla Quantity - Gross footprint area: 0 m2; Height: 8 mm; Width: 255 mm; sets with these values: 2
Name | Center of gravity Z (mm) | Center of gravity X (mm) | Bottom elevation | Top elevation | Part mark = Assembly mark | Net weight (kg) = Weight (kg) = NetWeight (kg) | Gross weight (kg) | Net volume (m3) = Gross volume (m3) = NetVolume (m3) | Area per tons (m2) | Net surface area (m2) = OuterSurfaceArea (m2) | Gross area (m2) | Tekla Quantity, Length (mm) = BaseQuantities, Length (mm)
ATTACHE | 4905.93 | 73782.4 | +4.819 | +4.952 | H52 | 3.20284 | 3.07864 | 0.000408005 | 34.1201 | 0.109281 | 0.00153797 | 192.247
ATTACHE | 4884.32 | 71026.7 | +4.796 | +4.937 | H51 | 3.37354 | 3.27538 | 0.00042975 | 34.0557 | 0.114888 | 0.00163626 | 204.532
ATTACHE | 4773.87 | 78315.9 | +4.699 | +4.811 | H53 | 2.88256 | 2.75836 | 0.000367205 | 34.2617 | 0.0987614 | 0.00137797 | 172.247
ATTACHE | 4872.9 | 74852.7 | +4.787 | +4.917 | H54 | 3.20284 | 3.07069 | 0.000408005 | 34.1201 | 0.109281 | 0.001534 | 191.751

# IfcBeam: FPL3*3600 (6)
In: Undefined
Description: FPL3*3600; Material: STEEL/S235JR
Tekla Common - Center of gravity Z: 1800 mm; Bottom elevation: -0.000; Top elevation: +3.600; Phase: 5; Class: 5000; Finish: TOLGALVA; Grade: S235JR; Profile: FPL3*3600; Name: FEUILLURE; sets with these values: 2
Tekla Quantity - Height: 3 mm; Width: 3600 mm; sets with these values: 2
Name | Center of gravity Y (mm) | Center of gravity X (mm) | Part mark | Assembly mark | Net weight (kg) = Weight (kg) = NetWeight (kg) | Gross weight (kg) | Net volume (m3) = Gross volume (m3) = NetVolume (m3) | Gross footprint area (m2) | Area per tons (m2) | Net surface area (m2) = OuterSurfaceArea (m2) | Gross area (m2) | Tekla Quantity, Length (mm) = BaseQuantities, Length (mm)
FEUILLURE | 26100 | 97.1598 | F4 | F4 | 41.3726 | 40.3553 | 0.0052704 | 0.001464 | 85.5185 | 3.53813 | 0.001428 | 476
FEUILLURE | 18560 | 97.1598 | F4 | F4 | 41.3726 | 40.3553 | 0.0052704 | 0.001464 | 85.5185 | 3.53813 | 0.001428 | 476
FEUILLURE | 10171 | 908.969 | 1374 | F1 | 36.1163 | 35.6076 | 0.0046008 | 0.001278 | 85.5945 | 3.09136 | 0.00126 | 420
FEUILLURE | 11115.2 | -16.6667 | 1375 | F3 | 39.9314 | 39.9314 | 0.0050868 | 0.001413 | 85.5374 | 3.41563 | 0.001413 | 471
FEUILLURE | 11062.5 | 85.9868 | 1376 | F3 | 19.2451 | 18.9907 | 0.0024516 | 0.000681 | 86.1188 | 1.65736 | 0.000672 | 224
FEUILLURE | 10167.3 | 8597.25 | 1373 | F2 | 39.5075 | 38.9988 | 0.0050328 | 0.001398 | 85.5432 | 3.3796 | 0.00138 | 460

# IfcBeam: FPL370*6, ATTACHE
In: Undefined
Description: FPL370*6; Material: STEEL/E24-2
Tekla Common - Center of gravity Z: 3548.02 mm; Center of gravity Y: 19730 mm; Center of gravity X: 78056.8 mm; Bottom elevation: +3.485; Top elevation: +3.569; Part mark: H48; Assembly mark: H48; Phase: 7; Class: 7001; Finish: GRENAILLE-PEINT; Grade: E24-2; Profile: FPL370*6; Name: ATTACHE; sets with these values: 2
Tekla Quantity - Net weight: 3.38661 kg; Gross weight: 3.28528 kg; Weight: 3.38661 kg; Net volume: 0.000431415 m3; Gross volume: 0.000431415 m3; Gross footprint area: 0 m2; Area per tons: 44.4625 m2; Net surface area: 0.150577 m2; Gross area: 0.0011311 m2; Height: 6 mm; Width: 370 mm; Length: 188.516 mm; sets with these values: 2
BaseQuantities - Length: 188.516 mm; OuterSurfaceArea: 0.150577 m2; NetVolume: 0.000431415 m3; NetWeight: 3.38661 kg

# IfcBeam: FPL6*1050 (3)
In: Undefined
Description: FPL6*1050; Material: STEEL/E24-2
Tekla Common - Center of gravity Z: 5190 mm; Center of gravity Y: 19584.9 mm; Bottom elevation: +4.665; Top elevation: +5.715; Finish: GRENAILLE-PEINT; Grade: E24-2; Profile: FPL6*1050; sets with these values: 2
Tekla Quantity - Net weight: 4.82186 kg; Gross weight: 4.52513 kg; Weight: 4.82186 kg; Net volume: 0.00061425 m3; Gross volume: 0.00061425 m3; Gross footprint area: 0.000585 m2; Area per tons: 45.3186 m2; Net surface area: 0.21852 m2; Gross area: 0.000549 m2; Height: 6 mm; Width: 1050 mm; Length: 91.4999 mm; sets with these values: 2
BaseQuantities - Length: 91.4999 mm; OuterSurfaceArea: 0.21852 m2; NetVolume: 0.00061425 m3; NetWeight: 4.82186 kg
Name | Center of gravity X (mm) | Part mark | Assembly mark | Phase | Class
 | 55756.8 | 863 | P36 | 1 | 1001
 | 32406.8 | 862 | P32 | 3 | 3001
 | 44081.8 | 863 | P36 | 1 | 1001

# IfcBeam: FPL6*120 (18)
In: Undefined
Description: FPL6*120; Material: STEEL/E24-2
Tekla Common - Bottom elevation: +5.509; Top elevation: +5.584; Finish: GRENAILLE-PEINT; Grade: E24-2; Profile: FPL6*120; Name: ATTACHE; sets with these values: 2
Tekla Quantity - Gross weight: 0.76302 kg; Gross volume: 0.000101024 m3; Gross footprint area: 0.00072 m2; Gross area: 0.00081 m2; Height: 6 mm; Width: 120 mm; Length: 135 mm; sets with these values: 2
BaseQuantities - Length: 135 mm
Name | Center of gravity Z (mm) | Center of gravity Y (mm) | Center of gravity X (mm) | Part mark = Assembly mark | Phase | Class | Net weight (kg) = Weight (kg) = NetWeight (kg) | Net volume (m3) = NetVolume (m3) | Area per tons (m2) | Net surface area (m2) = OuterSurfaceArea (m2)
ATTACHE | 5533.2 | 40065 | 20879.3 | H49 | 3 | 3004 | 0.793042 | 0.000101024 | 46.4018 | 0.0367986
ATTACHE | 5533.2 | 19265 | 20879.3 | H49 | 3 | 3004 | 0.793042 | 0.000101024 | 46.4018 | 0.0367986
ATTACHE | 5533.2 | 19635 | 20879.3 | H49 | 3 | 3004 | 0.793042 | 0.000101024 | 46.4018 | 0.0367986
ATTACHE | 5533.2 | 40435 | 67579.3 | H49 | 1 | 1004 | 0.793042 | 0.000101024 | 46.4018 | 0.0367986
ATTACHE | 5533.2 | 40065 | 67579.3 | H49 | 1 | 1004 | 0.793042 | 0.000101024 | 46.4018 | 0.0367986
ATTACHE | 5533.2 | 40435 | 32554.3 | H49 | 3 | 3004 | 0.793042 | 0.000101024 | 46.4018 | 0.0367986
ATTACHE | 5533.2 | 40065 | 32554.3 | H49 | 3 | 3004 | 0.793042 | 0.000101024 | 46.4018 | 0.0367986
ATTACHE | 5533.2 | 40065 | 44229.3 | H49 | 1 | 1004 | 0.793042 | 0.000101024 | 46.4018 | 0.0367986
ATTACHE | 5533.2 | 40435 | 44229.3 | H49 | 1 | 1004 | 0.793042 | 0.000101024 | 46.4018 | 0.0367986
ATTACHE | 5533.54 | 19635.9 | 67578.5 | H46 | 1 | 1009 | 0.779671 | 0.0000993212 | 46.3629 | 0.0361478
ATTACHE | 5533.2 | 40435 | 55904.3 | H49 | 1 | 1004 | 0.793042 | 0.000101024 | 46.4018 | 0.0367986
ATTACHE | 5533.2 | 19265 | 32554.3 | H49 | 3 | 3004 | 0.793042 | 0.000101024 | 46.4018 | 0.0367986
ATTACHE | 5533.2 | 19265 | 44229.3 | H49 | 1 | 1004 | 0.793042 | 0.000101024 | 46.4018 | 0.0367986
ATTACHE | 5533.2 | 19635 | 32554.3 | H49 | 3 | 3004 | 0.793042 | 0.000101024 | 46.4018 | 0.0367986
ATTACHE | 5533.2 | 19635 | 44229.3 | H49 | 1 | 1004 | 0.793042 | 0.000101024 | 46.4018 | 0.0367986
ATTACHE | 5533.2 | 40065 | 55904.3 | H49 | 1 | 1004 | 0.793042 | 0.000101024 | 46.4018 | 0.0367986
ATTACHE | 5533.2 | 19635 | 55904.3 | H49 | 1 | 1004 | 0.793042 | 0.000101024 | 46.4018 | 0.0367986
ATTACHE | 5533.2 | 19265 | 55904.3 | H49 | 1 | 1004 | 0.793042 | 0.000101024 | 46.4018 | 0.0367986

# IfcBeam: FPL6*50 (92)
In: Undefined
Description: FPL6*50; Material: STEEL/E24-2
Tekla Common - Part mark: H47; Assembly mark: H47; Finish: GRENAILLE-PEINT; Grade: E24-2; Profile: FPL6*50; Name: ATTACHE; sets with these values: 2
Tekla Quantity - Net weight: 0.393167 kg; Gross weight: 0.379037 kg; Weight: 0.393167 kg; Net volume: 0.000050085 m3; Gross volume: 0.000050085 m3; Gross footprint area: 0 m2; Area per tons: 49.0845 m2; Net surface area: 0.0192984 m2; Gross area: 0.0009657 m2; Height: 6 mm; Width: 50 mm; Length: 160.95 mm; sets with these values: 2
BaseQuantities - Length: 160.95 mm; OuterSurfaceArea: 0.0192984 m2; NetVolume: 0.000050085 m3; NetWeight: 0.393167 kg
Name | Center of gravity Z (mm) | Center of gravity Y (mm) | Center of gravity X (mm) | Bottom elevation | Top elevation | Phase | Class
ATTACHE | 10256.5 | 63792.3 | 28860.8 | +10.230 | +10.282 | 2 | 2005
ATTACHE | 10257.4 | 63792.3 | 28829.7 | +10.232 | +10.284 | 2 | 2005
ATTACHE | 5358.6 | 27703.2 | 78028.3 | +5.333 | +5.385 | 1 | 1010
ATTACHE | 5357.98 | 27703.2 | 78059.4 | +5.332 | +5.383 | 1 | 1010
ATTACHE | 5358.61 | 26586.8 | 78028.3 | +5.333 | +5.385 | 1 | 1010
ATTACHE | 5357.98 | 26586.8 | 78059.4 | +5.332 | +5.383 | 1 | 1010
ATTACHE | 5412.33 | 27703.2 | 75342 | +5.387 | +5.438 | 1 | 1010
ATTACHE | 5411.71 | 27703.2 | 75373.1 | +5.386 | +5.437 | 1 | 1010
ATTACHE | 5412.34 | 26586.8 | 75342 | +5.387 | +5.438 | 1 | 1010
ATTACHE | 5411.71 | 26586.8 | 75373.1 | +5.386 | +5.437 | 1 | 1010
ATTACHE | 5466.32 | 27703.2 | 72642 | +5.441 | +5.492 | 1 | 1010
ATTACHE | 5465.7 | 27703.2 | 72673.1 | +5.440 | +5.491 | 1 | 1010
ATTACHE | 5465.7 | 26586.8 | 72673.1 | +5.440 | +5.491 | 1 | 1010
ATTACHE | 5466.33 | 26586.8 | 72642 | +5.441 | +5.492 | 1 | 1010
ATTACHE | 5358.61 | 30586.8 | 78028.3 | +5.333 | +5.385 | 1 | 1010
ATTACHE | 5357.98 | 30586.8 | 78059.4 | +5.332 | +5.383 | 1 | 1010
ATTACHE | 5358.6 | 31703.2 | 78028.3 | +5.333 | +5.385 | 1 | 1010
ATTACHE | 5357.98 | 31703.2 | 78059.4 | +5.332 | +5.383 | 1 | 1010
ATTACHE | 5411.71 | 31703.2 | 75373.1 | +5.386 | +5.437 | 1 | 1010
ATTACHE | 5412.33 | 31703.2 | 75342 | +5.387 | +5.438 | 1 | 1010
ATTACHE | 5412.34 | 30586.8 | 75342 | +5.387 | +5.438 | 1 | 1010
ATTACHE | 5411.71 | 30586.8 | 75373.1 | +5.386 | +5.437 | 1 | 1010
ATTACHE | 5465.7 | 30586.8 | 72673.1 | +5.440 | +5.491 | 1 | 1010
ATTACHE | 5466.33 | 30586.8 | 72642 | +5.441 | +5.492 | 1 | 1010
ATTACHE | 5466.32 | 31703.2 | 72642 | +5.441 | +5.492 | 1 | 1010
ATTACHE | 5465.7 | 31703.2 | 72673.1 | +5.440 | +5.491 | 1 | 1010
ATTACHE | 5067.83 | 41.5729 | 78008 | +5.042 | +5.094 | 1 | 1010
ATTACHE | 5066.87 | 41.5729 | 78039 | +5.040 | +5.092 | 1 | 1010
ATTACHE | 5067.83 | 2508.43 | 78008 | +5.042 | +5.094 | 1 | 1010
ATTACHE | 5066.87 | 2508.43 | 78039 | +5.040 | +5.092 | 1 | 1010
ATTACHE | 5144.56 | 41.5729 | 75533 | +5.119 | +5.171 | 1 | 1010
ATTACHE | 5143.6 | 41.5729 | 75564 | +5.117 | +5.169 | 1 | 1010
ATTACHE | 5144.56 | 2508.43 | 75533 | +5.119 | +5.171 | 1 | 1010
ATTACHE | 5143.6 | 2508.43 | 75564 | +5.117 | +5.169 | 1 | 1010
ATTACHE | 5221.28 | 41.5729 | 73058 | +5.196 | +5.248 | 1 | 1010
ATTACHE | 5220.32 | 41.5729 | 73089 | +5.194 | +5.246 | 1 | 1010
ATTACHE | 5221.28 | 2508.43 | 73058 | +5.196 | +5.248 | 1 | 1010
ATTACHE | 5220.32 | 2508.43 | 73089 | +5.194 | +5.246 | 1 | 1010
ATTACHE | 5298.01 | 41.5729 | 70583 | +5.273 | +5.324 | 1 | 1010
ATTACHE | 5297.05 | 41.5729 | 70614 | +5.271 | +5.322 | 1 | 1010
ATTACHE | 5298.01 | 2508.43 | 70583 | +5.273 | +5.324 | 1 | 1010
ATTACHE | 5297.05 | 2508.43 | 70614 | +5.271 | +5.322 | 1 | 1010
ATTACHE | 5374.73 | 2508.43 | 68108 | +5.349 | +5.401 | 1 | 1010
ATTACHE | 5373.77 | 2508.43 | 68139 | +5.347 | +5.399 | 1 | 1010
ATTACHE | 5373.77 | 41.5729 | 68139 | +5.347 | +5.399 | 1 | 1010
ATTACHE | 5374.73 | 41.5729 | 68108 | +5.349 | +5.401 | 1 | 1010
ATTACHE | 5298.01 | 19230.5 | 70583 | +5.273 | +5.324 | 1 | 1010
ATTACHE | 5297.05 | 19230.5 | 70614.1 | +5.271 | +5.322 | 1 | 1010
ATTACHE | 5298.01 | 17131.6 | 70583 | +5.273 | +5.324 | 1 | 1010
ATTACHE | 5297.05 | 17131.6 | 70614 | +5.271 | +5.322 | 1 | 1010
ATTACHE | 5373.77 | 17131.6 | 68139 | +5.347 | +5.399 | 1 | 1010
ATTACHE | 5374.73 | 17131.6 | 68108 | +5.349 | +5.401 | 1 | 1010
ATTACHE | 5374.73 | 19230.5 | 68108 | +5.349 | +5.401 | 1 | 1010
ATTACHE | 5373.77 | 19230.5 | 68139.1 | +5.347 | +5.399 | 1 | 1010
ATTACHE | 5360.17 | 19491.6 | 70910.7 | +5.330 | +5.387 | 1 | 1010
ATTACHE | 5363.94 | 19491.6 | 70879.8 | +5.338 | +5.395 | 1 | 1010
ATTACHE | 5360.17 | 22008.4 | 70910.7 | +5.330 | +5.387 | 1 | 1010
ATTACHE | 5363.94 | 22008.4 | 70879.8 | +5.338 | +5.395 | 1 | 1010
ATTACHE | 5360.17 | 24691.6 | 70910.7 | +5.330 | +5.387 | 1 | 1010
ATTACHE | 5363.94 | 24691.6 | 70879.8 | +5.338 | +5.395 | 1 | 1010
ATTACHE | 5360.17 | 27208.4 | 70910.7 | +5.330 | +5.387 | 1 | 1010
ATTACHE | 5363.94 | 27208.4 | 70879.8 | +5.338 | +5.395 | 1 | 1010
ATTACHE | 5360.17 | 32492.5 | 70910.7 | +5.330 | +5.387 | 1 | 1010
ATTACHE | 5363.94 | 32492.5 | 70879.8 | +5.338 | +5.395 | 1 | 1010
ATTACHE | 5363.94 | 35008.4 | 70879.8 | +5.338 | +5.395 | 1 | 1010
ATTACHE | 5360.17 | 35008.4 | 70910.7 | +5.330 | +5.387 | 1 | 1010
ATTACHE | 3338.81 | 45808.2 | 10391.2 | +3.312 | +3.364 | 2 | 2005
ATTACHE | 10520.5 | 63792.3 | 20342.7 | +10.495 | +10.547 | 2 | 2005
ATTACHE | 10345.1 | 52647.7 | 26001.7 | +10.320 | +10.372 | 2 | 2005
ATTACHE | 10344.1 | 63792.3 | 26032.8 | +10.318 | +10.370 | 2 | 2005
ATTACHE | 10431.8 | 52647.7 | 23204.8 | +10.405 | +10.457 | 2 | 2005
ATTACHE | 10432.8 | 63792.3 | 23173.7 | +10.407 | +10.459 | 2 | 2005
ATTACHE | 10519.6 | 63792.3 | 20373.8 | +10.493 | +10.545 | 2 | 2005
ATTACHE | 10431.8 | 63792.3 | 23204.8 | +10.405 | +10.457 | 2 | 2005
ATTACHE | 10345.1 | 63792.3 | 26001.7 | +10.320 | +10.372 | 2 | 2005
ATTACHE | 10344.1 | 52647.7 | 26032.8 | +10.318 | +10.370 | 2 | 2005
ATTACHE | 10432.8 | 52647.7 | 23173.7 | +10.407 | +10.459 | 2 | 2005
ATTACHE | 10169.8 | 63792.3 | 31657.7 | +10.144 | +10.196 | 2 | 2005
ATTACHE | 10168.8 | 52647.7 | 31688.8 | +10.142 | +10.194 | 2 | 2005
ATTACHE | 10257.4 | 52647.7 | 28829.7 | +10.232 | +10.284 | 2 | 2005
ATTACHE | 10520.5 | 52647.7 | 20342.7 | +10.495 | +10.547 | 2 | 2005
ATTACHE | 10168.8 | 63792.3 | 31688.8 | +10.142 | +10.194 | 2 | 2005
ATTACHE | 10256.5 | 52647.7 | 28860.8 | +10.230 | +10.282 | 2 | 2005
ATTACHE | 10169.8 | 52647.7 | 31657.7 | +10.144 | +10.196 | 2 | 2005
ATTACHE | 10519.6 | 52647.7 | 20373.8 | +10.493 | +10.545 | 2 | 2005
ATTACHE | 3338.81 | 48483.4 | 10391.2 | +3.312 | +3.364 | 2 | 2005
ATTACHE | 3339.78 | 45808.2 | 10422.3 | +3.314 | +3.366 | 2 | 2005
ATTACHE | 3339.78 | 48483.4 | 10422.3 | +3.314 | +3.366 | 2 | 2005
ATTACHE | 3339.78 | 13018.4 | 10422.3 | +3.314 | +3.366 | 2 | 2005
ATTACHE | 3339.78 | 10971.6 | 10422.3 | +3.314 | +3.366 | 2 | 2005
ATTACHE | 3338.81 | 13018.4 | 10391.2 | +3.312 | +3.364 | 2 | 2005
ATTACHE | 3338.81 | 10971.6 | 10391.2 | +3.312 | +3.364 | 2 | 2005

# IfcBeam: FPL6*86 (16)
In: Undefined
Description: FPL6*86; Material: STEEL/S235JR
Tekla Common - Part mark: 861; Finish: GRENAILLE-PEINT; Grade: S235JR; Profile: FPL6*86; Name: PLAT; sets with these values: 2
Tekla Quantity - Net weight: 0.652147 kg; Gross weight: 0.627843 kg; Weight: 0.652147 kg; Net volume: 0.000083076 m3; Gross volume: 0.000083076 m3; Area per tons: 47.0078 m2; Net surface area: 0.030656 m2; Gross area: 0.00093 m2; Height: 6 mm; Width: 86 mm; Length: 155 mm; sets with these values: 2
BaseQuantities - Length: 155 mm; OuterSurfaceArea: 0.030656 m2; NetVolume: 0.000083076 m3; NetWeight: 0.652147 kg
Name | Center of gravity Z (mm) | Center of gravity Y (mm) | Center of gravity X (mm) | Bottom elevation | Top elevation | Assembly mark | Phase | Class | Gross footprint area (m2)
PLAT | 4789.89 | 69197 | 44080.3 | +4.757 | +4.858 | L22 | 3 | 3003 | 0.000516
PLAT | 5857.21 | 69197 | 35598.5 | +5.789 | +5.890 | L22 | 3 | 3003 | 0.005676
PLAT | 4789.89 | 69197 | 55755.3 | +4.757 | +4.858 | L22 | 1 | 1003 | 0.000516
PLAT | 5857.21 | 69197 | 47273.5 | +5.789 | +5.890 | L22 | 1 | 1003 | 0.005676
PLAT | 5857.21 | 69197 | 58948.5 | +5.789 | +5.890 | L22 | 1 | 1003 | 0.005676
PLAT | 4789.89 | 69197 | 67430.3 | +4.757 | +4.858 | L22 | 1 | 1003 | 0.000516
PLAT | 5857.21 | -46.9999 | 35598.5 | +5.789 | +5.890 | L21 | 3 | 3003 | 0.005676
PLAT | 4789.89 | -46.9999 | 44080.3 | +4.757 | +4.858 | L21 | 3 | 3003 | 0.000516
PLAT | 4789.89 | -46.9999 | 55755.3 | +4.757 | +4.858 | L21 | 1 | 1003 | 0.000516
PLAT | 4789.89 | -46.9999 | 32405.3 | +4.757 | +4.858 | L24 | 3 | 3003 | 0.000516
PLAT | 5857.21 | -46.9999 | 47273.5 | +5.789 | +5.890 | L21 | 1 | 1003 | 0.005676
PLAT | 5857.21 | -46.9999 | 58948.5 | +5.789 | +5.890 | L21 | 1 | 1003 | 0.005676
PLAT | 4789.89 | -46.9999 | 67430.3 | +4.757 | +4.858 | L21 | 1 | 1003 | 0.000516
PLAT | 5857.21 | -46.9999 | 23923.5 | +5.789 | +5.890 | L24 | 3 | 3003 | 0.005676
PLAT | 4800.38 | 69197 | 79064.3 | +4.768 | +4.869 | L23 | 1 | 1003 | 0.000516
PLAT | 5857.21 | 69197 | 70623.5 | +5.789 | +5.890 | L23 | 1 | 1003 | 0.005676

# IfcBeam: FPL6*90 (32)
In: Undefined
Description: FPL6*90; Material: STEEL/E24-2
Tekla Common - Part mark: H45; Assembly mark: H45; Phase: 1; Class: 1010; Finish: GRENAILLE-PEINT; Grade: E24-2; Profile: FPL6*90; Name: ATTACHE; sets with these values: 2
Tekla Quantity - Net weight: 0.707701 kg; Gross weight: 0.682267 kg; Weight: 0.707701 kg; Net volume: 0.000090153 m3; Gross volume: 0.000090153 m3; Gross footprint area: 0 m2; Area per tons: 46.8198 m2; Net surface area: 0.0331344 m2; Gross area: 0.0009657 m2; Height: 6 mm; Width: 90 mm; Length: 160.95 mm; sets with these values: 2
BaseQuantities - Length: 160.95 mm; OuterSurfaceArea: 0.0331344 m2; NetVolume: 0.000090153 m3; NetWeight: 0.707701 kg
Name | Center of gravity Z (mm) | Center of gravity Y (mm) | Center of gravity X (mm) | Bottom elevation | Top elevation
ATTACHE | 3744.06 | 19758.4 | 77926.8 | +3.699 | +3.791
ATTACHE | 3743.08 | 19758.4 | 77958.4 | +3.697 | +3.788
ATTACHE | 3744.06 | 17758.3 | 77926.8 | +3.699 | +3.791
ATTACHE | 3743.08 | 17758.3 | 77958.4 | +3.697 | +3.788
ATTACHE | 3773.23 | 19758.4 | 76985.8 | +3.728 | +3.820
ATTACHE | 3772.25 | 19758.4 | 77017.4 | +3.726 | +3.818
ATTACHE | 3773.23 | 17758.3 | 76985.8 | +3.728 | +3.820
ATTACHE | 3772.25 | 17758.3 | 77017.4 | +3.726 | +3.818
ATTACHE | 3871.62 | 21841.8 | 73811.8 | +3.826 | +3.918
ATTACHE | 3870.63 | 21841.8 | 73843.4 | +3.824 | +3.916
ATTACHE | 3871.62 | 19841.6 | 73811.8 | +3.826 | +3.918
ATTACHE | 3870.63 | 19841.6 | 73843.4 | +3.824 | +3.916
ATTACHE | 3809.81 | 21841.8 | 75805.8 | +3.764 | +3.856
ATTACHE | 3808.83 | 21841.8 | 75837.4 | +3.762 | +3.854
ATTACHE | 3809.81 | 19841.6 | 75805.8 | +3.764 | +3.856
ATTACHE | 3808.83 | 19841.6 | 75837.4 | +3.762 | +3.854
ATTACHE | 3744.06 | 23925.1 | 77926.8 | +3.699 | +3.791
ATTACHE | 3743.08 | 23925.1 | 77958.4 | +3.697 | +3.788
ATTACHE | 3744.06 | 21924.9 | 77926.8 | +3.699 | +3.791
ATTACHE | 3743.08 | 21924.9 | 77958.4 | +3.697 | +3.788
ATTACHE | 3772.25 | 23925.1 | 77017.4 | +3.726 | +3.818
ATTACHE | 3773.23 | 23925.1 | 76985.8 | +3.728 | +3.820
ATTACHE | 3772.25 | 21924.9 | 77017.4 | +3.726 | +3.818
ATTACHE | 3773.23 | 21924.9 | 76985.8 | +3.728 | +3.820
ATTACHE | 3870.63 | 26008.4 | 73843.4 | +3.824 | +3.916
ATTACHE | 3871.62 | 26008.4 | 73811.8 | +3.826 | +3.918
ATTACHE | 3870.63 | 24008.3 | 73843.4 | +3.824 | +3.916
ATTACHE | 3871.62 | 24008.3 | 73811.8 | +3.826 | +3.918
ATTACHE | 3809.81 | 24008.3 | 75805.8 | +3.764 | +3.856
ATTACHE | 3808.83 | 24008.3 | 75837.4 | +3.762 | +3.854
ATTACHE | 3809.81 | 26008.4 | 75805.8 | +3.764 | +3.856
ATTACHE | 3808.83 | 26008.4 | 75837.4 | +3.762 | +3.854

# IfcBeam: FPL60*5 (8)
In: Undefined
Description: FPL60*5; Material: STEEL/S235JR
Tekla Common - Part mark: H93; Assembly mark: H93; Phase: 3; Class: 3003; Finish: GRENAILLE-PEINT; Grade: S235JR; Profile: FPL60*5; Name: ATTACHE; sets with these values: 2
Tekla Quantity - Net weight: 0.506325 kg; Gross weight: 0.49455 kg; Weight: 0.506325 kg; Net volume: 0.0000645 m3; Gross volume: 0.0000645 m3; Gross footprint area: 0 m2; Area per tons: 56.3867 m2; Net surface area: 0.02855 m2; Gross area: 0.00105 m2; Height: 5 mm; Width: 60 mm; Length: 210 mm; sets with these values: 2
BaseQuantities - Length: 210 mm; OuterSurfaceArea: 0.02855 m2; NetVolume: 0.0000645 m3; NetWeight: 0.506325 kg
Name | Center of gravity Z (mm) | Center of gravity Y (mm) | Center of gravity X (mm) | Bottom elevation | Top elevation
ATTACHE | 5057.11 | 2710.64 | 78287.4 | +5.025 | +5.088
ATTACHE | 5043.43 | 2710.64 | 78728.5 | +5.013 | +5.076
ATTACHE | 5057.11 | 3277.36 | 78287.4 | +5.025 | +5.088
ATTACHE | 5043.43 | 3277.36 | 78728.5 | +5.013 | +5.076
ATTACHE | 5364.01 | 1822.64 | 68387.4 | +5.332 | +5.395
ATTACHE | 5350.33 | 1822.64 | 68828.5 | +5.319 | +5.383
ATTACHE | 5364.01 | 2389.36 | 68387.4 | +5.332 | +5.395
ATTACHE | 5350.33 | 2389.36 | 68828.5 | +5.319 | +5.383

# IfcBeam: FPL8*140 (2)
In: Undefined
Description: FPL8*140; Material: STEEL/E24-2
Tekla Common - Center of gravity Z: 4995.7 mm; Center of gravity X: 71726.3 mm; Bottom elevation: +4.949; Top elevation: +5.017; Part mark: 1020; Phase: 1; Class: 1007; Finish: GRENAILLE-PEINT; Grade: E24-2; Profile: FPL8*140; Name: ATTACHE; sets with these values: 2
Tekla Quantity - Net weight: 1.25767 kg; Gross weight: 1.19541 kg; Weight: 1.25767 kg; Net volume: 0.000160213 m3; Gross volume: 0.000160213 m3; Gross footprint area: 0 m2; Area per tons: 35.448 m2; Net surface area: 0.0445821 m2; Gross area: 0.00108772 m2; Height: 8 mm; Width: 140 mm; Length: 135.965 mm; sets with these values: 2
BaseQuantities - Length: 135.965 mm; OuterSurfaceArea: 0.0445821 m2; NetVolume: 0.000160213 m3; NetWeight: 1.25767 kg
Name | Center of gravity Y (mm) | Assembly mark
ATTACHE | 26545 | M13
ATTACHE | 26030 | M14

# IfcBeam: FPL8*210 (15)
In: Undefined
Description: FPL8*210; Material: STEEL/S235JR
Tekla Common - Bottom elevation: +3.207; Phase: 2; Finish: GRENAILLE-PEINT; Grade: S235JR; Profile: FPL8*210; Name: GOUSSET; sets with these values: 2
Tekla Quantity - Gross footprint area: 0 m2; Height: 8 mm; Width: 210 mm; sets with these values: 2
Name | Center of gravity Z (mm) | Center of gravity Y (mm) | Center of gravity X (mm) | Top elevation | Part mark = Assembly mark | Class | Net weight (kg) = Weight (kg) = NetWeight (kg) | Gross weight (kg) | Net volume (m3) = NetVolume (m3) | Gross volume (m3) | Area per tons (m2) | Net surface area (m2) = OuterSurfaceArea (m2) | Gross area (m2) | Tekla Quantity, Length (mm) = BaseQuantities, Length (mm)
GOUSSET | 3211.9 | 45644.1 | 9432.91 | +3.218 | G69 | 2005 | 2.3904 | 2.64087 | 0.000304509 | 0.000336624 | 34.4189 | 0.0822747 | 0.00160198 | 200.248
GOUSSET | 3212.05 | 40378 | 9439.3 | +3.218 | G80 | 2005 | 2.13962 | 2.64087 | 0.000272563 | 0.000336624 | 34.8995 | 0.0746716 | 0.00160198 | 200.248
GOUSSET | 3212.05 | 40122 | 9439.3 | +3.218 | G79 | 2005 | 2.13962 | 2.64087 | 0.000272563 | 0.000336624 | 34.8994 | 0.0746716 | 0.00160198 | 200.248
GOUSSET | 3212.02 | 11056.9 | 9438.28 | +3.218 | G82 | 2005 | 2.11135 | 2.64087 | 0.000268962 | 0.000336624 | 34.8737 | 0.0736308 | 0.00160198 | 200.248
GOUSSET | 3211.88 | 15311.5 | 9431.92 | +3.218 | G81 | 2005 | 2.36213 | 2.64087 | 0.000300909 | 0.000336624 | 34.3901 | 0.0812341 | 0.00160198 | 200.248
GOUSSET | 3211.9 | 15067.4 | 9432.91 | +3.218 | G70 | 2005 | 2.39039 | 2.64087 | 0.000304509 | 0.000336624 | 34.4189 | 0.0822747 | 0.00160198 | 200.248
GOUSSET | 3212.05 | 19578 | 9439.3 | +3.218 | G78 | 2006 | 2.13961 | 2.64087 | 0.000272562 | 0.000336624 | 34.8995 | 0.0746713 | 0.00160198 | 200.248
GOUSSET | 3212.05 | 19322 | 9439.3 | +3.218 | G77 | 2006 | 2.13962 | 2.64087 | 0.000272563 | 0.000336624 | 34.8994 | 0.0746715 | 0.00160198 | 200.248
GOUSSET | 3211.9 | 24635.1 | 9432.91 | +3.218 | G71 | 2005 | 2.39039 | 2.64087 | 0.000304509 | 0.000336624 | 34.4189 | 0.0822746 | 0.00160198 | 200.248
GOUSSET | 3211.9 | 34789.9 | 9432.91 | +3.218 | G73 | 2005 | 2.3904 | 2.64087 | 0.000304509 | 0.000336624 | 34.4189 | 0.0822747 | 0.00160198 | 200.248
GOUSSET | 3211.9 | 35035.1 | 9432.91 | +3.218 | G74 | 2005 | 2.39039 | 2.64087 | 0.000304509 | 0.000336624 | 34.4189 | 0.0822747 | 0.00160198 | 200.248
GOUSSET | 3212.05 | 29447 | 9439.3 | +3.218 | G76 | 2005 | 2.13962 | 2.64087 | 0.000272563 | 0.000336624 | 34.8994 | 0.0746715 | 0.00160198 | 200.248
GOUSSET | 3211.9 | 24389.9 | 9432.91 | +3.218 | G72 | 2005 | 2.39039 | 2.64087 | 0.000304509 | 0.000336624 | 34.4189 | 0.0822747 | 0.00160198 | 200.248
GOUSSET | 3212.05 | 29703 | 9439.3 | +3.218 | G75 | 2005 | 2.13962 | 2.64087 | 0.000272562 | 0.000336624 | 34.8995 | 0.0746715 | 0.00160198 | 200.248
GOUSSET | 3213.22 | 48407.3 | 9480.4 | +3.221 | G83 | 2005 | 3.12315 | 3.85047 | 0.000397853 | 0.000490714 | 34.2907 | 0.107095 | 0.00233574 | 291.968

# IfcBeam: FPL8*366, GOUSSET
In: Undefined
Description: FPL8*366; Material: STEEL/E24-2
Tekla Common - Center of gravity Z: 5262.33 mm; Center of gravity Y: 29850 mm; Center of gravity X: 69632.4 mm; Bottom elevation: +5.251; Top elevation: +5.278; Part mark: 1038; Assembly mark: N36; Phase: 1; Class: 1011; Finish: GRENAILLE-PEINT; Grade: E24-2; Profile: FPL8*366; Name: GOUSSET; sets with these values: 2
Tekla Quantity - Net weight: 4.8272 kg; Gross weight: 4.81602 kg; Weight: 4.8272 kg; Net volume: 0.000614931 m3; Gross volume: 0.000614931 m3; Gross footprint area: 0 m2; Area per tons: 33.7564 m2; Net surface area: 0.162949 m2; Gross area: 0.00167624 m2; Height: 8 mm; Width: 366 mm; Length: 209.531 mm; sets with these values: 2
BaseQuantities - Length: 209.531 mm; OuterSurfaceArea: 0.162949 m2; NetVolume: 0.000614931 m3; NetWeight: 4.8272 kg

# IfcBeam: HEA100 (60)
In: Undefined
Description: HEA100; Material: STEEL/E24-2
Tekla Common - Finish: GRENAILLE-PEINT; Grade: E24-2; Profile: HEA100; sets with these values: 2
Tekla Quantity - Area per tons: 33.7099 m2; Width: 100 mm; sets with these values: 2
Name | Center of gravity Z (mm) | Center of gravity Y (mm) | Center of gravity X (mm) | Bottom elevation | Top elevation | Part mark | Assembly mark | Phase | Class | Name | Net weight (kg) = NetWeight (kg) | Gross weight (kg) = Weight (kg) | Net volume (m3) = NetVolume (m3) | Gross volume (m3) | Gross footprint area (m2) | Net surface area (m2) | Gross area (m2) = OuterSurfaceArea (m2) | Height (mm) | Tekla Quantity, Length (mm) = BaseQuantities, Length (mm)
ATTACHE | 3170 | 11008.7 | 8551.01 | +3.020 | +3.320 | H79 | H79 | 2 | 2003 | ATTACHE | 2.68469 | 4.99258 | 0.000341998 | 0.000635997 | 0.00114 | 0.10788 | 0.168299 | 76 | 299.999
ATTACHE | 3170 | 17405.1 | 5467.5 | +3.020 | +3.320 | H79 | H79 | 2 | 2003 | ATTACHE | 2.68469 | 4.99258 | 0.000341998 | 0.000635997 | 0.00114 | 0.10788 | 0.168299 | 76 | 299.999
ATTACHE | 3170 | 32334.8 | 2488.99 | +3.020 | +3.320 | H79 | H79 | 2 | 2003 | ATTACHE | 2.68469 | 4.99258 | 0.000341998 | 0.000635997 | 0.00114 | 0.10788 | 0.168299 | 76 | 299.999
LISSE | 3635 | 10930 | -207 | +2.992 | +4.278 | 1327 | L118 | 2 | 2003 | LISSE | 20.1902 | 21.4016 | 0.002572 | 0.00272632 | 0.002 | 0.752452 | 0.721446 | 96 | 1286
LISSE | 3635 | 13060 | -207 | +2.992 | +4.278 | 1327 | L118 | 2 | 2003 | LISSE | 20.1902 | 21.4016 | 0.002572 | 0.00272632 | 0.002 | 0.752452 | 0.721446 | 96 | 1286
LISSE | 3635 | 15190 | -207 | +2.992 | +4.278 | 1327 | L118 | 2 | 2003 | LISSE | 20.1902 | 21.4016 | 0.002572 | 0.00272632 | 0.002 | 0.752452 | 0.721446 | 96 | 1286
LISSE | 3635 | 19450 | -207 | +2.992 | +4.278 | 1327 | L118 | 2 | 2003 | LISSE | 20.1902 | 21.4016 | 0.002572 | 0.00272632 | 0.002 | 0.752452 | 0.721446 | 96 | 1286
LISSE | 3635 | 21981.2 | -207 | +2.992 | +4.278 | 1327 | L118 | 2 | 2003 | LISSE | 20.1902 | 21.4016 | 0.002572 | 0.00272632 | 0.002 | 0.752452 | 0.721446 | 96 | 1286
ATTACHE | 3170 | 34788.6 | 2496.19 | +3.020 | +3.320 | H80 | H80 | 2 | 2003 | ATTACHE | 4.70998 | 4.99258 | 0.000599997 | 0.000635997 | 0.002 | 0.178599 | 0.168299 | 96 | 299.999
ATTACHE | 3170 | 29451.5 | 2653.98 | +3.020 | +3.320 | H80 | H80 | 2 | 2003 | ATTACHE | 4.70998 | 4.99258 | 0.000599997 | 0.000635997 | 0.002 | 0.178599 | 0.168299 | 96 | 299.999
ATTACHE | 3170 | 29698.5 | 2632.45 | +3.020 | +3.320 | H80 | H80 | 2 | 2003 | ATTACHE | 4.70998 | 4.99258 | 0.000599997 | 0.000635997 | 0.002 | 0.178599 | 0.168299 | 96 | 299.999
ATTACHE | 3170 | 24634 | 3355.21 | +3.020 | +3.320 | H80 | H80 | 2 | 2003 | ATTACHE | 4.70998 | 4.99258 | 0.000599997 | 0.000635997 | 0.002 | 0.178599 | 0.168299 | 96 | 299.999
ATTACHE | 3170 | 27134.1 | 2924.03 | +3.020 | +3.320 | H79 | H79 | 2 | 2003 | ATTACHE | 2.68469 | 4.99258 | 0.000341998 | 0.000635997 | 0.00114 | 0.10788 | 0.168299 | 76 | 299.999
ATTACHE | 3170 | 19593 | 4686.05 | +3.020 | +3.320 | H80 | H80 | 2 | 2003 | ATTACHE | 4.70998 | 4.99258 | 0.000599997 | 0.000635997 | 0.002 | 0.178599 | 0.168299 | 96 | 299.999
ATTACHE | 3170 | 19357.6 | 4763.98 | +3.020 | +3.320 | H80 | H80 | 2 | 2003 | ATTACHE | 4.70998 | 4.99258 | 0.000599997 | 0.000635997 | 0.002 | 0.178599 | 0.168299 | 96 | 299.999
ATTACHE | 3170 | 24391 | 3405.01 | +3.020 | +3.320 | H80 | H80 | 2 | 2003 | ATTACHE | 4.70998 | 4.99258 | 0.000599997 | 0.000635997 | 0.002 | 0.178599 | 0.168299 | 96 | 299.999
ATTACHE | 3170 | 22069.5 | 3953.14 | +3.020 | +3.320 | H79 | H79 | 2 | 2003 | ATTACHE | 2.68469 | 4.99258 | 0.000341998 | 0.000635997 | 0.00114 | 0.10788 | 0.168299 | 76 | 299.999
ATTACHE | 3170 | 15303.1 | 6343.32 | +3.020 | +3.320 | H80 | H80 | 2 | 2003 | ATTACHE | 4.70998 | 4.99258 | 0.000599997 | 0.000635997 | 0.002 | 0.178599 | 0.168299 | 96 | 299.999
ATTACHE | 3170 | 13141.2 | 7380.95 | +3.020 | +3.320 | H79 | H79 | 2 | 2003 | ATTACHE | 2.68469 | 4.99258 | 0.000341998 | 0.000635997 | 0.00114 | 0.10788 | 0.168299 | 76 | 299.999
ATTACHE | 3170 | 15076.9 | 6445.18 | +3.020 | +3.320 | H80 | H80 | 2 | 2003 | ATTACHE | 4.70998 | 4.99258 | 0.000599997 | 0.000635997 | 0.002 | 0.178599 | 0.168299 | 96 | 299.999
TRAVERSE | 5360.81 | 33752.1 | 70895.1 | +5.308 | +5.416 | N55 | N55 | 1 | 1010 | TRAVERSE | 39.2503 | 42.7699 | 0.00500004 | 0.0054484 | 0 | 1.46198 | 1.44177 | 96.0003 | 2570
TRAVERSE | 5463.41 | 31145 | 72657.5 | +5.417 | +5.515 | N54 | N54 | 1 | 1010 | TRAVERSE | 17.3386 | 19.4711 | 0.00220874 | 0.0024804 | 0 | 0.64954 | 0.65637 | 96.0004 | 1170
TRAVERSE | 5296.18 | 18182.2 | 70598.5 | +5.248 | +5.347 | N51 | N51 | 1 | 1010 | TRAVERSE | 32.7984 | 35.8144 | 0.00417814 | 0.00456235 | 0 | 1.22239 | 1.2073 | 96.0057 | 2152.05
TRAVERSE | 5372.9 | 18182.2 | 68123.5 | +5.325 | +5.424 | N51 | N51 | 1 | 1010 | TRAVERSE | 32.7945 | 35.8144 | 0.00417764 | 0.00456235 | 0 | 1.22238 | 1.2073 | 96.0008 | 2152.05
TRAVERSE | 5066.15 | 1275 | 78023.5 | +5.018 | +5.117 | N50 | N50 | 1 | 1010 | TRAVERSE | 38.5343 | 41.9378 | 0.00490882 | 0.0053424 | 0 | 1.43524 | 1.41372 | 96.0006 | 2520
TRAVERSE | 5142.88 | 1275 | 75548.5 | +5.094 | +5.194 | N50 | N50 | 1 | 1010 | TRAVERSE | 38.539 | 41.9378 | 0.00490942 | 0.0053424 | 0 | 1.43526 | 1.41372 | 96.0057 | 2520
TRAVERSE | 5219.6 | 1275 | 73073.5 | +5.171 | +5.270 | N50 | N50 | 1 | 1010 | TRAVERSE | 38.5343 | 41.9378 | 0.00490883 | 0.0053424 | 0 | 1.43524 | 1.41372 | 96.0007 | 2520
TRAVERSE | 5373.05 | 1275 | 68123.5 | +5.325 | +5.424 | N50 | N50 | 1 | 1010 | TRAVERSE | 38.5344 | 41.9378 | 0.00490884 | 0.0053424 | 0 | 1.43524 | 1.41372 | 96.0008 | 2520
TRAVERSE | 5296.33 | 1275 | 70598.5 | +5.248 | +5.347 | N50 | N50 | 1 | 1010 | TRAVERSE | 38.539 | 41.9378 | 0.00490943 | 0.0053424 | 0 | 1.43526 | 1.41372 | 96.0057 | 2520
TRAVERSE | 5360.89 | 20750 | 70895.1 | +5.308 | +5.416 | N52 | N52 | 1 | 1010 | TRAVERSE | 39.3191 | 42.7699 | 0.0050088 | 0.0054484 | 0 | 1.46434 | 1.44177 | 96.0004 | 2570
TRAVERSE | 5360.89 | 25950 | 70895.1 | +5.308 | +5.416 | N53 | N53 | 1 | 1010 | TRAVERSE | 39.3191 | 42.7699 | 0.0050088 | 0.0054484 | 0 | 1.46434 | 1.44177 | 96.0004 | 2570
TRAVERSE | 5463.41 | 27145 | 72657.5 | +5.417 | +5.515 | N54 | N54 | 1 | 1010 | TRAVERSE | 17.3386 | 19.4711 | 0.00220874 | 0.0024804 | 0 | 0.64954 | 0.65637 | 96.0004 | 1170
TRAVERSE | 5409.42 | 31145 | 75357.5 | +5.363 | +5.461 | N54 | N54 | 1 | 1010 | TRAVERSE | 17.3386 | 19.4711 | 0.00220874 | 0.0024804 | 0 | 0.64954 | 0.65637 | 96.0004 | 1170
TRAVERSE | 5409.42 | 27145 | 75357.5 | +5.363 | +5.461 | N54 | N54 | 1 | 1010 | TRAVERSE | 17.3386 | 19.4711 | 0.00220874 | 0.0024804 | 0 | 0.64954 | 0.65637 | 96.0004 | 1170
TRAVERSE | 5355.69 | 31145 | 78043.8 | +5.309 | +5.407 | N54 | N54 | 1 | 1010 | TRAVERSE | 17.3386 | 19.4711 | 0.00220874 | 0.0024804 | 0 | 0.64954 | 0.65637 | 96.0004 | 1170
TRAVERSE | 5355.69 | 27145 | 78043.8 | +5.309 | +5.407 | N54 | N54 | 1 | 1010 | TRAVERSE | 17.3386 | 19.4711 | 0.00220874 | 0.0024804 | 0 | 0.64954 | 0.65637 | 96.0004 | 1170
LISSE | 3635 | 24512.5 | -207 | +2.992 | +4.278 | 1327 | L118 | 2 | 2003 | LISSE | 20.1902 | 21.4016 | 0.002572 | 0.00272632 | 0.002 | 0.752452 | 0.721446 | 96 | 1286
LISSE | 3635 | 17320 | -207 | +2.992 | +4.278 | 1327 | L118 | 2 | 2003 | LISSE | 20.1902 | 21.4016 | 0.002572 | 0.00272632 | 0.002 | 0.752452 | 0.721446 | 96 | 1286
LISSE | 3635 | 27043.8 | -207 | +2.992 | +4.278 | 1327 | L118 | 2 | 2003 | LISSE | 20.1902 | 21.4016 | 0.002572 | 0.00272632 | 0.002 | 0.752452 | 0.721446 | 96 | 1286
LISSE | 3635 | 29375 | -207 | +2.992 | +4.278 | 1327 | L118 | 2 | 2003 | LISSE | 20.1902 | 21.4016 | 0.002572 | 0.00272632 | 0.002 | 0.752452 | 0.721446 | 96 | 1286
LISSE | 3635 | 9978 | -3.42778e-16 | +2.980 | +4.290 | 1342 | L52 | 2 | 2003 | LISSE | 20.567 | 21.801 | 0.00262 | 0.0027772 | 0.002 | 0.76642 | 0.73491 | 96 | 1310
LISSE | 3635 | 9978 | 2310 | +2.980 | +4.290 | 1326 | L52 | 2 | 2003 | LISSE | 20.567 | 21.801 | 0.00262 | 0.0027772 | 0.002 | 0.76642 | 0.73491 | 96 | 1310
LISSE | 3635 | 9978 | 4620 | +2.980 | +4.290 | 1326 | L52 | 2 | 2003 | LISSE | 20.567 | 21.801 | 0.00262 | 0.0027772 | 0.002 | 0.76642 | 0.73491 | 96 | 1310
LISSE | 3635 | 9978 | 10320 | +2.980 | +4.290 | 1326 | L52 | 2 | 2003 | LISSE | 20.567 | 21.801 | 0.00262 | 0.0027772 | 0.002 | 0.76642 | 0.73491 | 96 | 1310
LISSE | 3635 | 9978 | 6930 | +2.980 | +4.290 | 1326 | L52 | 2 | 2003 | LISSE | 20.567 | 21.801 | 0.00262 | 0.0027772 | 0.002 | 0.76642 | 0.73491 | 96 | 1310
LISSE | 3635 | 9978 | 9234.6 | +2.980 | +4.290 | 1343 | L52 | 2 | 2003 | LISSE | 20.567 | 21.801 | 0.00262 | 0.0027772 | 0.002 | 0.76642 | 0.73491 | 96 | 1310
TRAVERSE | 10520.2 | 65094.4 | 20358.3 | +10.470 | +10.570 | N56 | N56 | 2 | 2005 | TRAVERSE | 40.686 | 44.4225 | 0.00518293 | 0.00565892 | 0 | 1.51569 | 1.49748 | 96.006 | 2669.3
TRAVERSE | 10432.4 | 65094.4 | 23189.3 | +10.383 | +10.482 | N58 | N58 | 2 | 2005 | TRAVERSE | 40.686 | 44.4225 | 0.00518293 | 0.00565891 | 0 | 1.51569 | 1.49748 | 96.006 | 2669.3
TRAVERSE | 10344.8 | 51345.6 | 26017.3 | +10.295 | +10.394 | N60 | N60 | 2 | 2005 | TRAVERSE | 40.687 | 44.4225 | 0.00518306 | 0.00565892 | 0 | 1.51569 | 1.49748 | 96.0045 | 2669.3
TRAVERSE | 10432.4 | 51370.6 | 23189.3 | +10.383 | +10.482 | N59 | N59 | 2 | 2005 | TRAVERSE | 39.902 | 43.5904 | 0.00508305 | 0.00555292 | 0 | 1.48659 | 1.46943 | 96.0045 | 2619.3
TRAVERSE | 10344.8 | 65094.4 | 26017.3 | +10.295 | +10.394 | N56 | N56 | 2 | 2005 | TRAVERSE | 40.686 | 44.4225 | 0.00518293 | 0.00565891 | 0 | 1.51569 | 1.49748 | 96.006 | 2669.3
TRAVERSE | 10257.1 | 65094.4 | 28845.3 | +10.207 | +10.306 | N56 | N56 | 2 | 2005 | TRAVERSE | 40.686 | 44.4225 | 0.00518293 | 0.00565891 | 0 | 1.51569 | 1.49748 | 96.006 | 2669.3
TRAVERSE | 10169.4 | 51345.6 | 31673.3 | +10.120 | +10.219 | N60 | N60 | 2 | 2005 | TRAVERSE | 40.687 | 44.4225 | 0.00518306 | 0.00565892 | 0 | 1.51569 | 1.49748 | 96.0045 | 2669.3
TRAVERSE | 10169.4 | 65094.4 | 31673.3 | +10.120 | +10.219 | N56 | N56 | 2 | 2005 | TRAVERSE | 40.686 | 44.4225 | 0.00518293 | 0.00565891 | 0 | 1.51569 | 1.49748 | 96.006 | 2669.3
TRAVERSE | 10520.2 | 51370.6 | 20358.3 | +10.470 | +10.570 | N57 | N57 | 2 | 2005 | TRAVERSE | 39.902 | 43.5904 | 0.00508306 | 0.00555292 | 0 | 1.48659 | 1.46943 | 96.0045 | 2619.3
TRAVERSE | 10257.1 | 51345.6 | 28845.3 | +10.207 | +10.306 | N60 | N60 | 2 | 2005 | TRAVERSE | 40.687 | 44.4225 | 0.00518306 | 0.00565892 | 0 | 1.51569 | 1.49748 | 96.0045 | 2669.3
TRAVERSE | 3338.08 | 47140.2 | 10406.8 | +3.290 | +3.389 | N61 | N61 | 2 | 2005 | TRAVERSE | 41.6352 | 45.3217 | 0.00530385 | 0.00577346 | 0 | 1.55007 | 1.52779 | 96.0152 | 2723.33
TRAVERSE | 3337.72 | 11989.4 | 10406.8 | +3.290 | +3.389 | N62 | N62 | 2 | 2005 | TRAVERSE | 31.7674 | 34.865 | 0.0040468 | 0.0044414 | 0 | 1.18437 | 1.17529 | 96.0151 | 2095
LISSE | 3635 | 33300 | -207 | +2.992 | +4.278 | 1322 | L117 | 5 | 5001 | LISSE | 20.1902 | 21.4016 | 0.002572 | 0.00272632 | 0.002 | 0.752452 | 0.721446 | 96 | 1286
LISSE | 3635 | 32243.8 | -207 | +2.992 | +4.278 | 1322 | L32 | 5 | 5001 | LISSE | 20.1902 | 21.4016 | 0.002572 | 0.00272632 | 0.002 | 0.752452 | 0.721446 | 96 | 1286

# IfcBeam: HEA120 (23)
In: Undefined
Description: HEA120; Material: STEEL/E24-2
Tekla Common - Finish: GRENAILLE-PEINT; Grade: E24-2; Profile: HEA120; sets with these values: 2
Tekla Quantity - Gross footprint area: 0.00241 m2; Area per tons: 33.5975 m2; Height: 114 mm; Width: 120 mm; sets with these values: 2
Name | Center of gravity Z (mm) | Center of gravity Y (mm) | Center of gravity X (mm) | Bottom elevation | Top elevation | Part mark | Assembly mark | Phase | Class | Name | Net weight (kg) = NetWeight (kg) | Gross weight (kg) = Weight (kg) | Net volume (m3) = NetVolume (m3) | Gross volume (m3) | Net surface area (m2) | Gross area (m2) = OuterSurfaceArea (m2) | Tekla Quantity, Length (mm) = BaseQuantities, Length (mm)
LISSE | 5237.9 | 49857 | 30085 | +4.526 | +5.950 | 590 | L1 | 3 | 3003 | LISSE | 26.9439 | 28.2743 | 0.00343234 | 0.00360183 | 0.998918 | 0.949948 | 1424.21
LISSE | 5113.31 | 49857 | 32125 | +4.277 | +5.950 | 592 | L3 | 3 | 3003 | LISSE | 31.6578 | 33.221 | 0.00403284 | 0.00423198 | 1.17284 | 1.11614 | 1673.38
LISSE | 5362.48 | 49857 | 28045 | +4.775 | +5.950 | 591 | L2 | 3 | 3003 | LISSE | 22.2302 | 23.3278 | 0.00283187 | 0.0029717 | 0.825004 | 0.783758 | 1175.05
LISSE | 3300 | -587.368 | 20627.9 | +3.055 | +3.545 | 589 | L116 | 3 | 3003 | LISSE | 9.27007 | 9.7278 | 0.0011809 | 0.00123921 | 0.34684 | 0.32683 | 490
MONTANT | 4949 | 26050 | 71815 | +4.010 | +5.888 | 580 | M14 | 1 | 1007 | MONTANT | 35.5289 | 37.2833 | 0.00452598 | 0.00474946 | 1.31566 | 1.25263 | 1878
MONTANT | 4949 | 19450 | 71815 | +4.010 | +5.888 | 581 | M1 | 1 | 1007 | MONTANT | 35.5289 | 37.2833 | 0.00452598 | 0.00474946 | 1.31566 | 1.25263 | 1878
MONTANT | 4949 | 17090 | 71815 | +4.010 | +5.888 | 582 | M4 | 1 | 1007 | MONTANT | 35.5289 | 37.2833 | 0.00452598 | 0.00474946 | 1.31566 | 1.25263 | 1878
MONTANT | 4949 | 14730 | 71815 | +4.010 | +5.888 | 582 | M4 | 1 | 1007 | MONTANT | 35.5289 | 37.2833 | 0.00452598 | 0.00474946 | 1.31566 | 1.25263 | 1878
MONTANT | 4949 | 22050 | 71815 | +4.010 | +5.888 | 581 | M2 | 1 | 1007 | MONTANT | 35.5289 | 37.2833 | 0.00452598 | 0.00474946 | 1.31566 | 1.25263 | 1878
MONTANT | 4949 | 24650 | 71815 | +4.010 | +5.888 | 581 | M3 | 1 | 1007 | MONTANT | 35.5289 | 37.2833 | 0.00452598 | 0.00474946 | 1.31566 | 1.25263 | 1878
MONTANT | 4764.75 | 26545 | 71815 | +4.010 | +5.519 | 583 | M13 | 1 | 1007 | MONTANT | 28.5573 | 29.9674 | 0.00363787 | 0.0038175 | 1.05844 | 1.00683 | 1509.49
LISSE | 3300 | -2297.56 | 22797.3 | +3.055 | +3.545 | 584 | L115 | 3 | 3003 | LISSE | 9.27007 | 9.7278 | 0.0011809 | 0.00123921 | 0.34684 | 0.32683 | 490
LISSE | 3300 | -2262.05 | 24743.6 | +3.055 | +3.545 | 585 | L115 | 3 | 3003 | LISSE | 9.27006 | 9.7278 | 0.0011809 | 0.00123921 | 0.34684 | 0.32683 | 490
LISSE | 3300 | -2311.67 | 20850.1 | +3.055 | +3.545 | 585 | L115 | 3 | 3003 | LISSE | 9.27007 | 9.7278 | 0.0011809 | 0.00123921 | 0.34684 | 0.32683 | 490
LISSE | 3300 | -2126.77 | 28636.1 | +3.055 | +3.545 | 586 | L115 | 3 | 3003 | LISSE | 9.27007 | 9.7278 | 0.0011809 | 0.00123921 | 0.34684 | 0.32683 | 490
LISSE | 3300 | -1412.14 | 38369.2 | +3.055 | +3.545 | 587 | L80 | 3 | 3003 | LISSE | 9.27006 | 9.7278 | 0.0011809 | 0.00123921 | 0.34684 | 0.32683 | 490
LISSE | 3300 | -723.072 | 44209 | +3.055 | +3.545 | 588 | L80 | 3 | 3003 | LISSE | 9.27007 | 9.7278 | 0.0011809 | 0.00123921 | 0.34684 | 0.32683 | 490
LISSE | 3300 | -2205.13 | 26690 | +3.055 | +3.545 | 584 | L115 | 3 | 3003 | LISSE | 9.27007 | 9.7278 | 0.0011809 | 0.00123921 | 0.34684 | 0.32683 | 490
LISSE | 3300 | -2027.05 | 30580.7 | +3.055 | +3.545 | 584 | L115 | 3 | 3003 | LISSE | 9.27007 | 9.7278 | 0.0011809 | 0.00123921 | 0.34684 | 0.32683 | 490
LISSE | 3300 | -1597.53 | 36430.9 | +3.055 | +3.545 | 584 | L80 | 3 | 3003 | LISSE | 9.27007 | 9.7278 | 0.0011809 | 0.00123921 | 0.34684 | 0.32683 | 490
LISSE | 3300 | -1761.59 | 34490.6 | +3.055 | +3.545 | 584 | L80 | 3 | 3003 | LISSE | 9.27007 | 9.7278 | 0.0011809 | 0.00123921 | 0.34684 | 0.32683 | 490
LISSE | 3300 | -1205.44 | 40305.4 | +3.055 | +3.545 | 584 | L80 | 3 | 3003 | LISSE | 9.27006 | 9.7278 | 0.0011809 | 0.00123921 | 0.34684 | 0.32683 | 490
LISSE | 3300 | -977.476 | 42239.3 | +3.055 | +3.545 | 584 | L80 | 3 | 3003 | LISSE | 9.27006 | 9.7278 | 0.0011809 | 0.00123921 | 0.34684 | 0.32683 | 490

# IfcBeam: HEA140 (12)
In: Undefined
Description: HEA140; Material: STEEL/E24-2
Tekla Common - Finish: GRENAILLE-PEINT; Grade: E24-2; Profile: HEA140; sets with these values: 2
Tekla Quantity - Area per tons: 32.2123 m2; Height: 133 mm; Width: 140 mm; sets with these values: 2
Name | Center of gravity Z (mm) | Center of gravity Y (mm) | Center of gravity X (mm) | Bottom elevation | Top elevation | Part mark | Assembly mark | Phase | Class | Name | Net weight (kg) = NetWeight (kg) | Gross weight (kg) = Weight (kg) | Net volume (m3) = NetVolume (m3) | Gross volume (m3) | Gross footprint area (m2) | Net surface area (m2) | Gross area (m2) = OuterSurfaceArea (m2) | Tekla Quantity, Length (mm) = BaseQuantities, Length (mm)
TRAVERSE | 3807.32 | 25008.3 | 75821.5 | +3.741 | +3.878 | N34 | N34 | 1 | 1010 | TRAVERSE | 47.1489 | 50.6125 | 0.00600624 | 0.00644746 | 0 | 1.63224 | 1.63034 | 2053.33
TRAVERSE | 3869.12 | 25008.3 | 73827.5 | +3.802 | +3.940 | N34 | N34 | 1 | 1010 | TRAVERSE | 47.1463 | 50.6125 | 0.0060059 | 0.00644746 | 0 | 1.63224 | 1.63034 | 2053.33
TRAVERSE | 3770.74 | 18758.3 | 77001.5 | +3.704 | +3.841 | N32 | N32 | 1 | 1010 | TRAVERSE | 47.145 | 50.6125 | 0.00600573 | 0.00644746 | 0 | 1.63223 | 1.63034 | 2053.33
TRAVERSE | 3741.57 | 22925 | 77942.5 | +3.675 | +3.812 | N33 | N33 | 1 | 1010 | TRAVERSE | 47.1488 | 50.6128 | 0.00600621 | 0.00644749 | 0 | 1.63225 | 1.63035 | 2053.34
TRAVERSE | 3869.12 | 20841.7 | 73827.5 | +3.802 | +3.940 | N35 | N35 | 1 | 1010 | TRAVERSE | 47.1463 | 50.6125 | 0.0060059 | 0.00644746 | 0 | 1.63224 | 1.63034 | 2053.33
TRAVERSE | 3807.32 | 20841.7 | 75821.5 | +3.741 | +3.878 | N35 | N35 | 1 | 1010 | TRAVERSE | 47.1489 | 50.6125 | 0.00600624 | 0.00644746 | 0 | 1.63224 | 1.63034 | 2053.33
TRAVERSE | 3741.57 | 18758.3 | 77942.5 | +3.675 | +3.812 | N32 | N32 | 1 | 1010 | TRAVERSE | 47.1486 | 50.6125 | 0.0060062 | 0.00644746 | 0 | 1.63224 | 1.63034 | 2053.33
TRAVERSE | 3770.74 | 22925 | 77001.5 | +3.704 | +3.841 | N33 | N33 | 1 | 1010 | TRAVERSE | 47.1451 | 50.6128 | 0.00600574 | 0.00644749 | 0 | 1.63224 | 1.63035 | 2053.34
ATTACHE | 5357.28 | 69308.5 | 50037.5 | +4.750 | +5.965 | 873 | P20 | 1 | 1001 | ATTACHE | 28.7951 | 29.9591 | 0.00366817 | 0.00381645 | 0.003018 | 0.996611 | 0.965051 | 1215.43
ATTACHE | 5357.28 | 69308.5 | 61712.5 | +4.750 | +5.965 | 873 | P19 | 1 | 1001 | ATTACHE | 28.7951 | 29.9591 | 0.00366817 | 0.00381645 | 0.003018 | 0.996611 | 0.965051 | 1215.43
ATTACHE | 5357.28 | 69308.5 | 73387.5 | +4.750 | +5.965 | 873 | P18 | 1 | 1001 | ATTACHE | 28.7951 | 29.9591 | 0.00366817 | 0.00381645 | 0.003018 | 0.996611 | 0.965051 | 1215.43
ATTACHE | 5357.28 | 69308.5 | 38362.5 | +4.750 | +5.965 | 873 | P21 | 3 | 3001 | ATTACHE | 28.7951 | 29.9591 | 0.00366817 | 0.00381645 | 0.003018 | 0.996611 | 0.965051 | 1215.43

# IfcBeam: HEA160 (26)
In: Undefined
Description: HEA160
Tekla Common - Profile: HEA160; sets with these values: 2
Tekla Quantity - Area per tons: 29.7535 m2; Height: 152 mm; Width: 160 mm; sets with these values: 2
Name | Material | Center of gravity Z (mm) | Center of gravity Y (mm) | Center of gravity X (mm) | Bottom elevation | Top elevation | Part mark | Assembly mark | Phase | Class | Finish | Grade | Name | Net weight (kg) = NetWeight (kg) | Gross weight (kg) = Weight (kg) | Net volume (m3) = NetVolume (m3) | Gross volume (m3) | Gross footprint area (m2) | Net surface area (m2) | Gross area (m2) = OuterSurfaceArea (m2) | Tekla Quantity, Length (mm) = BaseQuantities, Length (mm)
SUPPORT | STEEL/S235JR | 4130 | 40250 | -581 | +3.310 | +4.950 | 1361 | E3 | 4 | 4000 | GALVANISE | S235JR | SUPPORT | 47.4278 | 49.9382 | 0.00604176 | 0.00636156 | 0.003684 | 1.53585 | 1.48584 | 1640
SUPPORT | STEEL/S235JR | 4130 | 48525 | -581 | +3.310 | +4.950 | 1361 | E3 | 4 | 4000 | GALVANISE | S235JR | SUPPORT | 47.4278 | 49.9382 | 0.00604176 | 0.00636156 | 0.003684 | 1.53585 | 1.48584 | 1640
ATTACHE | STEEL/E24-2 | 3332.65 | 34912.5 | 2500.24 | +3.020 | +3.648 | 1350 | H81 | 2 | 2003 | GRENAILLE-PEINT | E24-2 | ATTACHE | 18.0832 | 19.1283 | 0.0023036 | 0.00243673 | 0 | 0.590148 | 0.569136 | 628.185
ATTACHE | STEEL/E24-2 | 3329.49 | 32243.5 | 2491.59 | +3.020 | +3.645 | 1351 | H82 | 2 | 2003 | GRENAILLE-PEINT | E24-2 | ATTACHE | 17.9 | 19.0371 | 0.00228025 | 0.0024251 | 0 | 0.584207 | 0.56642 | 625.188
ATTACHE | STEEL/E24-2 | 3330.15 | 29575 | 2643.12 | +3.020 | +3.643 | 1359 | H90 | 2 | 2003 | GRENAILLE-PEINT | E24-2 | ATTACHE | 17.9386 | 18.9801 | 0.00228517 | 0.00241785 | 0 | 0.585487 | 0.564725 | 623.317
ATTACHE | STEEL/E24-2 | 3325.01 | 27043.8 | 2937.06 | +3.020 | +3.633 | 1358 | H89 | 2 | 2003 | GRENAILLE-PEINT | E24-2 | ATTACHE | 17.6411 | 18.6709 | 0.00224727 | 0.00237845 | 0 | 0.575898 | 0.555524 | 613.162
ATTACHE | STEEL/E24-2 | 3293.72 | 19475.4 | 4724.89 | +3.020 | +3.571 | 1360 | H91 | 2 | 2003 | GRENAILLE-PEINT | E24-2 | ATTACHE | 15.8314 | 16.7758 | 0.00201674 | 0.00213704 | 0 | 0.517576 | 0.499138 | 550.925
ATTACHE | STEEL/E24-2 | 3306.81 | 21981.3 | 3976.57 | +3.020 | +3.597 | 1356 | H87 | 2 | 2003 | GRENAILLE-PEINT | E24-2 | ATTACHE | 16.5888 | 17.5702 | 0.00211323 | 0.00223824 | 0 | 0.541987 | 0.522775 | 577.015
ATTACHE | STEEL/E24-2 | 3317.26 | 24512.5 | 3380.01 | +3.020 | +3.618 | 1357 | H88 | 2 | 2003 | GRENAILLE-PEINT | E24-2 | ATTACHE | 17.1927 | 18.2025 | 0.00219015 | 0.00231879 | 0 | 0.561448 | 0.54159 | 597.781
ATTACHE | STEEL/E24-2 | 3280.15 | 17320.1 | 5500.5 | +3.020 | +3.544 | 1355 | H86 | 2 | 2003 | GRENAILLE-PEINT | E24-2 | ATTACHE | 15.0463 | 15.9515 | 0.00191672 | 0.00203204 | 0 | 0.492274 | 0.474615 | 523.858
ATTACHE | STEEL/E24-2 | 3264.51 | 15190.1 | 6394.1 | +3.020 | +3.513 | 1354 | H85 | 2 | 2003 | GRENAILLE-PEINT | E24-2 | ATTACHE | 14.1417 | 15.0013 | 0.0018015 | 0.00191099 | 0 | 0.463123 | 0.446342 | 492.651
ATTACHE | STEEL/E24-2 | 3246.51 | 13060.1 | 7422.67 | +3.020 | +3.477 | 1353 | H84 | 2 | 2003 | GRENAILLE-PEINT | E24-2 | ATTACHE | 13.1006 | 13.9069 | 0.00166887 | 0.00177159 | 0 | 0.42957 | 0.413781 | 456.712
ATTACHE | STEEL/E24-2 | 3225.95 | 10930.1 | 8597.09 | +3.020 | +3.436 | 1352 | H83 | 2 | 2003 | GRENAILLE-PEINT | E24-2 | ATTACHE | 11.9118 | 12.6569 | 0.00151743 | 0.00161234 | 0 | 0.391258 | 0.376587 | 415.659
EMPANNON | STEEL/E24-2 | 3716.92 | 45766.7 | 20850 | +3.494 | +3.940 | 1349 | N46 | 2 | 2006 | GRENAILLE-PEINT | E24-2 | EMPANNON | 12.9029 | 13.5859 | 0.00164369 | 0.00173069 | 0.003684 | 0.423197 | 0.404229 | 446.169
EMPANNON | STEEL/E24-2 | 3716.92 | 43008.3 | 20850 | +3.494 | +3.940 | 1349 | N46 | 2 | 2006 | GRENAILLE-PEINT | E24-2 | EMPANNON | 12.9029 | 13.5859 | 0.00164369 | 0.00173069 | 0.003684 | 0.423197 | 0.404229 | 446.169
EMPANNON | STEEL/E24-2 | 3716.92 | 10930 | 20850 | +3.494 | +3.940 | 1349 | N49 | 2 | 2006 | GRENAILLE-PEINT | E24-2 | EMPANNON | 12.9029 | 13.5859 | 0.00164369 | 0.00173069 | 0.003684 | 0.423197 | 0.404229 | 446.169
EMPANNON | STEEL/E24-2 | 3716.92 | 13060 | 20850 | +3.494 | +3.940 | 1349 | N49 | 2 | 2006 | GRENAILLE-PEINT | E24-2 | EMPANNON | 12.9029 | 13.5859 | 0.00164369 | 0.00173069 | 0.003684 | 0.423197 | 0.404229 | 446.169
EMPANNON | STEEL/E24-2 | 3716.92 | 15190 | 20850 | +3.494 | +3.940 | 1349 | N49 | 2 | 2006 | GRENAILLE-PEINT | E24-2 | EMPANNON | 12.9029 | 13.5859 | 0.00164369 | 0.00173069 | 0.003684 | 0.423197 | 0.404229 | 446.169
EMPANNON | STEEL/E24-2 | 3716.92 | 17320 | 20850 | +3.494 | +3.940 | 1349 | N49 | 2 | 2006 | GRENAILLE-PEINT | E24-2 | EMPANNON | 12.9029 | 13.5859 | 0.00164369 | 0.00173069 | 0.003684 | 0.423197 | 0.404229 | 446.169
EMPANNON | STEEL/E24-2 | 3716.92 | 21981.2 | 20850 | +3.494 | +3.940 | 1349 | N45 | 2 | 2006 | GRENAILLE-PEINT | E24-2 | EMPANNON | 12.9029 | 13.5859 | 0.00164369 | 0.00173069 | 0.003684 | 0.423197 | 0.404229 | 446.169
EMPANNON | STEEL/E24-2 | 3716.92 | 37581.2 | 20850 | +3.494 | +3.940 | 1349 | N44 | 2 | 2006 | GRENAILLE-PEINT | E24-2 | EMPANNON | 12.9029 | 13.5859 | 0.00164369 | 0.00173069 | 0.003684 | 0.423197 | 0.404229 | 446.169
EMPANNON | STEEL/E24-2 | 3714.17 | 34912.5 | 20850 | +3.488 | +3.940 | 1348 | N44 | 2 | 2006 | GRENAILLE-PEINT | E24-2 | EMPANNON | 13.062 | 13.7534 | 0.00166395 | 0.00175202 | 0.003684 | 0.428323 | 0.409212 | 451.669
EMPANNON | STEEL/E24-2 | 3716.92 | 27043.8 | 20850 | +3.494 | +3.940 | 1349 | N45 | 2 | 2006 | GRENAILLE-PEINT | E24-2 | EMPANNON | 12.9029 | 13.5859 | 0.00164369 | 0.00173069 | 0.003684 | 0.423197 | 0.404229 | 446.169
EMPANNON | STEEL/E24-2 | 3716.92 | 32243.8 | 20850 | +3.494 | +3.940 | 1349 | N44 | 2 | 2006 | GRENAILLE-PEINT | E24-2 | EMPANNON | 12.9029 | 13.5859 | 0.00164369 | 0.00173069 | 0.003684 | 0.423197 | 0.404229 | 446.169
EMPANNON | STEEL/E24-2 | 3714.17 | 29575 | 20850 | +3.488 | +3.940 | 1348 | N44 | 2 | 2006 | GRENAILLE-PEINT | E24-2 | EMPANNON | 13.062 | 13.7534 | 0.00166395 | 0.00175202 | 0.003684 | 0.428323 | 0.409212 | 451.669
EMPANNON | STEEL/E24-2 | 3716.92 | 24512.5 | 20850 | +3.494 | +3.940 | 1349 | N45 | 2 | 2006 | GRENAILLE-PEINT | E24-2 | EMPANNON | 12.9029 | 13.5859 | 0.00164369 | 0.00173069 | 0.003684 | 0.423197 | 0.404229 | 446.169

# IfcBeam: HEA180 (2)
In: Undefined
Description: HEA180; Material: STEEL/E24-2
Tekla Common - Center of gravity Y: 19363 mm; Part mark: H10; Assembly mark: H10; Phase: 1; Class: 1010; Finish: GRENAILLE-PEINT; Grade: E24-2; Profile: HEA180; Name: ATTACHE; sets with these values: 2
Tekla Quantity - Net weight: 4.76087 kg; Gross weight: 4.97847 kg; Weight: 4.97847 kg; Net volume: 0.00060648 m3; Gross volume: 0.0006342 m3; Gross footprint area: 0.004332 m2; Area per tons: 28.6835 m2; Net surface area: 0.155664 m2; Gross area: 0.1428 m2; Height: 171 mm; Width: 180 mm; Length: 140 mm; sets with these values: 2
BaseQuantities - Length: 140 mm; OuterSurfaceArea: 0.1428 m2; NetVolume: 0.00060648 m3; NetWeight: 4.76087 kg
Name | Center of gravity Z (mm) | Center of gravity X (mm) | Bottom elevation | Top elevation
ATTACHE | 5214.16 | 71608 | +5.144 | +5.284
ATTACHE | 5332.98 | 67775 | +5.263 | +5.403

# IfcBeam: IPE120 (5)
In: Undefined
Description: IPE120; Material: STEEL/E24-2
Tekla Common - Bottom elevation: +3.206; Top elevation: +3.327; Phase: 3; Class: 3003; Finish: GRENAILLE-PEINT; Grade: E24-2; Profile: IPE120; Name: PANNE; sets with these values: 2
Tekla Quantity - Gross footprint area: 0 m2; Area per tons: 45.8406 m2; Height: 120 mm; Width: 64 mm; sets with these values: 2
Name | Center of gravity Z (mm) | Center of gravity Y (mm) | Center of gravity X (mm) | Part mark = Assembly mark | Net weight (kg) = NetWeight (kg) | Gross weight (kg) = Weight (kg) | Net volume (m3) = NetVolume (m3) | Gross volume (m3) | Net surface area (m2) | Gross area (m2) = OuterSurfaceArea (m2) | Tekla Quantity, Length (mm) = BaseQuantities, Length (mm)
PANNE | 3266.08 | -586.178 | 41281.3 | K106 | 57.807 | 60.2178 | 0.00736395 | 0.00767106 | 2.8101 | 2.76042 | 5811.41
PANNE | 3266.08 | -586.178 | 35443.8 | K106 | 57.807 | 60.2178 | 0.00736395 | 0.00767106 | 2.8101 | 2.76042 | 5811.41
PANNE | 3265.82 | -586.183 | 30579 | K107 | 38.2745 | 40.0586 | 0.00487574 | 0.005103 | 1.86225 | 1.83631 | 3865.91
PANNE | 3265.82 | -586.183 | 26687.5 | K107 | 38.2645 | 40.0482 | 0.00487446 | 0.00510168 | 1.86176 | 1.83583 | 3864.91
PANNE | 3265.82 | -586.183 | 22796 | K107 | 38.2745 | 40.0586 | 0.00487574 | 0.005103 | 1.86225 | 1.83631 | 3865.91

# IfcBeam: IPE220 (6)
In: Undefined
Description: IPE220; Material: STEEL/S235JR
Tekla Common - Center of gravity Y: 68037.5 mm; Phase: 2; Class: 2007; Finish: GALVANISE; Grade: S235JR; Profile: IPE220; Name: SOLIVE; sets with these values: 2
Tekla Quantity - Area per tons: 32.343 m2; Height: 220 mm; Width: 110 mm; sets with these values: 2
Name | Center of gravity Z (mm) | Center of gravity X (mm) | Bottom elevation | Top elevation | Part mark = Assembly mark | Net weight (kg) = NetWeight (kg) | Gross weight (kg) = Weight (kg) | Net volume (m3) = NetVolume (m3) | Gross volume (m3) | Gross footprint area (m2) | Net surface area (m2) | Gross area (m2) = OuterSurfaceArea (m2) | Tekla Quantity, Length (mm) = BaseQuantities, Length (mm)
SOLIVE | 7615 | 27680 | +7.505 | +7.725 | S95 | 62.1809 | 64.6299 | 0.00792113 | 0.0082331 | 0.27115 | 2.14654 | 2.09032 | 2465
SOLIVE | 7255 | 27570 | +7.145 | +7.365 | S95 | 62.1809 | 64.6299 | 0.00792113 | 0.0082331 | 0.27115 | 2.14654 | 2.09032 | 2465
SOLIVE | 7615 | 30184.6 | +7.505 | +7.725 | S96 | 123.873 | 129.653 | 0.0157799 | 0.0165163 | 0.53845 | 4.27386 | 4.19336 | 4945
SOLIVE | 7255 | 23692.5 | +7.145 | +7.365 | S95 | 62.1809 | 64.6299 | 0.00792113 | 0.0082331 | 0.27115 | 2.14654 | 2.09032 | 2465
SOLIVE | 7255 | 25631.2 | +7.145 | +7.365 | S98 | 95.3199 | 100.878 | 0.0121427 | 0.0128507 | 0.412225 | 3.29519 | 3.26268 | 3847.5
SOLIVE | 7255 | 21744.1 | +7.145 | +7.365 | S97 | 95.8091 | 100.484 | 0.012205 | 0.0128006 | 0.416075 | 3.30798 | 3.24996 | 3832.5

# IfcBeam: IPE240 (8)
In: Undefined
Description: IPE240; Material: STEEL/E24-2
Tekla Common - Finish: GRENAILLE-PEINT; Grade: E24-2; Profile: IPE240; Name: EMPANNON; sets with these values: 2
Tekla Quantity - Gross footprint area: 0 m2; Area per tons: 30.0466 m2; Height: 240 mm; Width: 120 mm; sets with these values: 2
Name | Center of gravity Z (mm) | Center of gravity Y (mm) | Center of gravity X (mm) | Bottom elevation | Top elevation | Part mark | Assembly mark | Phase | Class | Net weight (kg) = NetWeight (kg) | Gross weight (kg) = Weight (kg) | Net volume (m3) = NetVolume (m3) | Gross volume (m3) | Net surface area (m2) | Gross area (m2) = OuterSurfaceArea (m2) | Tekla Quantity, Length (mm) = BaseQuantities, Length (mm)
EMPANNON | 3756.49 | 49365 | 4645.19 | +3.475 | +4.036 | 375 | K86 | 2 | 2005 | 268.595 | 284.71 | 0.0342159 | 0.0362688 | 8.73442 | 8.55457 | 9278.27
EMPANNON | 3762.2 | 15633.3 | 75599 | +3.527 | +3.997 | 369 | K58 | 1 | 1010 | 217.983 | 230.02 | 0.0277686 | 0.0293019 | 7.08767 | 6.91132 | 7496.01
EMPANNON | 3762.19 | 26050 | 75597.8 | +3.527 | +3.997 | 370 | K87 | 1 | 1010 | 218.053 | 230.364 | 0.0277775 | 0.0293457 | 7.08994 | 6.92165 | 7507.21
EMPANNON | 3766.24 | 13550 | 75496.3 | +3.533 | +3.999 | 368 | K57 | 1 | 1010 | 211.939 | 223.803 | 0.0269986 | 0.0285099 | 6.89155 | 6.72452 | 7293.4
EMPANNON | 3762.19 | 17716.7 | 75597.8 | +3.527 | +3.997 | 371 | K88 | 1 | 1010 | 218.053 | 230.364 | 0.0277775 | 0.0293457 | 7.08994 | 6.92165 | 7507.21
EMPANNON | 3762.2 | 19800 | 75599 | +3.527 | +3.997 | K91 | K91 | 1 | 1010 | 217.983 | 230.02 | 0.0277686 | 0.0293019 | 7.08767 | 6.91132 | 7496.01
EMPANNON | 3762.19 | 21883.3 | 75597.8 | +3.527 | +3.997 | 373 | K89 | 1 | 1010 | 218.053 | 230.364 | 0.0277775 | 0.0293457 | 7.08994 | 6.92165 | 7507.21
EMPANNON | 3762.2 | 23966.7 | 75599 | +3.527 | +3.997 | K92 | K92 | 1 | 1010 | 217.983 | 230.02 | 0.0277686 | 0.0293019 | 7.08767 | 6.91132 | 7496.01

# IfcBeam: IPE270 (7)
In: Undefined
Description: IPE270
Tekla Common - Finish: GRENAILLE-PEINT; Profile: IPE270; sets with these values: 2
Tekla Quantity - Area per tons: 28.8914 m2; Height: 270 mm; Width: 135 mm; sets with these values: 2
Name | Material | Center of gravity Z (mm) | Center of gravity Y (mm) | Center of gravity X (mm) | Bottom elevation | Top elevation | Part mark | Assembly mark | Phase | Class | Grade | Name | Net weight (kg) = NetWeight (kg) | Gross weight (kg) = Weight (kg) | Net volume (m3) = NetVolume (m3) | Gross volume (m3) | Gross footprint area (m2) | Net surface area (m2) | Gross area (m2) = OuterSurfaceArea (m2) | Tekla Quantity, Length (mm) = BaseQuantities, Length (mm)
PANNE | STEEL/E24-2 | 3167.53 | -588.15 | 20763.4 | +3.055 | +3.328 | 1015 | K94 | 3 | 3003 | E24-2 | PANNE | 4.42867 | 5.47931 | 0.000564161 | 0.000698001 | 0 | 0.149245 | 0.158305 | 152.07
EMPANNON | STEEL/E24-2 | 5320 | 26545 | 75607.1 | +5.110 | +5.529 | 1016 | K95 | 1 | 1010 | E24-2 | EMPANNON | 257.464 | 268.596 | 0.0327979 | 0.034216 | 0 | 7.95835 | 7.7601 | 7454.47
EMPANNON | STEEL/E24-2 | 5340.47 | 31745 | 74583.2 | +5.110 | +5.570 | K96 | K96 | 1 | 1010 | E24-2 | EMPANNON | 328.22 | 344.045 | 0.0418115 | 0.0438273 | 0 | 10.1497 | 9.93992 | 9548.44
EMPANNON | STEEL/E24-2 | 5340.47 | 30545 | 74583.2 | +5.110 | +5.570 | K97 | K97 | 1 | 1010 | E24-2 | EMPANNON | 328.22 | 344.045 | 0.0418115 | 0.0438273 | 0 | 10.1497 | 9.93992 | 9548.44
EMPANNON | STEEL/E24-2 | 5340.47 | 29145 | 74583.2 | +5.110 | +5.570 | K98 | K98 | 1 | 1010 | E24-2 | EMPANNON | 328.22 | 344.045 | 0.0418115 | 0.0438273 | 0 | 10.1497 | 9.93992 | 9548.44
