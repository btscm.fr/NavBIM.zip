Properties of the parts of a building model (IFC2X3), part 24 of 32

# IfcElementAssembly (4665)
Name | Assembly/Cast unit weight (kg) | Assembly/Cast unit bottom elevation | Assembly/Cast unit top elevation | Assembly/Cast unit name | Assembly/Cast unit position code | Assembly/Cast unit Mark
FPL8*210 | 2.13962 | +3.207 | +3.218 | FPL8*210 | 2/C | G79
FPL8*210 | 2.11135 | +3.207 | +3.218 | FPL8*210 | 2/E-D | G82
2 x L60*6 | 0 | +3.215 | +3.278 | L60*6 | 2/C | H31
FPL8*210 | 2.13962 | +3.207 | +3.218 | FPL8*210 | 2/C | G80
L60*6 | 0 | +3.215 | +3.278 | L60*6 | 2/C-B | H31
FPL8*210 | 2.3904 | +3.207 | +3.218 | FPL8*210 | 2/C-B | G69
L60*6 | 0 | +3.215 | +3.281 | L60*6 | 2/C-B | H30
3 x PL50*8 | 0.157 | +3.342 | +3.352 | PL50*8 | 2-3/E-D | Y3
3 x PL50*8 | 0.157 | +3.330 | +3.341 | PL50*8 | 2-3/E-D | Y3
3 x PL50*8 | 0.157 | +3.319 | +3.329 | PL50*8 | 2-3/E-D | Y3
3 x PL50*8 | 0.157 | +3.307 | +3.317 | PL50*8 | 2-3/E-D | Y3
3 x PL50*8 | 0.157 | +3.354 | +3.364 | PL50*8 | 2-3/E-D | Y3
3 x PL50*8 | 0.157 | +3.366 | +3.376 | PL50*8 | 2-3/E-D | Y3
3 x PL50*8 | 0.157 | +3.219 | +3.229 | PL50*8 | 2-3/E-D | Y3
4 x PL50*8 | 0.157 | +3.231 | +3.241 | PL50*8 | 2-3/E-D | Y3
4 x PL50*8 | 0.157 | +3.242 | +3.253 | PL50*8 | 2-3/E-D | Y3
4 x PL50*8 | 0.157 | +3.254 | +3.264 | PL50*8 | 2-3/E-D | Y3
4 x PL50*8 | 0.157 | +3.266 | +3.276 | PL50*8 | 2-3/E-D | Y3
4 x PL50*8 | 0.157 | +3.278 | +3.288 | PL50*8 | 2-3/E-D | Y3
PL50*8 | 0.157 | +3.219 | +3.229 | PL50*8 | 2-3/D | Y3
4 x PL50*8 | 0.157 | +3.342 | +3.352 | PL50*8 | 2-3/D-C | Y3
2 x PL50*8 | 0.157 | +3.354 | +3.364 | PL50*8 | 2-3/D-C | Y3
PL50*8 | 0.157 | +3.366 | +3.376 | PL50*8 | 2-3/D | Y3
2 x PL50*8 | 0.157 | +3.255 | +3.265 | PL50*8 | 2-3/D-C | Y3
2 x PL50*8 | 0.157 | +3.330 | +3.340 | PL50*8 | 2-3/D-C | Y3
2 x PL50*8 | 0.157 | +3.318 | +3.329 | PL50*8 | 2-3/D-C | Y3
2 x PL50*8 | 0.157 | +3.307 | +3.317 | PL50*8 | 2-3/D-C | Y3
2 x PL50*8 | 0.157 | +3.278 | +3.288 | PL50*8 | 2-3/D-C | Y3
4 x PL50*8 | 0.157 | +3.243 | +3.253 | PL50*8 | 2-3/D-C | Y3
4 x PL50*8 | 0.157 | +3.266 | +3.276 | PL50*8 | 2-3/D-C | Y3
2 x PL50*8 | 0.157 | +3.231 | +3.241 | PL50*8 | 2-3/D-C | Y3
4 x PL50*8 | 0.157 | +3.220 | +3.230 | PL50*8 | 2-3/D-C | Y3
PL50*8 | 0.157 | +3.366 | +3.376 | PL50*8 | 2-3/D-C | Y3
2 x PL50*8 | 0.157 | +3.330 | +3.341 | PL50*8 | 2-3/D-C | Y3
2 x PL50*8 | 0.157 | +3.319 | +3.329 | PL50*8 | 2-3/D-C | Y3
2 x PL50*8 | 0.157 | +3.308 | +3.318 | PL50*8 | 2-3/D-C | Y3
2 x PL50*8 | 0.157 | +3.353 | +3.363 | PL50*8 | 2-3/D-C | Y3
2 x PL50*8 | 0.157 | +3.364 | +3.375 | PL50*8 | 2-3/D-C | Y3
2 x PL50*8 | 0.157 | +3.232 | +3.242 | PL50*8 | 2-3/D-C | Y3
2 x PL50*8 | 0.157 | +3.254 | +3.265 | PL50*8 | 2-3/D-C | Y3
2 x PL50*8 | 0.157 | +3.277 | +3.287 | PL50*8 | 2-3/D-C | Y3
PL50*8 | 0.157 | +3.342 | +3.352 | PL50*8 | 2-3/C-B | Y3
PL50*8 | 0.157 | +3.330 | +3.341 | PL50*8 | 2-3/C-B | Y3
PL50*8 | 0.157 | +3.353 | +3.363 | PL50*8 | 2-3/C-B | Y3
2 x PL50*8 | 0.157 | +3.364 | +3.374 | PL50*8 | 2-3/C-B | Y3
2 x PL50*8 | 0.157 | +3.277 | +3.287 | PL50*8 | 2-3/C-B | Y3
PL50*8 | 0.157 | +3.319 | +3.329 | PL50*8 | 2-3/C-B | Y3
2 x PL50*8 | 0.157 | +3.308 | +3.318 | PL50*8 | 2-3/C-B | Y3
2 x PL50*8 | 0.157 | +3.265 | +3.276 | PL50*8 | 2-3/C-B | Y3
2 x PL50*8 | 0.157 | +3.254 | +3.264 | PL50*8 | 2-3/C-B | Y3
2 x PL50*8 | 0.157 | +3.243 | +3.253 | PL50*8 | 2-3/C-B | Y3
2 x PL50*8 | 0.157 | +3.232 | +3.242 | PL50*8 | 2-3/C-B | Y3
2 x PL50*8 | 0.157 | +3.221 | +3.231 | PL50*8 | 2-3/C-B | Y3
PL50*8 | 0.157 | +3.280 | +3.290 | PL50*8 | 2-3/C-B | Y3
PL50*8 | 0.157 | +3.294 | +3.304 | PL50*8 | 2-3/C-B | Y3
PL50*8 | 0.157 | +3.266 | +3.276 | PL50*8 | 2-3/C-B | Y3
PL50*8 | 0.157 | +3.252 | +3.262 | PL50*8 | 2-3/C-B | Y3
PL50*8 | 0.157 | +3.238 | +3.248 | PL50*8 | 2-3/C-B | Y3
PL50*8 | 0.157 | +3.224 | +3.234 | PL50*8 | 2-3/C-B | Y3
PL50*8 | 0.157 | +3.322 | +3.332 | PL50*8 | 2-3/C-B | Y3
PL50*8 | 0.157 | +3.336 | +3.346 | PL50*8 | 2-3/C-B | Y3
PL50*8 | 0.157 | +3.350 | +3.360 | PL50*8 | 2-3/C-B | Y3
2 x PL50*8 | 0.157 | +3.421 | +3.431 | PL50*8 | 2-3/D-C | Y3
2 x PL50*8 | 0.157 | +3.520 | +3.530 | PL50*8 | 2-3/D-C | Y3
2 x PL50*8 | 0.157 | +3.432 | +3.442 | PL50*8 | 2-3/D-C | Y3
2 x PL50*8 | 0.157 | +3.444 | +3.454 | PL50*8 | 2-3/D-C | Y3
2 x PL50*8 | 0.157 | +3.455 | +3.465 | PL50*8 | 2-3/D-C | Y3
2 x PL50*8 | 0.157 | +3.409 | +3.420 | PL50*8 | 2-3/D-C | Y3
2 x PL50*8 | 0.157 | +3.398 | +3.408 | PL50*8 | 2-3/D-C | Y3
2 x PL50*8 | 0.157 | +3.509 | +3.519 | PL50*8 | 2-3/D-C | Y3
2 x PL50*8 | 0.157 | +3.497 | +3.508 | PL50*8 | 2-3/D-C | Y3
2 x PL50*8 | 0.157 | +3.486 | +3.496 | PL50*8 | 2-3/D-C | Y3
2 x PL50*8 | 0.157 | +3.532 | +3.542 | PL50*8 | 2-3/D-C | Y3
2 x PL50*8 | 0.157 | +3.543 | +3.553 | PL50*8 | 2-3/D-C | Y3
PL200*20 | 22.5756 | -0.400 | -0.165 | PL200*20 | -/D' | H78
UPN200 | 2.0881 | +2.930 | +3.800 | UPN200 | 1-2/E-D | L36
UPN200 | 2.0881 | +2.930 | +3.910 | UPN200 | 1-2/D-C | L37
UPN200 | 1.04405 | +2.930 | +3.730 | UPN200 | 1-2/E-D | L35
UPN200 | 2.0881 | +2.930 | +3.860 | UPN200 | 1-2/D-C | L34
UPN200 | 1.04405 | +2.930 | +3.910 | UPN200 | 1-2/D-C | L33
6 x L60*6 | 0 | +7.170 | +7.340 | L60*6 | 3-4/B-A | H28
HEA160 | 3.04947 | +3.020 | +3.446 | HEA160 | 1-2/E-D | H83
HEA160 | 3.09151 | +3.020 | +3.487 | HEA160 | 1-2/E-D | H84
IPE220 | 0 | +7.505 | +7.725 | IPE220 | 3-4/B-A | S95
2 x HEA100 | 0 | +3.020 | +3.320 | HEA100 | 1-2/E-D | H80
6 x L70*50*6 | 0 | +3.020 | +3.320 | L70*50*6 | 1-2/E-D | H92
HEA160 | 1.78463 | +3.020 | +3.523 | HEA160 | 1-2/E-D | H85
6 x L70*50*6 | 0 | +3.020 | +3.320 | L70*50*6 | 1-2/D-C | H92
6 x HEA100 | 0 | +3.020 | +3.320 | HEA100 | 1-2/E-D | H79
HEA160 | 1.78462 | +3.020 | +3.554 | HEA160 | 1-2/E-D | H86
HEA160 | 1.78462 | +3.020 | +3.628 | HEA160 | 1-2/D-C | H88
5 x HEA100 | 0 | +3.020 | +3.320 | HEA100 | 1-2/D-C | H80
6 x HEA100 | 0 | +3.020 | +3.320 | HEA100 | 1-2/D-C | H79
HEA160 | 1.78462 | +3.020 | +3.607 | HEA160 | 1-2/D-C | H87
2 x HEA100 | 0 | +3.020 | +3.320 | HEA100 | 1-2/D | H80
HEA160 | 2.31201 | +3.020 | +3.578 | HEA160 | 1-2/D | H91
HEA160 | 1.78461 | +3.020 | +3.643 | HEA160 | 1-2/D-C | H89
HEA160 | 1.78461 | +3.020 | +3.653 | HEA160 | 1-2/D-C | H90
HEA160 | 1.78462 | +3.020 | +3.655 | HEA160 | 1-2/D-C | H82
HEA160 | 1.78461 | +3.020 | +3.658 | HEA160 | 1-2/D-C | H81
2 x PL8 | 9.76032 | +5.129 | +5.190 | PL8 | 3-4/E-D | G41
PL60*10 | 0.66882 | +3.966 | +4.026 | PL60*10 | 1/D-C | H7
PL60*10 | 0.66882 | +3.966 | +4.026 | PL60*10 | 1/E-D | H7
L70*7 | 0 | +4.733 | +4.804 | L70*7 | 3-4/E-D | C115
L50*5 | 0 | +5.120 | +5.502 | L50*5 | 3-4/E-D | C35
L50*5 | 0 | +4.756 | +5.141 | L50*5 | 3-4/E-D | C24
L70*7 | 0 | +4.733 | +4.804 | L70*7 | 3-4/E-D | C116
2 x L50*5 | 0 | +5.122 | +5.503 | L50*5 | 3-4/D-C | C36
4 x PL8 | 9.12418 | +5.131 | +5.188 | PL8 | 3-4/D-C | G42
L50*5 | 0 | +4.760 | +5.143 | L50*5 | 3-4/D-C | C29
6 x L50*5 | 0 | +5.122 | +5.506 | L50*5 | 3-4/D-C | C28
3 x PL8 | 6.37364 | +4.795 | +4.833 | PL8 | 3-4/D-C | G48
L70*7 | 0 | +4.733 | +4.804 | L70*7 | 3-4/D-C | C117
6 x L50*5 | 0 | +4.761 | +5.143 | L50*5 | 3-4/D-C | C25
2 x L70*7 | 0 | +4.733 | +4.804 | L70*7 | 3-4/D-C | C118
L70*7 | 0 | +4.733 | +4.804 | L70*7 | 3-4/D-C | C119
L50*5 | 0 | +4.756 | +5.143 | L50*5 | 3-4/D-C | C29
PL8 | 2.02629 | +5.481 | +5.517 | PL8 | 3/D | G34
2 x L70*7 | 0 | +5.411 | +5.496 | L70*7 | 3/D | H39
2 x FPL6*120 | 0.793042 | +5.509 | +5.584 | FPL6*120 | 3/D | H49
PL8 | 2.02629 | +5.481 | +5.517 | PL8 | 3/D | G35
L70*7 | 0 | +4.733 | +4.804 | L70*7 | 3-4/C-B | C117
L70*7 | 0 | +4.733 | +4.804 | L70*7 | 3-4/C-B | C128
PL8 | 10.0751 | +4.767 | +4.835 | PL8 | 3-4/C-B | G37
PL20*300 | 22.7587 | +5.393 | +5.793 | PL20*300 | 4/B | H76
PL10 | 5.67839 | +5.632 | +5.852 | PL10 | 4/C-B | H2
PL8 | 2.93801 | +5.427 | +5.460 | PL8 | 4/B-A | G16
L70*7 | 0 | +5.411 | +5.496 | L70*7 | 3/C | H39
FPL6*120 | 0.793042 | +5.509 | +5.584 | FPL6*120 | 3/C | H49
PL8 | 2.02629 | +5.481 | +5.517 | PL8 | 3/C | G34
L50*5 | 0 | +4.767 | +5.504 | L50*5 | 3-4/C-B | C47
L50*5 | 0 | +4.042 | +4.783 | L50*5 | 3-4/C-B | C45
TUBE-C-120*120*4 | 15.035 | +5.600 | +5.920 | TUBE-C-120*120*4 | 2-3/F-E | S1
3 x TUBE-C-120*120*4 | 15.035 | +5.600 | +5.920 | TUBE-C-120*120*4 | 2-3/E-D | S1
UPN120 | 0 | +5.700 | +5.820 | UPN120 | 2-3/C-B | S107
TUBE-C-120*120*4 | 14.6378 | +5.600 | +5.920 | TUBE-C-120*120*4 | 2-3/F | S2
4 x TUBE-C-120*120*4 | 15.035 | +5.600 | +5.920 | TUBE-C-120*120*4 | 2-3/D-C | S1
UPN120 | 0 | +5.700 | +5.820 | UPN120 | 2-3/F-D | S105
2 x TUBE-C-120*120*4 | 15.035 | +5.600 | +5.920 | TUBE-C-120*120*4 | 2-3/C-B | S1
UPN120 | 1.51976 | +5.700 | +5.820 | UPN120 | 2-3/C-B | S99
UPN120 | 0 | +5.700 | +5.820 | UPN120 | 3/F-E | S106
UPN120 | 0 | +5.700 | +5.820 | UPN120 | 3/C-B | S107
UPN120 | 0 | +5.700 | +5.820 | UPN120 | 2-3/F-E | S106
UPN120 | 0 | +5.700 | +5.820 | UPN120 | 2-3/E-D | S104
UPN120 | 0 | +5.700 | +5.820 | UPN120 | 2-3/E-D | S103
UPN120 | 0 | +5.700 | +5.820 | UPN120 | 2-3/E-C | S102
3 x UPN120 | 0 | +5.700 | +5.820 | UPN120 | 2-3/D-C | S101
UPN120 | 0 | +5.700 | +5.820 | UPN120 | 2-3/C-B | S100
UPN120 | 0 | +5.700 | +5.820 | UPN120 | 2-3/D-B | S101
UPN120 | 0 | +5.700 | +5.820 | UPN120 | 3/F-D | S105
UPN120 | 0 | +5.700 | +5.820 | UPN120 | 3/E-D | S104
UPN120 | 0 | +5.700 | +5.820 | UPN120 | 3/E-D | S103
UPN120 | 0 | +5.700 | +5.820 | UPN120 | 3/E-C | S102
3 x UPN120 | 0 | +5.700 | +5.820 | UPN120 | 3/D-C | S101
UPN120 | 0 | +5.700 | +5.820 | UPN120 | 3/D-B | S101
UPN120 | 0 | +5.700 | +5.820 | UPN120 | 3/C-B | S100
IPEA300 | 13.0407 | +3.023 | +3.360 | IPEA300 | 3/1-F | K94
UPF-80*50*4 | 1.35648 | +3.276 | +3.378 | UPF-80*50*4 | 2-3/D-C | U14
UPF-100*50*4 | 1.35648 | +10.189 | +10.307 | UPF-100*50*4 | >/B'> | U1
UPF-80*50*4 | 1.35648 | +3.276 | +3.378 | UPF-80*50*4 | 2-3/D-C | U15
UPF-80*50*4 | 1.35648 | +3.276 | +3.378 | UPF-80*50*4 | 2-3/E-D | U16
UPF-100*50*4 | 1.35648 | +10.446 | +10.566 | UPF-100*50*4 | /B'> | U5
2 x L60*6 | 0 | +7.530 | +7.700 | L60*6 | 3-4/B-A | H28
UPF-100*50*4 | 1.35648 | +3.796 | +3.933 | UPF-100*50*4 | 1-2/C-B | U6
PL12*80 | 2.41152 | +5.421 | +5.741 | PL12*80 | 4/B | H77
PL8 | 9.51463 | +5.085 | +5.141 | PL8 | 4-5/B-A | G22
PL8 | 2.63006 | +4.759 | +4.781 | PL8 | 4-5/B-A | G19
PL8 | 3.33836 | +5.023 | +5.058 | PL8 | 3-4/F | G8
3 x PL8 | 2.63006 | +4.759 | +4.781 | PL8 | 4-5/C-B | G20
PL8 | 2.89301 | +5.427 | +5.460 | PL8 | 4/C-B | G15
PL60*8 | 0.22608 | +0.492 | +0.571 | PL60*8 | 5-6/A | Y2
PL8 | 5.6477 | +2.148 | +2.385 | PL8 | 5-6/A | G33
PL60*8 | 0.22608 | +0.215 | +0.295 | PL60*8 | 5-6/A | Y2
TUBE-C-60*60*3 | 1.45395 | +4.417 | +5.588 | TUBE-C-60*60*3 | 6/A | L44
PL8 | 4.77768 | +4.759 | +4.800 | PL8 | 4-5/C-B | G13
PL8 | 3.33836 | +4.548 | +4.582 | PL8 | 3-4/F | G8
PL8 | 9.69651 | +4.418 | +4.475 | PL8 | 3-4/F-E | G11
PL8 | 9.6965 | +5.131 | +5.188 | PL8 | 3-4/F-E | G11
IPE270 | 0 | +5.110 | +5.570 | IPE270 | 7-8/D-C | K98
UPN160 | 0 | +3.000 | +3.065 | UPN160 | 3-4/F | L111
UPN160 | 1.2089 | -0.200 | +3.000 | UPN160 | 3-4/F | M16
TUBE-C-100*100*3 | 0 | +2.187 | +3.440 | TUBE-C-100*100*3 | /<-D1 | B17
UPN120 | 0 | +3.000 | +3.600 | UPN120 | 3-4/1-8 | L115
UPN120 | 0.261605 | +3.000 | +3.600 | UPN120 | 4-5/8-F | L80
TUBE-C-60*60*3 | 1.45395 | +4.417 | +5.588 | TUBE-C-60*60*3 | 7/A | L44
4 x L60*6 | 0 | +3.220 | +3.305 | L60*6 | 3-4/8-F | H19
4 x L60*6 | 0 | +3.218 | +3.304 | L60*6 | 3-4/8-F | H19
3 x IPE120 | 0 | +3.206 | +3.327 | IPE120 | 3-4/8-F | K107
L60*6 | 0 | +3.220 | +3.305 | L60*6 | 3/8-F | H19
L60*6 | 0 | +3.218 | +3.304 | L60*6 | 3/8-F | H19
2 x L60*6 | 0 | +3.218 | +3.304 | L60*6 | 4/8-F | H19
2 x L60*6 | 0 | +3.220 | +3.305 | L60*6 | 4/8-F | H19
2 x IPE120 | 0 | +3.206 | +3.327 | IPE120 | 4-5/8-F | K106
2 x L60*6 | 0 | +3.218 | +3.304 | L60*6 | 4-5/8-F | H19
2 x L60*6 | 0 | +3.220 | +3.305 | L60*6 | 4-5/8-F | H19
L60*6 | 0 | +3.218 | +3.304 | L60*6 | 5/8-F | H19
HEA120 | 3.46185 | +4.526 | +5.960 | HEA120 | 3-4/C-B | L1
HEA120 | 3.46185 | +4.277 | +5.960 | HEA120 | 4/C-B | L3
L60*6 | 0 | +3.220 | +3.305 | L60*6 | 5/8-F | H19
UPN180 | 0.7532 | +4.222 | +4.962 | UPN180 | 3-4/C-B | K93
TUBE-C-60*60*3 | 0.747305 | +4.181 | +4.271 | TUBE-C-60*60*3 | 4/C-B | W6
TUBE-C-60*60*3 | 0 | +4.163 | +5.845 | TUBE-C-60*60*3 | 4/C-B | L46
HEA120 | 3.46185 | +4.775 | +5.960 | HEA120 | 3-4/C-B | L2
TUBE-C-60*60*3 | 0.747305 | +4.679 | +4.769 | TUBE-C-60*60*3 | 3-4/C-B | W6
TUBE-C-60*60*3 | 0.747305 | +4.430 | +4.520 | TUBE-C-60*60*3 | 3-4/C-B | W6
UPF-100*50*4 | 1.35648 | +4.322 | +4.477 | UPF-100*50*4 | 4-5/F-E | U11
PL6000*180 | 109855 | -0.000 | +6.000 | PL6000*180 | 3-8/F | Z2 | PredefinedType: REINFORCEMENT_UNIT; Tekla Assembly - Cast unit vertical position code: A-+3940; Cast unit rebar weight: 0 kg
UPF-100*50*4 | 1.35648 | +4.322 | +4.477 | UPF-100*50*4 | 3-4/F-E | U11
UPF-100*50*4 | 1.35648 | +4.322 | +4.477 | UPF-100*50*4 | 4-5/D-C | U12
UPF-100*50*4 | 1.35648 | +4.322 | +4.477 | UPF-100*50*4 | 3-4/D-C | U12
UPF-100*50*4 | 1.35648 | +4.322 | +4.477 | UPF-100*50*4 | 4-5/C-B | U12
UPF-100*50*4 | 1.35648 | +4.322 | +4.477 | UPF-100*50*4 | 3-4/C-B | U12
UPF-100*50*4 | 1.35648 | +4.322 | +4.489 | UPF-100*50*4 | 4-5/C-B | U13
L60*6 | 0 | +3.605 | +4.382 | L60*6 | 5/F | M7
L60*6 | 0 | +4.237 | +4.297 | L60*6 | 5/F | H17
L60*6 | 0 | +3.880 | +3.940 | L60*6 | 5/F | H18
L60*6 | 0 | +3.670 | +3.730 | L60*6 | 5/E | M9
14 x L60*6 | 0 | +4.237 | +4.297 | L60*6 | 5/D-C | H17
14 x L80*8 | 0 | +4.219 | +4.237 | L80*8 | 5/D-C | H63
14 x L80*8 | 0 | +3.940 | +3.958 | L80*8 | 5/D-C | C136
14 x L60*6 | 0 | +3.880 | +3.940 | L60*6 | 5/D-C | H18
4 x L60*6 | 0 | +3.605 | +4.382 | L60*6 | 5/D-C | M11
9 x L60*6 | 0 | +3.605 | +4.382 | L60*6 | 5/D-C | M7
14 x L60*6 | 0 | +3.880 | +3.940 | L60*6 | 5/C-B | H18
14 x L80*8 | 0 | +3.940 | +3.958 | L80*8 | 5/C-B | C136
9 x L60*6 | 0 | +3.605 | +4.382 | L60*6 | 5/C-B | M7
14 x L80*8 | 0 | +4.219 | +4.237 | L80*8 | 5/C-B | H63
14 x L60*6 | 0 | +4.237 | +4.297 | L60*6 | 5/C-B | H17
3 x L60*6 | 0 | +3.605 | +4.382 | L60*6 | 5/C-B | M11
4 x L80*8 | 0 | +4.219 | +4.237 | L80*8 | 5/B-A | H63
4 x L60*6 | 0 | +4.237 | +4.297 | L60*6 | 5/B-A | H17
3 x L60*6 | 0 | +3.605 | +4.382 | L60*6 | 5/B-A | M7
4 x L60*6 | 0 | +3.880 | +3.940 | L60*6 | 5/B-A | H18
4 x L80*8 | 0 | +3.940 | +3.958 | L80*8 | 5/B-A | C136
L60*6 | 0 | +3.605 | +4.382 | L60*6 | 5/B-A | M11
L60*6 | 0 | +3.605 | +4.382 | L60*6 | 5/A | M7
L60*6 | 0 | +3.880 | +3.940 | L60*6 | 5/A | H18
L80*8 | 0 | +3.940 | +3.958 | L80*8 | 5/A | C136
L60*6 | 0 | +4.237 | +4.297 | L60*6 | 5/A | H17
L80*8 | 0 | +4.219 | +4.237 | L80*8 | 5/A | H63
2 x L60*6 | 0 | +3.880 | +3.940 | L60*6 | 5/B | H18
2 x L80*8 | 0 | +3.940 | +3.958 | L80*8 | 5/B | C136
L60*6 | 0 | +3.605 | +4.382 | L60*6 | 5/B | M7
2 x L80*8 | 0 | +4.219 | +4.237 | L80*8 | 5/B | H63
2 x L60*6 | 0 | +4.237 | +4.297 | L60*6 | 5/B | H17
2 x L60*6 | 0 | +3.880 | +3.940 | L60*6 | 5/C | H18
2 x L80*8 | 0 | +3.940 | +3.958 | L80*8 | 5/C | C136
L60*6 | 0 | +3.605 | +4.382 | L60*6 | 5/C | M7
2 x L60*6 | 0 | +4.237 | +4.297 | L60*6 | 5/C | H17
2 x L80*8 | 0 | +4.219 | +4.237 | L80*8 | 5/C | H63
2 x L60*6 | 0 | +3.880 | +3.940 | L60*6 | 5/D | H18
2 x L80*8 | 0 | +3.940 | +3.958 | L80*8 | 5/D | C136
2 x L80*8 | 0 | +4.219 | +4.237 | L80*8 | 5/D | H63
2 x L60*6 | 0 | +4.237 | +4.297 | L60*6 | 5/D | H17
L60*6 | 0 | +3.605 | +4.382 | L60*6 | 5/D | M7
L60*6 | 0 | +3.605 | +4.312 | L60*6 | 5/D-C | M8
L60*6 | 0 | +3.605 | +4.312 | L60*6 | 5/D | M8
L60*6 | 0 | +3.605 | +4.312 | L60*6 | 5/C | M8
L60*6 | 0 | +3.605 | +4.312 | L60*6 | 5/C-B | M8
L60*6 | 0 | +3.605 | +4.312 | L60*6 | 5/B | M8
L60*6 | 0 | +3.605 | +4.312 | L60*6 | 5/C-B | M10
2 x L60*6 | 0 | +3.670 | +3.730 | L60*6 | 5/E-D | M9
2 x TUBE-C-70*70*3 | 0.205167 | +3.600 | +3.670 | TUBE-C-70*70*3 | 5/D-C | L61
TUBE-C-70*70*3 | 0.205167 | +3.600 | +3.670 | TUBE-C-70*70*3 | 5/E-D | L59
TUBE-C-70*70*3 | 0.205167 | +3.600 | +3.670 | TUBE-C-70*70*3 | 5/E-C | L60
4 x L60*6 | 0 | +3.670 | +3.730 | L60*6 | 5/D-C | M9
4 x L60*6 | 0 | +3.670 | +3.730 | L60*6 | 5/C-B | M9
TUBE-C-70*70*3 | 0.205167 | +3.600 | +3.670 | TUBE-C-70*70*3 | 5/D-C | L62
TUBE-C-70*70*3 | 0.205167 | +3.600 | +3.670 | TUBE-C-70*70*3 | 5/D-B | L63
2 x TUBE-C-70*70*3 | 0.205167 | +3.600 | +3.670 | TUBE-C-70*70*3 | 5/C-B | L61
6 x TUBE-C-70*70*3 | 0.205167 | +4.317 | +4.387 | TUBE-C-70*70*3 | 5/D-C | L72
TUBE-C-70*70*3 | 0.205167 | +3.600 | +3.670 | TUBE-C-70*70*3 | 5/C-B | L62
L60*6 | 0 | +3.670 | +3.730 | L60*6 | 5/B-A | M9
TUBE-C-70*70*3 | 0.205167 | +3.600 | +3.670 | TUBE-C-70*70*3 | 5/C-A | L64
TUBE-C-70*70*3 | 0.205167 | +3.600 | +3.670 | TUBE-C-70*70*3 | 5/B-A | L65
TUBE-C-70*70*3 | 0.205167 | +4.317 | +4.387 | TUBE-C-70*70*3 | 5/E-D | L71
TUBE-C-70*70*3 | 0.205167 | +4.247 | +4.317 | TUBE-C-70*70*3 | 5/D-C | L73
TUBE-C-70*70*3 | 0.205167 | +4.317 | +4.387 | TUBE-C-70*70*3 | 5/D-C | L74
TUBE-C-70*70*3 | 0.205167 | +4.247 | +4.317 | TUBE-C-70*70*3 | 5/C-B | L75
6 x TUBE-C-70*70*3 | 0.205167 | +4.317 | +4.387 | TUBE-C-70*70*3 | 5/C-B | L72
TUBE-C-70*70*3 | 0.205167 | +4.317 | +4.387 | TUBE-C-70*70*3 | 5/B-A | L76
TUBE-C-70*70*3 | 0.205167 | +4.247 | +4.317 | TUBE-C-70*70*3 | 5/C-B | L77
TUBE-C-70*70*3 | 0.205167 | +4.317 | +4.387 | TUBE-C-70*70*3 | 5/B-A | L78
TUBE-C-70*70*3 | 0.205167 | +4.317 | +4.387 | TUBE-C-70*70*3 | 5/B-A | L79
2 x PL80*8 | 0.582784 | +5.892 | +5.900 | PL80*8 | 7'/D1-C1 | H44
2 x PL120*12 | 6.25154 | +4.990 | +5.190 | PL120*12 | 7'/D1-C1 | E1
L60*6 | 0 | +3.880 | +5.608 | L60*6 | 6/D-C | M6
2 x TUBE-C-70*70*3 | 0.205168 | +3.500 | +3.570 | TUBE-C-70*70*3 | 5-7/D-C | M19
2 x L50*5 | 0 | +3.502 | +5.070 | L50*5 | 6-7/D-C | H34
2 x TUBE-C-70*70*3 | 0.205168 | +5.245 | +5.601 | TUBE-C-70*70*3 | 6-7/D-C | M20
4 x L40*4 | 0 | +4.208 | +4.795 | L40*4 | <1/C-B | W3
TUBE-C-150*150*4 | 1.4882 | +4.685 | +4.950 | TUBE-C-150*150*4 | <1/C-B | L6
HEA160 | 10.6652 | +3.260 | +4.950 | HEA160 | <1/C | E3
L70*7 | 0 | +5.523 | +5.593 | L70*7 | 6/D-C | H41
TUBE-C-70*70*3 | 0.481739 | +3.877 | +5.608 | TUBE-C-70*70*3 | 6/D-C | M18
TUBE-C-150*150*4 | 1.36004 | +4.050 | +4.365 | TUBE-C-150*150*4 | <1/C-B | L7
L60*6 | 0 | +4.237 | +4.297 | L60*6 | 6/D-C | H14
L60*6 | 0 | +3.880 | +3.940 | L60*6 | 6/D-C | H15
TUBE-C-70*70*3 | 0.307751 | +3.877 | +4.316 | TUBE-C-70*70*3 | 5-6/D-C | M21
HEA160 | 10.6652 | +3.260 | +4.950 | HEA160 | <1/C-B | E3
2 x L40*4 | 0 | +4.260 | +4.790 | L40*4 | <1/C-B | W2
2 x PL50*5 | 0.098125 | +4.538 | +4.594 | PL50*5 | <1/C-B | Y4
2 x PL50*5 | 0.098125 | +4.472 | +4.528 | PL50*5 | <1/C-B | Y4
2 x PL50*5 | 0.098125 | +4.406 | +4.462 | PL50*5 | <1/C-B | Y4
2 x PL50*5 | 0.098125 | +4.340 | +4.396 | PL50*5 | <1/C-B | Y4
2 x PL50*5 | 0.098125 | +4.274 | +4.330 | PL50*5 | <1/C-B | Y4
2 x PL50*5 | 0.098125 | +4.604 | +4.660 | PL50*5 | <1/C-B | Y4
2 x PL50*5 | 0.098125 | +4.670 | +4.726 | PL50*5 | <1/C-B | Y4
2 x TUBE-C-80*80*3 | 2.61248 | +3.120 | +3.722 | TUBE-C-80*80*3 | 1-2/E-D | S8
3 x L60*6 | 0 | +3.165 | +3.225 | L60*6 | 1-2/E-D | L13
2 x L60*6 | 0 | +3.165 | +3.225 | L60*6 | 1-2/E-D | L15
2 x L80*8 | 0 | +3.523 | +3.544 | L80*8 | 1-2/D-C | H56
L60*6 | 0 | +3.165 | +3.225 | L60*6 | 1-2/D-C | L17
TUBE-C-80*80*3 | 1.79394 | +3.040 | +3.527 | TUBE-C-80*80*3 | 1-2/D-C | S88
PL200*300 | 3053.94 | +3.273 | +3.473 | PL200*300 | /D1-C1 | Z13
PL300*250 | 3893.51 | +3.273 | +3.728 | PL300*250 | 7'-/D1-C1 | Z59
TUBE-C-70*70*3 | 0.205168 | +3.590 | +3.730 | TUBE-C-70*70*3 | 7'-/D1-C1 | L109
UPN160 | 0.8478 | +3.071 | +3.400 | UPN160 | 7'-/D1-C1 | M23
TUBE-C-60*60*3 | 0.147706 | +3.533 | +3.593 | TUBE-C-60*60*3 | 7'-/D1-C1 | L40
TUBE-C-70*70*3 | 0.205168 | +3.116 | +3.186 | TUBE-C-70*70*3 | 7'-/D1-C1 | L110
UPN160 | 0.4239 | +3.400 | +3.578 | UPN160 | 7'-/D1-C1 | L114
FPL370*6 | 3.38661 | +3.485 | +3.569 | FPL370*6 | 7'-/D1-C1 | H48
2 x L80*8 | 0 | +3.566 | +3.587 | L80*8 | 7'-/D1-C1 | H62
TUBE-C-60*60*3 | 0.147706 | +1.690 | +1.750 | TUBE-C-60*60*3 | 7'-/D1-C1 | L41
L60*6 | 0 | +1.630 | +1.690 | L60*6 | 7'-/D1-C1 | H16
L70*7 | 0 | +1.620 | +1.690 | L70*7 | 7'-/D1-C1 | H43
L70*7 | 0 | +0.080 | +0.150 | L70*7 | 7'-/D1-C1 | H43
TUBE-C-60*60*3 | 0.147706 | +0.150 | +0.210 | TUBE-C-60*60*3 | 7'-/D1-C1 | L41
L60*6 | 0 | +0.090 | +0.150 | L60*6 | 7'-/D1-C1 | H16
BLL300*60*1.5 | 0 | +3.505 | +3.658 | BLL300*60*1.5 | 7'-/D1-C1 | L120
UPN160 | 0.8478 | +3.071 | +3.400 | UPN160 | 7'-/D1-C1 | M15
PL30 | 0.288452 | +4.428 | +4.444 | PL30 | 4/D | G94
PL30 | 0.576904 | +5.169 | +5.331 | PL30 | 3/D | G98
PL30 | 0.288452 | +5.080 | +5.096 | PL30 | 5-6/C-B | G94
PL30 | 0.288452 | +4.919 | +4.935 | PL30 | 5-6/C-B | G94
PL30 | 0.288452 | +4.926 | +5.007 | PL30 | 5-6/C-B | G94
PL30 | 0.288452 | +5.007 | +5.088 | PL30 | 5-6/C-B | G94
PL30 | 0.288452 | +4.999 | +5.015 | PL30 | 5-6/C-B | G94
PL30 | 1.41321 | +4.037 | +4.215 | PL30 | 4/C-B | G91
PL30 | 0.851336 | +3.979 | +4.141 | PL30 | 5/C-B | G93
PL30 | 2.26286 | +3.072 | +3.250 | PL30 | 2-3/E-D | G85
PL30 | 1.68941 | +5.113 | +5.290 | PL30 | 4/B | G97
PL30 | 0.858856 | +4.504 | +4.674 | PL30 | 4-5/B-A | G92
PL30 | 1.15381 | +5.263 | +5.425 | PL30 | 6/C | G95
PL30 | 2.01916 | +4.536 | +4.713 | PL30 | 5-6/A | G89
PL30 | 1.68762 | +5.254 | +5.431 | PL30 | 5/A | G96
PL30 | 1.98974 | +3.512 | +3.690 | PL30 | 5/E-D | G86
PL30 | 1.9907 | +4.541 | +4.718 | PL30 | 6-7/D-C | G87
PL30 | 1.42809 | +5.175 | +5.338 | PL30 | 5-6/E-D | G90
PL30 | 0.288452 | +4.266 | +4.282 | PL30 | 4/D | G94
PL30 | 0.288452 | +4.274 | +4.355 | PL30 | 4/D | G94
PL30 | 0.288452 | +4.347 | +4.363 | PL30 | 4/D | G94
PL30 | 0.288452 | +4.355 | +4.436 | PL30 | 4/D | G94
PL30 | 2.27797 | +5.459 | +5.637 | PL30 | 6-7/B-A | G84
PL30 | 1.99145 | +4.177 | +4.355 | PL30 | 6/D-C | G88
PL1000 | 25878.2 | -0.000 | +1.000 | PL1000 | <1/D-C | G99
IPE500 | 58.6468 | -0.400 | +5.890 | IPE500 | 6/C | P35

# IfcMechanicalFastener: Bolt assembly (7434)
In: Undefined
Tekla Fastener - Location: Montage; sets with these values: 2
Name | NominalDiameter (mm) = Washer diameter (mm) = Bolt size (mm) | NominalLength (mm) = Bolt length (mm) | Washer count | Washer type | Washer name | Nut count | Nut type | Nut name | Slotted hole y (mm) | Slotted hole x (mm) | Bolt hole diameter (mm) | Bolt count | Bolt standard | Bolt Name
11 x Bolt assembly | 20 | 85 | 20 | PLA-HR10.9 | RONDELLE-M20-PLA-HR10.9 | 10 | E-HR10.9 | ECROU-M20-E-HR10.9 | 0 | 0 | 22 | 10 | HR10.9 | M20*85
88 x Bolt assembly | 12 | 40 | 0 | PLA-8.8 | RONDELLE-M12-PLA-8.8 | 2 | E-8.8 | ECROU-M12-E-8.8 | 0 | 0 | 14 | 2 | 8.8 | M12*40
46 x Bolt assembly | 30 | 3 | 0 | PLA-8.8 | RONDELLE-M30-PLA-8.8 | 0 | E-8.8 | ECROU-M30-E-8.8 | 0 | 0 | 33 | 2 | 8.8 | M30*90
10 x Bolt assembly | 12 | 100 | 0 | PLA-6.8 | RONDELLE-M12-PLA-6.8 | 1 | E-6.8 | ECROU-M12-E-6.8 | 0 | 0 | 14 | 1 | HILTI-HSA
2 x Bolt assembly | 12 | 25 | 0 | PLA-8.8 | RONDELLE-M12-PLA-8.8 | 2 | E-8.8 | ECROU-M12-E-8.8 | 0 | 16 | 14 | 2 | 8.8 | M12*25
301 x Bolt assembly | 12 | 25 | 0 | PLA-8.8 | RONDELLE-M12-PLA-8.8 | 1 | E-8.8 | ECROU-M12-E-8.8 | 0 | 0 | 14 | 1 | 8.8 | M12*25
292 x Bolt assembly | 30 | 3 | 0 | PLA-8.8 | RONDELLE-M30-PLA-8.8 | 0 | E-8.8 | ECROU-M30-E-8.8 | 0 | 0 | 33 | 1 | 8.8 | M30*90
2 x Bolt assembly | 12 | 30 | 0 | PLA-8.8 | RONDELLE-M12-PLA-8.8 | 2 | E-8.8 | ECROU-M12-E-8.8 | 16 | 0 | 14 | 2 | 8.8 | M12*30
927 x Bolt assembly | 12 | 30 | 0 | PLA-8.8 | RONDELLE-M12-PLA-8.8 | 2 | E-8.8 | ECROU-M12-E-8.8 | 0 | 0 | 14 | 2 | 8.8 | M12*30
5 x Bolt assembly | 12 | 100 | 0 | PLA-6.8 | RONDELLE-M12-PLA-6.8 | 2 | E-6.8 | ECROU-M12-E-6.8 | 0 | 0 | 14 | 2 | HILTI-HSA
4 x Bolt assembly | 30 | 3 | 0 | PLA-8.8 | RONDELLE-M30-PLA-8.8 | 0 | E-8.8 | ECROU-M30-E-8.8 | 0 | 0 | 33 | 3 | 8.8 | M30*90
14 x Bolt assembly | 12 | 25 | 0 | PLA-8.8 | RONDELLE-M12-PLA-8.8 | 3 | E-8.8 | ECROU-M12-E-8.8 | 0 | 0 | 14 | 3 | 8.8 | M12*25
293 x Bolt assembly | 12 | 30 | 0 | PLA-8.8 | RONDELLE-M12-PLA-8.8 | 1 | E-8.8 | ECROU-M12-E-8.8 | 0 | 0 | 14 | 1 | 8.8 | M12*30
1044 x Bolt assembly | 12 | 25 | 0 | PLA-8.8 | RONDELLE-M12-PLA-8.8 | 2 | E-8.8 | ECROU-M12-E-8.8 | 0 | 0 | 14 | 2 | 8.8 | M12*25
36 x Bolt assembly | 12 | 30 | 0 | PLA-8.8 | RONDELLE-M12-PLA-8.8 | 4 | E-8.8 | ECROU-M12-E-8.8 | 0 | 0 | 14 | 4 | 8.8 | M12*30
2 x Bolt assembly | 20 | 45 | 0 | PLA-8.8 | RONDELLE-M20-PLA-8.8 | 8 | E-8.8 | ECROU-M20-E-8.8 | 0 | 0 | 22 | 8 | 8.8 | M20*45
2 x Bolt assembly | 20 | 9.5 | 0 | PLA-8.8 | RONDELLE-M20-PLA-8.8 | 0 | E-8.8 | ECROU-M20-E-8.8 | 0 | 0 | 22 | 8 | 8.8 | M20*40
315 x Bolt assembly | 12 | 35 | 0 | PLA-8.8 | RONDELLE-M12-PLA-8.8 | 2 | E-8.8 | ECROU-M12-E-8.8 | 0 | 0 | 14 | 2 | 8.8 | M12*35
119 x Bolt assembly | 12 | 40 | 0 | PLA-8.8 | RONDELLE-M12-PLA-8.8 | 1 | E-8.8 | ECROU-M12-E-8.8 | 0 | 0 | 14 | 1 | 8.8 | M12*40
22 x Bolt assembly | 30 | 4 | 0 | PLA-8.8 | RONDELLE-M30-PLA-8.8 | 0 | E-8.8 | ECROU-M30-E-8.8 | 0 | 0 | 33 | 4 | 8.8 | M30*90
13 x Bolt assembly | 12 | 25 | 0 | PLA-8.8 | RONDELLE-M12-PLA-8.8 | 1 | E-8.8 | ECROU-M12-E-8.8 | 0 | 14 | 14 | 1 | 8.8 | M12*25
9 x Bolt assembly | 16 | 35 | 0 | PLA-8.8 | RONDELLE-M16-PLA-8.8 | 1 | E-8.8 | ECROU-M16-E-8.8 | 0 | 0 | 18 | 1 | 8.8 | M16*35
88 x Bolt assembly | 12 | 35 | 0 | PLA-8.8 | RONDELLE-M12-PLA-8.8 | 6 | E-8.8 | ECROU-M12-E-8.8 | 0 | 0 | 14 | 6 | 8.8 | M12*35
47 x Bolt assembly | 16 | 140 | 0 | PLA-6.8 | RONDELLE-M16-PLA-6.8 | 1 | E-6.8 | ECROU-M16-E-6.8 | 0 | 0 | 18 | 1 | HILTI-HSA
17 x Bolt assembly | 16 | 45 | 0 | PLA-8.8 | RONDELLE-M16-PLA-8.8 | 6 | E-8.8 | ECROU-M16-E-8.8 | 0 | 0 | 18 | 6 | 8.8 | M16*45
228 x Bolt assembly | 16 | 40 | 0 | PLA-8.8 | RONDELLE-M16-PLA-8.8 | 2 | E-8.8 | ECROU-M16-E-8.8 | 0 | 0 | 18 | 2 | 8.8 | M16*40
78 x Bolt assembly | 16 | 35 | 0 | PLA-8.8 | RONDELLE-M16-PLA-8.8 | 4 | E-8.8 | ECROU-M16-E-8.8 | 0 | 0 | 18 | 4 | 8.8 | M16*35
7 x Bolt assembly | 20 | 65 | 12 | PLA-HR10.9 | RONDELLE-M20-PLA-HR10.9 | 6 | E-HR10.9 | ECROU-M20-E-HR10.9 | 0 | 0 | 22 | 6 | HR10.9 | M20*65
230 x Bolt assembly | 12 | 35 | 0 | PLA-8.8 | RONDELLE-M12-PLA-8.8 | 4 | E-8.8 | ECROU-M12-E-8.8 | 0 | 0 | 14 | 4 | 8.8 | M12*35
312 x Bolt assembly | 16 | 35 | 0 | PLA-8.8 | RONDELLE-M16-PLA-8.8 | 2 | E-8.8 | ECROU-M16-E-8.8 | 0 | 0 | 18 | 2 | 8.8 | M16*35
10 x Bolt assembly | 16 | 40 | 0 | PLA-8.8 | RONDELLE-M16-PLA-8.8 | 4 | E-8.8 | ECROU-M16-E-8.8 | 0 | 0 | 18 | 4 | 8.8 | M16*40
11 x Bolt assembly | 16 | 50 | 0 | PLA-8.8 | RONDELLE-M16-PLA-8.8 | 2 | E-8.8 | ECROU-M16-E-8.8 | 0 | 0 | 18 | 2 | 8.8 | M16*50
11 x Bolt assembly | 16 | 30 | 0 | PLA-8.8 | RONDELLE-M16-PLA-8.8 | 2 | E-8.8 | ECROU-M16-E-8.8 | 0 | 0 | 18 | 2 | 8.8 | M16*30
243 x Bolt assembly | 16 | 35 | 0 | PLA-8.8 | RONDELLE-M16-PLA-8.8 | 3 | E-8.8 | ECROU-M16-E-8.8 | 0 | 0 | 18 | 3 | 8.8 | M16*35
2 x Bolt assembly | 20 | 55 | 0 | PLA-8.8 | RONDELLE-M20-PLA-8.8 | 3 | E-8.8 | ECROU-M20-E-8.8 | 0 | 0 | 22 | 3 | 8.8 | M20*55
2 x Bolt assembly | 12 | 8 | 0 | PLA-8.8 | RONDELLE-M12-PLA-8.8 | 0 | E-8.8 | ECROU-M12-E-8.8 | 0 | 0 | 14 | 2 | 8.8 | M12*25
Bolt assembly | 20 | 70 | 0 | PLA-8.8 | RONDELLE-M20-PLA-8.8 | 4 | E-8.8 | ECROU-M20-E-8.8 | 0 | 0 | 22 | 4 | 8.8 | M20*70
Bolt assembly | 24 | 60 | 0 | PLA-8.8 | RONDELLE-M24-PLA-8.8 | 3 | E-8.8 | ECROU-M24-E-8.8 | 0 | 0 | 26 | 3 | 8.8 | M24*60
18 x Bolt assembly | 16 | 140 | 0 | PLA-6.8 | RONDELLE-M16-PLA-6.8 | 2 | E-6.8 | ECROU-M16-E-6.8 | 0 | 0 | 18 | 2 | HILTI-HSA
10 x Bolt assembly | 12 | 30 | 0 | PLA-8.8 | RONDELLE-M12-PLA-8.8 | 2 | E-8.8 | ECROU-M12-E-8.8 | 14 | 0 | 14 | 2 | 8.8 | M12*30
12 x Bolt assembly | 12 | 25 | 0 | PLA-8.8 | RONDELLE-M12-PLA-8.8 | 3 | E-8.8 | ECROU-M12-E-8.8 | 14 | 0 | 14 | 3 | 8.8 | M12*25
6 x Bolt assembly | 30 | 6 | 0 | PLA-8.8 | RONDELLE-M30-PLA-8.8 | 0 | E-8.8 | ECROU-M30-E-8.8 | 0 | 0 | 40 | 1 | 8.8 | M30*90
Bolt assembly | 30 | 5.6 | 0 | PLA-8.8 | RONDELLE-M30-PLA-8.8 | 0 | E-8.8 | ECROU-M30-E-8.8 | 0 | 0 | 40 | 1 | 8.8 | M30*90
Bolt assembly | 30 | 8.6 | 0 | PLA-8.8 | RONDELLE-M30-PLA-8.8 | 0 | E-8.8 | ECROU-M30-E-8.8 | 0 | 0 | 40 | 1 | 8.8 | M30*90
5 x Bolt assembly | 30 | 6.1 | 0 | PLA-8.8 | RONDELLE-M30-PLA-8.8 | 0 | E-8.8 | ECROU-M30-E-8.8 | 0 | 0 | 40 | 1 | 8.8 | M30*90
7 x Bolt assembly | 20 | 70 | 12 | PLA-HR10.9 | RONDELLE-M20-PLA-HR10.9 | 6 | E-HR10.9 | ECROU-M20-E-HR10.9 | 0 | 0 | 22 | 6 | HR10.9 | M20*70
Bolt assembly | 16 | 140 | 0 | PLA-6.8 | RONDELLE-M16-PLA-6.8 | 3 | E-6.8 | ECROU-M16-E-6.8 | 0 | 0 | 18 | 3 | HILTI-HSA
11 x Bolt assembly | 30 | 8 | 0 | PLA-8.8 | RONDELLE-M30-PLA-8.8 | 0 | E-8.8 | ECROU-M30-E-8.8 | 0 | 0 | 33 | 1 | 8.8 | M30*90
11 x Bolt assembly | 20 | 10 | 0 | PLA-8.8 | RONDELLE-M20-PLA-8.8 | 0 | E-8.8 | ECROU-M20-E-8.8 | 0 | 0 | 22 | 4 | 8.8 | M20*40
47 x Bolt assembly | 16 | 40 | 0 | PLA-8.8 | RONDELLE-M16-PLA-8.8 | 6 | E-8.8 | ECROU-M16-E-8.8 | 0 | 0 | 18 | 6 | 8.8 | M16*40
11 x Bolt assembly | 16 | 6 | 0 | PLA-8.8 | RONDELLE-M16-PLA-8.8 | 0 | E-8.8 | ECROU-M16-E-8.8 | 0 | 0 | 18 | 4 | 8.8 | M16*25
68 x Bolt assembly | 16 | 45 | 0 | PLA-8.8 | RONDELLE-M16-PLA-8.8 | 2 | E-8.8 | ECROU-M16-E-8.8 | 0 | 0 | 18 | 2 | 8.8 | M16*45
Bolt assembly | 12 | 10 | 0 | PLA-8.8 | RONDELLE-M12-PLA-8.8 | 0 | E-8.8 | ECROU-M12-E-8.8 | 0 | 0 | 14 | 2 | 8.8 | M12*25
2 x Bolt assembly | 20 | 40 | 0 | PLA-8.8 | RONDELLE-M20-PLA-8.8 | 4 | E-8.8 | ECROU-M20-E-8.8 | 0 | 0 | 22 | 4 | 8.8 | M20*40
32 x Bolt assembly | 16 | 35 | 0 | PLA-8.8 | RONDELLE-M16-PLA-8.8 | 6 | E-8.8 | ECROU-M16-E-8.8 | 0 | 0 | 18 | 6 | 8.8 | M16*35
229 x Bolt assembly | 16 | 40 | 0 | PLA-8.8 | RONDELLE-M16-PLA-8.8 | 1 | E-8.8 | ECROU-M16-E-8.8 | 0 | 0 | 18 | 1 | 8.8 | M16*40
548 x Bolt assembly | 12 | 35 | 0 | PLA-8.8 | RONDELLE-M12-PLA-8.8 | 1 | E-8.8 | ECROU-M12-E-8.8 | 0 | 0 | 14 | 1 | 8.8 | M12*35
27 x Bolt assembly | 12 | 35 | 0 | PLA-8.8 | RONDELLE-M12-PLA-8.8 | 8 | E-8.8 | ECROU-M12-E-8.8 | 0 | 0 | 14 | 8 | 8.8 | M12*35
11 x Bolt assembly | 12 | 30 | 0 | PLA-8.8 | RONDELLE-M12-PLA-8.8 | 3 | E-8.8 | ECROU-M12-E-8.8 | 0 | 0 | 14 | 3 | 8.8 | M12*30
3 x Bolt assembly | 16 | 10 | 0 | PLA-8.8 | RONDELLE-M16-PLA-8.8 | 0 | E-8.8 | ECROU-M16-E-8.8 | 0 | 0 | 18 | 2 | 8.8 | M16*25
2 x Bolt assembly | 24 | 20 | 0 | PLA-8.8 | RONDELLE-M24-PLA-8.8 | 0 | E-8.8 | ECROU-M24-E-8.8 | 0 | 0 | 26 | 4 | 8.8 | M24*50
38 x Bolt assembly | 16 | 50 | 0 | PLA-8.8 | RONDELLE-M16-PLA-8.8 | 1 | E-8.8 | ECROU-M16-E-8.8 | 0 | 0 | 18 | 1 | 8.8 | M16*50
41 x Bolt assembly | 16 | 40 | 0 | PLA-8.8 | RONDELLE-M16-PLA-8.8 | 3 | E-8.8 | ECROU-M16-E-8.8 | 0 | 0 | 18 | 3 | 8.8 | M16*40
5 x Bolt assembly | 16 | 190 | 0 | PLA-6.8 | RONDELLE-M16-PLA-6.8 | 4 | E-6.8 | ECROU-M16-E-6.8 | 0 | 0 | 18 | 4 | HILTI-HAS | HILTI_HVU
27 x Bolt assembly | 16 | 190 | 0 | PLA-6.8 | RONDELLE-M16-PLA-6.8 | 2 | E-6.8 | ECROU-M16-E-6.8 | 0 | 0 | 18 | 2 | HILTI-HAS | HILTI_HVU
6 x Bolt assembly | 16 | 45 | 0 | PLA-8.8 | RONDELLE-M16-PLA-8.8 | 3 | E-8.8 | ECROU-M16-E-8.8 | 16 | 0 | 18 | 3 | 8.8 | M16*45
342 x Bolt assembly | 20 | 8 | 0 | PLA-8.8 | RONDELLE-M20-PLA-8.8 | 0 | E-8.8 | ECROU-M20-E-8.8 | 0 | 0 | 22 | 1 | 8.8 | M20*40
171 x Bolt assembly | 16 | 100 | 0 | PLA-8.8 | RONDELLE-M16-PLA-8.8 | 0 | E-8.8 | ECROU-M16-E-8.8 | 0 | 0 | 18 | 1 | 8.8 | M16*100
139 x Bolt assembly | 10 | 5 | 0 | PLA-6.8 | RONDELLE-M10-PLA-6.8 | 0 | E-6.8 | ECROU-M10-E-6.8 | 100 | 100 | 3 | 1 | 6.8 | M10*25
10 x Bolt assembly | 12 | 30 | 0 | PLA-8.8 | RONDELLE-M12-PLA-8.8 | 2 | E-8.8 | ECROU-M12-E-8.8 | 0 | 14 | 14 | 2 | 8.8 | M12*30
171 x Bolt assembly | 12 | 2 | 0 | PLA-8.8 | RONDELLE-M12-PLA-8.8 | 0 | E-8.8 | ECROU-M12-E-8.8 | 0 | 0 | 14 | 4 | 8.8 | M12*25
22 x Bolt assembly | 12 | 40 | 0 | PLA-8.8 | RONDELLE-M12-PLA-8.8 | 4 | E-8.8 | ECROU-M12-E-8.8 | 0 | 0 | 14 | 4 | 8.8 | M12*40
2 x Bolt assembly | 12 | 25 | 0 | PLA-8.8 | RONDELLE-M12-PLA-8.8 | 1 | E-8.8 | ECROU-M12-E-8.8 | 14 | 0 | 14 | 1 | 8.8 | M12*25
24 x Bolt assembly | 30 | 4 | 0 | PLA-8.8 | RONDELLE-M30-PLA-8.8 | 0 | E-8.8 | ECROU-M30-E-8.8 | 0 | 0 | 33 | 2 | 8.8 | M30*90
3 x Bolt assembly | 12 | 3 | 0 | PLA-8.8 | RONDELLE-M12-PLA-8.8 | 0 | E-8.8 | ECROU-M12-E-8.8 | 0 | 0 | 14 | 1 | 8.8 | M12*25
48 x Bolt assembly | 20 | 10 | 0 | PLA-8.8 | RONDELLE-M20-PLA-8.8 | 0 | E-8.8 | ECROU-M20-E-8.8 | 0 | 0 | 22 | 1 | 8.8 | M20*40
12 x Bolt assembly | 12 | 15 | 0 | PLA-8.8 | RONDELLE-M12-PLA-8.8 | 0 | E-8.8 | ECROU-M12-E-8.8 | 0 | 0 | 14 | 4 | 8.8 | M12*25
18 x Bolt assembly | 12 | 25 | 0 | PLA-8.8 | RONDELLE-M12-PLA-8.8 | 6 | E-8.8 | ECROU-M12-E-8.8 | 0 | 0 | 14 | 6 | 8.8 | M12*25
2 x Bolt assembly | 30 | 3 | 0 | PLA-8.8 | RONDELLE-M30-PLA-8.8 | 0 | E-8.8 | ECROU-M30-E-8.8 | 0 | 0 | 33 | 4 | 8.8 | M30*90
2 x Bolt assembly | 12 | 8.5 | 0 | PLA-8.8 | RONDELLE-M12-PLA-8.8 | 0 | E-8.8 | ECROU-M12-E-8.8 | 0 | 0 | 14 | 4 | 8.8 | M12*25
3 x Bolt assembly | 16 | 30 | 0 | PLA-8.8 | RONDELLE-M16-PLA-8.8 | 3 | E-8.8 | ECROU-M16-E-8.8 | 0 | 0 | 18 | 3 | 8.8 | M16*30
8 x Bolt assembly | 16 | 9.8 | 0 | PLA-8.8 | RONDELLE-M16-PLA-8.8 | 0 | E-8.8 | ECROU-M16-E-8.8 | 0 | 0 | 18 | 2 | 8.8 | M16*25
2 x Bolt assembly | 16 | 45 | 0 | PLA-8.8 | RONDELLE-M16-PLA-8.8 | 1 | E-8.8 | ECROU-M16-E-8.8 | 0 | 0 | 18 | 1 | 8.8 | M16*45
21 x Bolt assembly | 16 | 9.2 | 0 | PLA-8.8 | RONDELLE-M16-PLA-8.8 | 0 | E-8.8 | ECROU-M16-E-8.8 | 0 | 0 | 18 | 2 | 8.8 | M16*25
12 x Bolt assembly | 12 | 8.5 | 0 | PLA-8.8 | RONDELLE-M12-PLA-8.8 | 0 | E-8.8 | ECROU-M12-E-8.8 | 0 | 0 | 14 | 1 | 8.8 | M12*25
10 x Bolt assembly | 12 | 30 | 0 | PLA-8.8 | RONDELLE-M12-PLA-8.8 | 4 | E-8.8 | ECROU-M12-E-8.8 | 0 | 38 | 14 | 4 | 8.8 | M12*30
10 x Bolt assembly | 12 | 35 | 0 | PLA-8.8 | RONDELLE-M12-PLA-8.8 | 4 | E-8.8 | ECROU-M12-E-8.8 | 0 | 38 | 14 | 4 | 8.8 | M12*35
17 x Bolt assembly | 20 | 75 | 28 | PLA-HR10.9 | RONDELLE-M20-PLA-HR10.9 | 14 | E-HR10.9 | ECROU-M20-E-HR10.9 | 0 | 0 | 22 | 14 | HR10.9 | M20*75
11 x Bolt assembly | 20 | 100 | 20 | PLA-HR10.9 | RONDELLE-M20-PLA-HR10.9 | 10 | E-HR10.9 | ECROU-M20-E-HR10.9 | 0 | 0 | 22 | 10 | HR10.9 | M20*100
8 x Bolt assembly | 20 | 80 | 20 | PLA-HR10.9 | RONDELLE-M20-PLA-HR10.9 | 10 | E-HR10.9 | ECROU-M20-E-HR10.9 | 0 | 0 | 22 | 10 | HR10.9 | M20*80
Bolt assembly | 20 | 40 | 0 | PLA-8.8 | RONDELLE-M20-PLA-8.8 | 3 | E-8.8 | ECROU-M20-E-8.8 | 0 | 0 | 22 | 3 | 8.8 | M20*40
128 x Bolt assembly | 16 | 50 | 0 | PLA-8.8 | RONDELLE-M16-PLA-8.8 | 3 | E-8.8 | ECROU-M16-E-8.8 | 0 | 0 | 18 | 3 | 8.8 | M16*50
8 x Bolt assembly | 20 | 80 | 12 | PLA-HR10.9 | RONDELLE-M20-PLA-HR10.9 | 6 | E-HR10.9 | ECROU-M20-E-HR10.9 | 0 | 0 | 22 | 6 | HR10.9 | M20*80
6 x Bolt assembly | 20 | 70 | 20 | PLA-HR10.9 | RONDELLE-M20-PLA-HR10.9 | 10 | E-HR10.9 | ECROU-M20-E-HR10.9 | 0 | 0 | 22 | 10 | HR10.9 | M20*70
2 x Bolt assembly | 20 | 65 | 20 | PLA-HR10.9 | RONDELLE-M20-PLA-HR10.9 | 10 | E-HR10.9 | ECROU-M20-E-HR10.9 | 0 | 0 | 22 | 10 | HR10.9 | M20*65
10 x Bolt assembly | 30 | 25 | 0 | PLA-8.8 | RONDELLE-M30-PLA-8.8 | 0 | E-8.8 | ECROU-M30-E-8.8 | 0 | 0 | 33 | 2 | 8.8 | M30*90
33 x Bolt assembly | 24 | 12 | 0 | PLA-8.8 | RONDELLE-M24-PLA-8.8 | 0 | E-8.8 | ECROU-M24-E-8.8 | 0 | 0 | 26 | 2 | 8.8 | M24*50
6 x Bolt assembly | 24 | 12 | 0 | PLA-8.8 | RONDELLE-M24-PLA-8.8 | 0 | E-8.8 | ECROU-M24-E-8.8 | 0 | 0 | 26 | 4 | 8.8 | M24*50
8 x Bolt assembly | 24 | 25 | 0 | PLA-8.8 | RONDELLE-M24-PLA-8.8 | 0 | E-8.8 | ECROU-M24-E-8.8 | 0 | 0 | 26 | 2 | 8.8 | M24*50
6 x Bolt assembly | 30 | 25 | 0 | PLA-8.8 | RONDELLE-M30-PLA-8.8 | 0 | E-8.8 | ECROU-M30-E-8.8 | 0 | 0 | 33 | 4 | 8.8 | M30*90
8 x Bolt assembly | 12 | 35 | 0 | PLA-8.8 | RONDELLE-M12-PLA-8.8 | 3 | E-8.8 | ECROU-M12-E-8.8 | 0 | 0 | 14 | 3 | 8.8 | M12*35
Bolt assembly | 12 | 5 | 0 | PLA-8.8 | RONDELLE-M12-PLA-8.8 | 0 | E-8.8 | ECROU-M12-E-8.8 | 0 | 0 | 14 | 2 | 8.8 | M12*25
5 x Bolt assembly | 16 | 8 | 0 | PLA-8.8 | RONDELLE-M16-PLA-8.8 | 0 | E-8.8 | ECROU-M16-E-8.8 | 0 | 0 | 18 | 2 | 8.8 | M16*25
10 x Bolt assembly | 24 | 55 | 0 | PLA-8.8 | RONDELLE-M24-PLA-8.8 | 2 | E-8.8 | ECROU-M24-E-8.8 | 0 | 0 | 26 | 2 | 8.8 | M24*55
Bolt assembly | 16 | 55 | 0 | PLA-8.8 | RONDELLE-M16-PLA-8.8 | 4 | E-8.8 | ECROU-M16-E-8.8 | 0 | 0 | 18 | 4 | 8.8 | M16*55
4 x Bolt assembly | 16 | 30 | 0 | PLA-8.8 | RONDELLE-M16-PLA-8.8 | 2 | E-8.8 | ECROU-M16-E-8.8 | 0 | 22 | 18 | 2 | 8.8 | M16*30
3 x Bolt assembly | 16 | 50 | 0 | PLA-8.8 | RONDELLE-M16-PLA-8.8 | 4 | E-8.8 | ECROU-M16-E-8.8 | 0 | 0 | 18 | 4 | 8.8 | M16*50
2 x Bolt assembly | 16 | 60 | 0 | PLA-8.8 | RONDELLE-M16-PLA-8.8 | 2 | E-8.8 | ECROU-M16-E-8.8 | 0 | 0 | 18 | 2 | 8.8 | M16*60
4 x Bolt assembly | 16 | 10.2 | 0 | PLA-8.8 | RONDELLE-M16-PLA-8.8 | 0 | E-8.8 | ECROU-M16-E-8.8 | 0 | 0 | 18 | 2 | 8.8 | M16*25
Bolt assembly | 16 | 21.2 | 0 | PLA-8.8 | RONDELLE-M16-PLA-8.8 | 0 | E-8.8 | ECROU-M16-E-8.8 | 0 | 0 | 18 | 2 | 8.8 | M16*25
Bolt assembly | 16 | 30 | 0 | PLA-8.8 | RONDELLE-M16-PLA-8.8 | 4 | E-8.8 | ECROU-M16-E-8.8 | 0 | 0 | 18 | 4 | 8.8 | M16*30
Bolt assembly | 12 | 25 | 0 | PLA-8.8 | RONDELLE-M12-PLA-8.8 | 1 | E-8.8 | ECROU-M12-E-8.8 | 0 | 0 | 15 | 1 | 8.8 | M12*25
2 x Bolt assembly | 16 | 25 | 0 | PLA-8.8 | RONDELLE-M16-PLA-8.8 | 2 | E-8.8 | ECROU-M16-E-8.8 | 0 | 0 | 18 | 2 | 8.8 | M16*25
4 x Bolt assembly | 12 | 35 | 0 | PLA-8.8 | RONDELLE-M12-PLA-8.8 | 2 | E-8.8 | ECROU-M12-E-8.8 | 0 | 18 | 14 | 2 | 8.8 | M12*35
Bolt assembly | 16 | 8 | 0 | PLA-8.8 | RONDELLE-M16-PLA-8.8 | 0 | E-8.8 | ECROU-M16-E-8.8 | 0 | 0 | 18 | 4 | 8.8 | M16*25
7 x Bolt assembly | 16 | 45 | 0 | PLA-8.8 | RONDELLE-M16-PLA-8.8 | 4 | E-8.8 | ECROU-M16-E-8.8 | 0 | 0 | 18 | 4 | 8.8 | M16*45
Bolt assembly | 16 | 35 | 0 | PLA-8.8 | RONDELLE-M16-PLA-8.8 | 2 | E-8.8 | ECROU-M16-E-8.8 | 16 | 0 | 18 | 2 | 8.8 | M16*35
33 x Bolt assembly | 12 | 4 | 0 | PLA-8.8 | RONDELLE-M12-PLA-8.8 | 0 | E-8.8 | ECROU-M12-E-8.8 | 0 | 0 | 14 | 2 | 8.8 | M12*25
4 x Bolt assembly | 20 | 45 | 0 | PLA-8.8 | RONDELLE-M20-PLA-8.8 | 1 | E-8.8 | ECROU-M20-E-8.8 | 0 | 0 | 22 | 1 | 8.8 | M20*45
2 x Bolt assembly | 12 | 30 | 0 | PLA-8.8 | RONDELLE-M12-PLA-8.8 | 10 | E-8.8 | ECROU-M12-E-8.8 | 0 | 0 | 14 | 10 | 8.8 | M12*30
5 x Bolt assembly | 12 | 25 | 0 | PLA-8.8 | RONDELLE-M12-PLA-8.8 | 10 | E-8.8 | ECROU-M12-E-8.8 | 0 | 0 | 14 | 10 | 8.8 | M12*25
2 x Bolt assembly | 12 | 35 | 0 | PLA-8.8 | RONDELLE-M12-PLA-8.8 | 2 | E-8.8 | ECROU-M12-E-8.8 | 0 | 14 | 14 | 2 | 8.8 | M12*35
7 x Bolt assembly | 12 | 45 | 0 | PLA-8.8 | RONDELLE-M12-PLA-8.8 | 3 | E-8.8 | ECROU-M12-E-8.8 | 26 | 0 | 14 | 3 | 8.8 | M12*45
3 x Bolt assembly | 12 | 160 | 0 | PLA-6.8 | RONDELLE-M12-PLA-6.8 | 4 | E-6.8 | ECROU-M12-E-6.8 | 0 | 0 | 14 | 4 | HILTI-HAS | HILTI_HVU
2 x Bolt assembly | 12 | 100 | 0 | PLA-8.8 | RONDELLE-M12-PLA-8.8 | 2 | E-8.8 | ECROU-M12-E-8.8 | 0 | 0 | 14 | 2 | 8.8 | M12*100
8 x Bolt assembly | 12 | 45 | 0 | PLA-8.8 | RONDELLE-M12-PLA-8.8 | 2 | E-8.8 | ECROU-M12-E-8.8 | 0 | 0 | 14 | 2 | 8.8 | M12*45
Bolt assembly | 16 | 10 | 0 | PLA-8.8 | RONDELLE-M16-PLA-8.8 | 0 | E-8.8 | ECROU-M16-E-8.8 | 0 | 0 | 18 | 4 | 8.8 | M16*25
2 x Bolt assembly | 30 | 10 | 0 | PLA-8.8 | RONDELLE-M30-PLA-8.8 | 0 | E-8.8 | ECROU-M30-E-8.8 | 0 | 0 | 33 | 2 | 8.8 | M30*90
Bolt assembly | 16 | 35 | 0 | PLA-8.8 | RONDELLE-M16-PLA-8.8 | 2 | E-8.8 | ECROU-M16-E-8.8 | 0 | 22 | 18 | 2 | 8.8 | M16*35
Bolt assembly | 12 | 35 | 0 | PLA-8.8 | RONDELLE-M12-PLA-8.8 | 1 | E-8.8 | ECROU-M12-E-8.8 | 0 | 16 | 14 | 1 | 8.8 | M12*35
2 x Bolt assembly | 12 | 25 | 0 | PLA-8.8 | RONDELLE-M12-PLA-8.8 | 2 | E-8.8 | ECROU-M12-E-8.8 | 16 | 0 | 14 | 2 | 8.8 | M12*25
2 x Bolt assembly | 12 | 25 | 0 | PLA-8.8 | RONDELLE-M12-PLA-8.8 | 1 | E-8.8 | ECROU-M12-E-8.8 | 0 | 16 | 14 | 1 | 8.8 | M12*25
Bolt assembly | 12 | 25 | 0 | PLA-8.8 | RONDELLE-M12-PLA-8.8 | 1 | E-8.8 | ECROU-M12-E-8.8 | 16 | 0 | 14 | 1 | 8.8 | M12*25

# IfcPlate: PL10*130, PLATINE
In: Undefined
Description: PL10*130; Material: STEEL/E36-3
Tekla Common - Center of gravity Z: 2995 mm; Center of gravity Y: -87.8428 mm; Center of gravity X: 20913.2 mm; Bottom elevation: +2.990; Top elevation: +3.000; Part mark: 198; Assembly mark: P119; Phase: 2; Class: 2001; Finish: GRENAILLE-PEINT; Grade: E36-3; Profile: PL10*130; Name: PLATINE; sets with these values: 2
Tekla Quantity - Net weight: 2.52087 kg; Gross weight: 2.83291 kg; Weight: 2.52087 kg; Net volume: 0.00032113 m3; Gross volume: 0.00032113 m3; Gross footprint area: 0.032113 m2; Area per tons: 28.4579 m2; Net surface area: 0.0717388 m2; Gross area: 0.036088 m2; Height: 130 mm; Width: 10 mm; Length: 277.6 mm; sets with these values: 2

# IfcPlate: PL10*137 (3)
In: Undefined
Description: PL10*137; Material: STEEL/E24-2
Tekla Common - Finish: GRENAILLE-PEINT; Grade: E24-2; Profile: PL10*137; sets with these values: 2
Tekla Quantity - Width: 10 mm; sets with these values: 2
Name | Center of gravity Z (mm) | Center of gravity Y (mm) | Center of gravity X (mm) | Bottom elevation | Top elevation | Part mark | Assembly mark | Phase | Class | Name | Net weight (kg) = Weight (kg) | Gross weight (kg) | Net volume (m3) = Gross volume (m3) | Gross footprint area (m2) | Area per tons (m2) | Net surface area (m2) | Gross area (m2) | Height (mm) | Length (mm)
PLAT | 5741.5 | 49639.4 | 32589 | +5.737 | +5.747 | 189 | H2 | 3 | 3006 | PLAT | 1.44724 | 2.41888 | 0.000184361 | 0.0184361 | 29.8628 | 0.0432186 | 0.0308138 | 136.95 | 225
 | 4989.39 | 12303.9 | 75518.3 | +4.978 | +5.001 | 250 | K45 | 1 | 1010 |  | 3.83608 | 4.78082 | 0.000488672 | 0 | 28.181 | 0.108105 | 0.0609021 | 137.448 | 443.092
PLAT | 5741.5 | 48044.4 | 20786 | +5.737 | +5.747 | 189 | H2 | 2 | 2003 | PLAT | 1.44724 | 2.41888 | 0.000184361 | 0.0184361 | 29.8628 | 0.0432186 | 0.0308138 | 136.95 | 225

# IfcPlate: PL10*140 (8)
In: Undefined
Description: PL10*140; Material: STEEL/S235JR
Tekla Common - Part mark: 174; Phase: 2; Class: 2007; Finish: GALVANISE; Grade: S235JR; Profile: PL10*140; Name: PLAT; sets with these values: 2
Tekla Quantity - Net weight: 1.41696 kg; Gross weight: 1.49895 kg; Weight: 1.41696 kg; Net volume: 0.000180505 m3; Gross volume: 0.000180505 m3; Gross footprint area: 0.000425478 m2; Area per tons: 29.2196 m2; Net surface area: 0.0414032 m2; Gross area: 0.0190949 m2; Height: 140 mm; Width: 10 mm; Length: 136.392 mm; sets with these values: 2
Name | Center of gravity Z (mm) | Center of gravity Y (mm) | Center of gravity X (mm) | Bottom elevation | Top elevation | Assembly mark
PLAT | 7642.2 | 69278 | 27672 | +7.577 | +7.713 | S89
PLAT | 7642.2 | 66797 | 27672 | +7.577 | +7.713 | S90
PLAT | 7282.2 | 69278 | 23684.5 | +7.217 | +7.353 | S91
PLAT | 7282.2 | 66797 | 27562 | +7.217 | +7.353 | S92
PLAT | 7282.2 | 69278 | 27562 | +7.217 | +7.353 | S91
PLAT | 7282.2 | 66797 | 23684.5 | +7.217 | +7.353 | S92
PLAT | 7282.2 | 68029.5 | 19837 | +7.217 | +7.353 | S94
PLAT | 7642.2 | 68029.5 | 32648 | +7.577 | +7.713 | S93

# IfcPlate: PL10*142 (7)
In: Undefined
Description: PL10*142; Material: STEEL/E24-2
Tekla Common - Phase: 2; Class: 2003; Finish: GRENAILLE-PEINT; Grade: E24-2; Profile: PL10*142; Name: PLAT; sets with these values: 2
Tekla Quantity - Gross footprint area: 0 m2; Area per tons: 28.8633 m2; Width: 10 mm; sets with these values: 2
Name | Center of gravity Z (mm) | Center of gravity Y (mm) | Center of gravity X (mm) | Bottom elevation | Top elevation | Part mark | Assembly mark | Net weight (kg) = Weight (kg) | Gross weight (kg) | Net volume (m3) = Gross volume (m3) | Net surface area (m2) | Gross area (m2) | Height (mm) | Length (mm)
PLAT | 3514 | 15190 | 6394.43 | +3.505 | +3.523 | 272 | H85 | 1.78463 | 1.7854 | 0.000227341 | 0.0515101 | 0.022744 | 142.016 | 160.151
PLAT | 3545.28 | 17320 | 5500.81 | +3.537 | +3.554 | 273 | H86 | 1.78462 | 1.78532 | 0.00022734 | 0.05151 | 0.022743 | 142.012 | 160.148
PLAT | 3598.62 | 21981.3 | 3976.86 | +3.590 | +3.607 | 274 | H87 | 1.78462 | 1.78513 | 0.00022734 | 0.0515099 | 0.0227406 | 142.006 | 160.138
PLAT | 3619.5 | 24512.5 | 3380.29 | +3.611 | +3.628 | 275 | H88 | 1.78462 | 1.78502 | 0.00022734 | 0.0515099 | 0.0227392 | 142.004 | 160.131
PLAT | 3635.01 | 27043.7 | 2937.34 | +3.627 | +3.643 | 276 | H89 | 1.78461 | 1.78491 | 0.000227339 | 0.0515098 | 0.0227377 | 142.002 | 160.122
PLAT | 3645.29 | 29575 | 2643.39 | +3.637 | +3.653 | 277 | H90 | 1.78461 | 1.78479 | 0.000227339 | 0.0515098 | 0.0227362 | 142.001 | 160.113
PLAT | 3650.3 | 34912.5 | 2500.51 | +3.642 | +3.658 | 278 | H81 | 1.78461 | 1.78468 | 0.000227339 | 0.0515098 | 0.0227348 | 142 | 160.104

# IfcPlate: PL10*147 (176)
In: Undefined
Description: PL10*147; Material: STEEL/E24-2
Tekla Common - Finish: GRENAILLE-PEINT; Grade: E24-2; Profile: PL10*147; Name: PLATINE; sets with these values: 2
Tekla Quantity - Width: 10 mm; sets with these values: 2
Name | Center of gravity Z (mm) | Center of gravity Y (mm) | Center of gravity X (mm) | Bottom elevation | Top elevation | Part mark | Assembly mark | Phase | Class | Net weight (kg) = Weight (kg) | Gross weight (kg) | Net volume (m3) | Gross volume (m3) | Gross footprint area (m2) | Area per tons (m2) | Net surface area (m2) | Gross area (m2) | Height (mm) | Length (mm)
PLATINE | 4258.28 | 58458.1 | 44122.1 | +4.142 | +4.372 | 186 | N42 | 1 | 1006 | 2.5696 | 2.65318 | 0.000327338 | 0.000327338 | 0.0014695 | 28.9302 | 0.0743392 | 0.0337985 | 146.95 | 230
PLATINE | 4238.09 | 63758.1 | 67473.1 | +4.095 | +4.372 | 287 | N17 | 1 | 1006 | 3.01906 | 3.19618 | 0.000384593 | 0.000384593 | 0.0014695 | 28.6579 | 0.0865197 | 0.0407156 | 146.953 | 277.066
PLATINE | 4238.09 | 63758.1 | 55798.1 | +4.095 | +4.372 | 287 | N38 | 1 | 1006 | 3.01906 | 3.19618 | 0.000384593 | 0.000384593 | 0.0014695 | 28.6579 | 0.0865197 | 0.0407156 | 146.953 | 277.066
PLATINE | 4221.04 | 63758.1 | 44123.1 | +4.062 | +4.372 | 290 | N39 | 1 | 1006 | 3.40262 | 3.57974 | 0.000433454 | 0.000433454 | 0.0014695 | 28.4948 | 0.096957 | 0.0456018 | 146.953 | 310.316
PLATINE | 5633.37 | 27241.9 | 67631.6 | +5.501 | +5.770 | 253 | N11 | 1 | 1006 | 2.70747 | 3.10163 | 0.0003449 | 0.000370783 | 0.00073 | 28.9608 | 0.0784103 | 0.0395113 | 146.95 | 268.876
PLATINE | 5641.71 | -8.05 | 32604.5 | +5.501 | +5.770 | 283 | P113 | 3 | 3001 | 2.91073 | 3.10176 | 0.000370794 | 0.000370794 | 0.00146954 | 28.7176 | 0.0835891 | 0.0395128 | 146.954 | 268.879
PLATINE | 5648.99 | 42841.9 | 32606.1 | +5.540 | +5.770 | 296 | N43 | 3 | 3003 | 2.36643 | 2.65318 | 0.000301456 | 0.000327338 | 0.00073 | 29.2266 | 0.0691627 | 0.0337985 | 146.95 | 230
PLATINE | 5633.37 | 45441.9 | 32606.6 | +5.501 | +5.770 | 241 | N43 | 3 | 3003 | 2.7075 | 3.10169 | 0.000344905 | 0.000370787 | 0.00073 | 28.9607 | 0.0784113 | 0.0395119 | 146.95 | 268.88
PLATINE | 5657.2 | 48058.1 | 32602.9 | +5.540 | +5.770 | 266 | N43 | 3 | 3003 | 2.5696 | 2.65318 | 0.000327338 | 0.000327338 | 0.0014695 | 28.9302 | 0.0743392 | 0.0337985 | 146.95 | 230
PLATINE | 4258.28 | 42858.1 | 44122.1 | +4.142 | +4.372 | 186 | N41 | 1 | 1006 | 2.5696 | 2.65318 | 0.000327338 | 0.000327338 | 0.0014695 | 28.9302 | 0.0743392 | 0.0337985 | 146.95 | 230
PLATINE | 4258.28 | 45458.1 | 44122.1 | +4.142 | +4.372 | 186 | N41 | 1 | 1006 | 2.5696 | 2.65318 | 0.000327338 | 0.000327338 | 0.0014695 | 28.9302 | 0.0743392 | 0.0337985 | 146.95 | 230
PLATINE | 4258.28 | 48058.1 | 44122.1 | +4.142 | +4.372 | 186 | N41 | 1 | 1006 | 2.5696 | 2.65318 | 0.000327338 | 0.000327338 | 0.0014695 | 28.9302 | 0.0743392 | 0.0337985 | 146.95 | 230
PLATINE | 5641.71 | 50658.1 | 44278.7 | +5.501 | +5.770 | 286 | N41 | 1 | 1006 | 2.91065 | 3.10164 | 0.000370783 | 0.000370783 | 0.0014695 | 28.7176 | 0.0835868 | 0.0395114 | 146.95 | 268.876
PLATINE | 5657.2 | 2558.05 | 44277.9 | +5.540 | +5.770 | 187 | N16 | 1 | 1006 | 2.5696 | 2.65318 | 0.000327338 | 0.000327338 | 0.0014695 | 28.9302 | 0.0743392 | 0.0337985 | 146.95 | 230
PLATINE | 5641.71 | 5108.05 | 44278.7 | +5.501 | +5.770 | 286 | N16 | 1 | 1006 | 2.91065 | 3.10164 | 0.000370783 | 0.000370783 | 0.0014695 | 28.7176 | 0.0835868 | 0.0395114 | 146.95 | 268.876
PLATINE | 5648.99 | 58458.1 | 44281.1 | +5.540 | +5.770 | 199 | N42 | 1 | 1006 | 2.36643 | 2.65318 | 0.000301456 | 0.000327338 | 0.00073 | 29.2266 | 0.0691627 | 0.0337985 | 146.95 | 230
PLATINE | 5633.37 | 55858 | 44281.6 | +5.501 | +5.770 | 253 | N42 | 1 | 1006 | 2.7075 | 3.10169 | 0.000344905 | 0.000370787 | 0.00073 | 28.9607 | 0.0784113 | 0.0395119 | 146.95 | 268.88
PLATINE | 5648.99 | 17098 | 44281.1 | +5.540 | +5.770 | 199 | N47 | 1 | 1006 | 2.36643 | 2.65318 | 0.000301456 | 0.000327338 | 0.00073 | 29.2266 | 0.0691627 | 0.0337985 | 146.95 | 230
PLATINE | 5641.71 | 14738 | 44278.7 | +5.501 | +5.770 | 286 | N47 | 1 | 1006 | 2.91065 | 3.10164 | 0.000370783 | 0.000370783 | 0.0014695 | 28.7176 | 0.0835868 | 0.0395114 | 146.95 | 268.876
PLATINE | 5641.71 | 10018 | 44278.7 | +5.501 | +5.770 | 286 | N47 | 1 | 1006 | 2.91065 | 3.10164 | 0.000370783 | 0.000370783 | 0.0014695 | 28.7176 | 0.0835868 | 0.0395114 | 146.95 | 268.876
PLATINE | 5657.2 | 12378 | 44277.9 | +5.540 | +5.770 | 187 | N47 | 1 | 1006 | 2.5696 | 2.65318 | 0.000327338 | 0.000327338 | 0.0014695 | 28.9302 | 0.0743392 | 0.0337985 | 146.95 | 230
PLATINE | 5648.99 | 22042 | 44281.1 | +5.540 | +5.770 | 199 | N10 | 1 | 1006 | 2.36643 | 2.65318 | 0.000301456 | 0.000327338 | 0.00073 | 29.2266 | 0.0691627 | 0.0337985 | 146.95 | 230
PLATINE | 5633.37 | 24641.9 | 44281.6 | +5.501 | +5.770 | 253 | N10 | 1 | 1006 | 2.70747 | 3.10163 | 0.0003449 | 0.000370783 | 0.00073 | 28.9608 | 0.0784103 | 0.0395113 | 146.95 | 268.876
PLATINE | 5657.2 | 27258 | 44277.9 | +5.540 | +5.770 | 187 | N10 | 1 | 1006 | 2.5696 | 2.65318 | 0.000327338 | 0.000327338 | 0.0014695 | 28.9302 | 0.0743392 | 0.0337985 | 146.95 | 230
PLATINE | 5633.37 | 35058 | 44281.6 | +5.501 | +5.770 | 253 | N8 | 1 | 1006 | 2.7075 | 3.10169 | 0.000344905 | 0.000370787 | 0.00073 | 28.9607 | 0.0784113 | 0.0395119 | 146.95 | 268.88
PLATINE | 5648.99 | 37658.1 | 44281.1 | +5.540 | +5.770 | 199 | N8 | 1 | 1006 | 2.36643 | 2.65318 | 0.000301456 | 0.000327338 | 0.00073 | 29.2266 | 0.0691627 | 0.0337985 | 146.95 | 230
PLATINE | 5657.2 | 32458 | 44277.9 | +5.540 | +5.770 | 187 | N8 | 1 | 1006 | 2.5696 | 2.65318 | 0.000327338 | 0.000327338 | 0.0014695 | 28.9302 | 0.0743392 | 0.0337985 | 146.95 | 230
PLATINE | 5641.71 | 29858 | 44278.7 | +5.501 | +5.770 | 286 | N8 | 1 | 1006 | 2.91065 | 3.10164 | 0.000370783 | 0.000370783 | 0.0014695 | 28.7176 | 0.0835868 | 0.0395114 | 146.95 | 268.876
PLATINE | 5657.2 | 48038.1 | 20927.9 | +5.540 | +5.770 | 187 | N46 | 2 | 2006 | 2.5696 | 2.65318 | 0.000327338 | 0.000327338 | 0.0014695 | 28.9302 | 0.0743392 | 0.0337985 | 146.95 | 230
PLATINE | 4258.28 | 42858.1 | 32447.1 | +4.142 | +4.372 | 265 | N43 | 3 | 3003 | 2.5696 | 2.65318 | 0.000327338 | 0.000327338 | 0.0014695 | 28.9302 | 0.0743392 | 0.0337985 | 146.95 | 230
PLATINE | 4258.28 | 17098 | 44122.1 | +4.142 | +4.372 | 186 | N47 | 1 | 1006 | 2.5696 | 2.65318 | 0.000327338 | 0.000327338 | 0.0014695 | 28.9302 | 0.0743392 | 0.0337985 | 146.95 | 230
PLATINE | 4258.28 | 45458.1 | 32447.1 | +4.142 | +4.372 | 265 | N43 | 3 | 3003 | 2.5696 | 2.65318 | 0.000327338 | 0.000327338 | 0.0014695 | 28.9302 | 0.0743392 | 0.0337985 | 146.95 | 230
PLATINE | 4258.28 | 12378 | 44122.1 | +4.142 | +4.372 | 186 | N47 | 1 | 1006 | 2.5696 | 2.65318 | 0.000327338 | 0.000327338 | 0.0014695 | 28.9302 | 0.0743392 | 0.0337985 | 146.95 | 230
PLATINE | 4258.28 | 14738 | 44122.1 | +4.142 | +4.372 | 186 | N47 | 1 | 1006 | 2.5696 | 2.65318 | 0.000327338 | 0.000327338 | 0.0014695 | 28.9302 | 0.0743392 | 0.0337985 | 146.95 | 230
PLATINE | 5641.71 | 5108.05 | 20928.7 | +5.501 | +5.770 | 283 | N18 | 2 | 2006 | 2.91065 | 3.10164 | 0.000370783 | 0.000370783 | 0.0014695 | 28.7176 | 0.0835868 | 0.0395114 | 146.95 | 268.876
PLATINE | 5657.2 | 2558.05 | 20927.9 | +5.540 | +5.770 | 187 | N18 | 2 | 2006 | 2.5696 | 2.65318 | 0.000327338 | 0.000327338 | 0.0014695 | 28.9302 | 0.0743392 | 0.0337985 | 146.95 | 230
PLATINE | 4258.28 | 2558.05 | 32447.1 | +4.142 | +4.372 | 186 | N15 | 3 | 3006 | 2.5696 | 2.65318 | 0.000327338 | 0.000327338 | 0.0014695 | 28.9302 | 0.0743392 | 0.0337985 | 146.95 | 230
PLATINE | 4238.09 | 5108.05 | 32448.1 | +4.095 | +4.372 | 287 | N15 | 3 | 3006 | 3.01906 | 3.19618 | 0.000384593 | 0.000384593 | 0.0014695 | 28.6579 | 0.0865197 | 0.0407156 | 146.953 | 277.066
PLATINE | 5657.2 | 12378 | 20927.9 | +5.540 | +5.770 | 187 | N49 | 2 | 2006 | 2.5696 | 2.65318 | 0.000327338 | 0.000327338 | 0.0014695 | 28.9302 | 0.0743392 | 0.0337985 | 146.95 | 230
PLATINE | 5641.71 | 14738 | 20928.7 | +5.501 | +5.770 | 283 | N49 | 2 | 2006 | 2.91065 | 3.10164 | 0.000370783 | 0.000370783 | 0.0014695 | 28.7176 | 0.0835868 | 0.0395114 | 146.95 | 268.876
PLATINE | 5648.99 | 17098 | 20931.1 | +5.540 | +5.770 | 199 | N49 | 2 | 2006 | 2.36643 | 2.65318 | 0.000301456 | 0.000327338 | 0.00073 | 29.2266 | 0.0691627 | 0.0337985 | 146.95 | 230
PLATINE | 5657.2 | 27258 | 20927.9 | +5.540 | +5.770 | 187 | N45 | 2 | 2006 | 2.5696 | 2.65318 | 0.000327338 | 0.000327338 | 0.0014695 | 28.9302 | 0.0743392 | 0.0337985 | 146.95 | 230
PLATINE | 5641.71 | 29858 | 20928.7 | +5.501 | +5.770 | 283 | N44 | 2 | 2006 | 2.91065 | 3.10164 | 0.000370783 | 0.000370783 | 0.0014695 | 28.7176 | 0.0835868 | 0.0395114 | 146.95 | 268.876
PLATINE | 5657.2 | 32458 | 20927.9 | +5.540 | +5.770 | 187 | N44 | 2 | 2006 | 2.5696 | 2.65318 | 0.000327338 | 0.000327338 | 0.0014695 | 28.9302 | 0.0743392 | 0.0337985 | 146.95 | 230
PLATINE | 5633.37 | 35058 | 20931.6 | +5.501 | +5.770 | 241 | N44 | 2 | 2006 | 2.7075 | 3.10169 | 0.000344905 | 0.000370787 | 0.00073 | 28.9607 | 0.0784113 | 0.0395119 | 146.95 | 268.88
PLATINE | 5648.99 | 37658.1 | 20931.1 | +5.540 | +5.770 | 199 | N44 | 2 | 2006 | 2.36643 | 2.65318 | 0.000301456 | 0.000327338 | 0.00073 | 29.2266 | 0.0691627 | 0.0337985 | 146.95 | 230
PLATINE | 5648.99 | 22042 | 20931.1 | +5.540 | +5.770 | 199 | N45 | 2 | 2006 | 2.36643 | 2.65318 | 0.000301456 | 0.000327338 | 0.00073 | 29.2266 | 0.0691627 | 0.0337985 | 146.95 | 230
PLATINE | 5633.37 | 24641.9 | 20931.6 | +5.501 | +5.770 | 241 | N45 | 2 | 2006 | 2.70747 | 3.10163 | 0.0003449 | 0.000370783 | 0.00073 | 28.9608 | 0.0784103 | 0.0395113 | 146.95 | 268.876
PLATINE | 4258.28 | 2558.05 | 67472.1 | +4.142 | +4.372 | 186 | N14 | 1 | 1006 | 2.5696 | 2.65318 | 0.000327338 | 0.000327338 | 0.0014695 | 28.9302 | 0.0743392 | 0.0337985 | 146.95 | 230
PLATINE | 4238.09 | 5108.05 | 67473.1 | +4.095 | +4.372 | 287 | N14 | 1 | 1006 | 3.01906 | 3.19618 | 0.000384593 | 0.000384593 | 0.0014695 | 28.6579 | 0.0865197 | 0.0407156 | 146.953 | 277.066
PLATINE | 4258.28 | 10018 | 67472.1 | +4.142 | +4.372 | 186 | N12 | 1 | 1006 | 2.5696 | 2.65318 | 0.000327338 | 0.000327338 | 0.0014695 | 28.9302 | 0.0743392 | 0.0337985 | 146.95 | 230
PLATINE | 4258.28 | 12378 | 67472.1 | +4.142 | +4.372 | 186 | N12 | 1 | 1006 | 2.5696 | 2.65318 | 0.000327338 | 0.000327338 | 0.0014695 | 28.9302 | 0.0743392 | 0.0337985 | 146.95 | 230
PLATINE | 4258.28 | 14738 | 67472.1 | +4.142 | +4.372 | 186 | N12 | 1 | 1006 | 2.5696 | 2.65318 | 0.000327338 | 0.000327338 | 0.0014695 | 28.9302 | 0.0743392 | 0.0337985 | 146.95 | 230
PLATINE | 4258.28 | 17098 | 67472.1 | +4.142 | +4.372 | 186 | N12 | 1 | 1006 | 2.5696 | 2.65318 | 0.000327338 | 0.000327338 | 0.0014695 | 28.9302 | 0.0743392 | 0.0337985 | 146.95 | 230
PLATINE | 4258.28 | 22058 | 67472.1 | +4.142 | +4.372 | 186 | N11 | 1 | 1006 | 2.5696 | 2.65318 | 0.000327338 | 0.000327338 | 0.0014695 | 28.9302 | 0.0743392 | 0.0337985 | 146.95 | 230
PLATINE | 4258.28 | 24658 | 67472.1 | +4.142 | +4.372 | 186 | N11 | 1 | 1006 | 2.5696 | 2.65318 | 0.000327338 | 0.000327338 | 0.0014695 | 28.9302 | 0.0743392 | 0.0337985 | 146.95 | 230
PLATINE | 5648.99 | 22042 | 67631.1 | +5.540 | +5.770 | 199 | N11 | 1 | 1006 | 2.36643 | 2.65318 | 0.000301456 | 0.000327338 | 0.00073 | 29.2266 | 0.0691627 | 0.0337985 | 146.95 | 230
PLATINE | 4258.28 | 27258 | 67472.1 | +4.142 | +4.372 | 186 | N11 | 1 | 1006 | 2.5696 | 2.65318 | 0.000327338 | 0.000327338 | 0.0014695 | 28.9302 | 0.0743392 | 0.0337985 | 146.95 | 230
PLATINE | 4258.28 | 29858 | 67472.1 | +4.142 | +4.372 | 186 | N7 | 1 | 1006 | 2.5696 | 2.65318 | 0.000327338 | 0.000327338 | 0.0014695 | 28.9302 | 0.0743392 | 0.0337985 | 146.95 | 230
PLATINE | 5657.2 | 66458.1 | 67627.9 | +5.540 | +5.770 | 187 | N17 | 1 | 1006 | 2.5696 | 2.65318 | 0.000327338 | 0.000327338 | 0.0014695 | 28.9302 | 0.0743392 | 0.0337985 | 146.95 | 230
PLATINE | 4258.28 | 32458 | 67472.1 | +4.142 | +4.372 | 186 | N7 | 1 | 1006 | 2.5696 | 2.65318 | 0.000327338 | 0.000327338 | 0.0014695 | 28.9302 | 0.0743392 | 0.0337985 | 146.95 | 230
PLATINE | 5648.99 | 58458.1 | 67631.1 | +5.540 | +5.770 | 199 | N13 | 1 | 1006 | 2.36643 | 2.65318 | 0.000301456 | 0.000327338 | 0.00073 | 29.2266 | 0.0691627 | 0.0337985 | 146.95 | 230
PLATINE | 5641.71 | 63758.1 | 67628.7 | +5.501 | +5.770 | 286 | N17 | 1 | 1006 | 2.91068 | 3.10169 | 0.000370787 | 0.000370787 | 0.0014695 | 28.7176 | 0.0835878 | 0.0395119 | 146.95 | 268.88
PLATINE | 4258.28 | 35058.1 | 67472.1 | +4.142 | +4.372 | 186 | N7 | 1 | 1006 | 2.5696 | 2.65318 | 0.000327338 | 0.000327338 | 0.0014695 | 28.9302 | 0.0743392 | 0.0337985 | 146.95 | 230
PLATINE | 5633.37 | 55858 | 67631.6 | +5.501 | +5.770 | 253 | N13 | 1 | 1006 | 2.7075 | 3.10169 | 0.000344905 | 0.000370787 | 0.00073 | 28.9607 | 0.0784113 | 0.0395119 | 146.95 | 268.88
PLATINE | 4258.28 | 37658.1 | 67472.1 | +4.142 | +4.372 | 186 | N7 | 1 | 1006 | 2.5696 | 2.65318 | 0.000327338 | 0.000327338 | 0.0014695 | 28.9302 | 0.0743392 | 0.0337985 | 146.95 | 230
PLATINE | 4258.28 | 42858.1 | 67472.1 | +4.142 | +4.372 | 186 | N6 | 1 | 1006 | 2.5696 | 2.65318 | 0.000327338 | 0.000327338 | 0.0014695 | 28.9302 | 0.0743392 | 0.0337985 | 146.95 | 230
PLATINE | 5657.2 | 48058.1 | 67627.9 | +5.540 | +5.770 | 187 | N6 | 1 | 1006 | 2.5696 | 2.65318 | 0.000327338 | 0.000327338 | 0.0014695 | 28.9302 | 0.0743392 | 0.0337985 | 146.95 | 230
PLATINE | 5641.71 | 50658.1 | 67628.7 | +5.501 | +5.770 | 286 | N6 | 1 | 1006 | 2.91065 | 3.10164 | 0.000370783 | 0.000370783 | 0.0014695 | 28.7176 | 0.0835868 | 0.0395114 | 146.95 | 268.876
PLATINE | 4258.28 | 45458.1 | 67472.1 | +4.142 | +4.372 | 186 | N6 | 1 | 1006 | 2.5696 | 2.65318 | 0.000327338 | 0.000327338 | 0.0014695 | 28.9302 | 0.0743392 | 0.0337985 | 146.95 | 230
PLATINE | 5633.37 | 45441.9 | 67631.6 | +5.501 | +5.770 | 253 | N6 | 1 | 1006 | 2.7075 | 3.10169 | 0.000344905 | 0.000370787 | 0.00073 | 28.9607 | 0.0784113 | 0.0395119 | 146.95 | 268.88
PLATINE | 4258.28 | 48058.1 | 67472.1 | +4.142 | +4.372 | 186 | N6 | 1 | 1006 | 2.5696 | 2.65318 | 0.000327338 | 0.000327338 | 0.0014695 | 28.9302 | 0.0743392 | 0.0337985 | 146.95 | 230
PLATINE | 4258.28 | 50658.1 | 67472.1 | +4.142 | +4.372 | 186 | N6 | 1 | 1006 | 2.5696 | 2.65318 | 0.000327338 | 0.000327338 | 0.0014695 | 28.9302 | 0.0743392 | 0.0337985 | 146.95 | 230
PLATINE | 5648.99 | 42841.9 | 67631.1 | +5.540 | +5.770 | 199 | N6 | 1 | 1006 | 2.36643 | 2.65318 | 0.000301456 | 0.000327338 | 0.00073 | 29.2266 | 0.0691627 | 0.0337985 | 146.95 | 230
PLATINE | 4258.28 | 53258.1 | 67472.1 | +4.142 | +4.372 | 186 | N13 | 1 | 1006 | 2.5696 | 2.65318 | 0.000327338 | 0.000327338 | 0.0014695 | 28.9302 | 0.0743392 | 0.0337985 | 146.95 | 230
PLATINE | 5633.37 | 24641.9 | 67631.6 | +5.501 | +5.770 | 253 | N11 | 1 | 1006 | 2.70747 | 3.10163 | 0.0003449 | 0.000370783 | 0.00073 | 28.9608 | 0.0784103 | 0.0395113 | 146.95 | 268.876
PLATINE | 4258.28 | 55858.1 | 67472.1 | +4.142 | +4.372 | 186 | N13 | 1 | 1006 | 2.5696 | 2.65318 | 0.000327338 | 0.000327338 | 0.0014695 | 28.9302 | 0.0743392 | 0.0337985 | 146.95 | 230
PLATINE | 5648.99 | 37658.1 | 67631.1 | +5.540 | +5.770 | 199 | N7 | 1 | 1006 | 2.36643 | 2.65318 | 0.000301456 | 0.000327338 | 0.00073 | 29.2266 | 0.0691627 | 0.0337985 | 146.95 | 230
PLATINE | 4258.28 | 58458.1 | 67472.1 | +4.142 | +4.372 | 186 | N13 | 1 | 1006 | 2.5696 | 2.65318 | 0.000327338 | 0.000327338 | 0.0014695 | 28.9302 | 0.0743392 | 0.0337985 | 146.95 | 230
PLATINE | 5633.37 | 35058 | 67631.6 | +5.501 | +5.770 | 253 | N7 | 1 | 1006 | 2.7075 | 3.10169 | 0.000344905 | 0.000370787 | 0.00073 | 28.9607 | 0.0784113 | 0.0395119 | 146.95 | 268.88
PLATINE | 4258.28 | 66458.1 | 67472.1 | +4.142 | +4.372 | 186 | N17 | 1 | 1006 | 2.5696 | 2.65318 | 0.000327338 | 0.000327338 | 0.0014695 | 28.9302 | 0.0743392 | 0.0337985 | 146.95 | 230
PLATINE | 5657.2 | 53258.1 | 67627.9 | +5.540 | +5.770 | 187 | N13 | 1 | 1006 | 2.5696 | 2.65318 | 0.000327338 | 0.000327338 | 0.0014695 | 28.9302 | 0.0743392 | 0.0337985 | 146.95 | 230
PLATINE | 5657.2 | 2558.05 | 55952.9 | +5.540 | +5.770 | 187 | N16 | 1 | 1006 | 2.5696 | 2.65318 | 0.000327338 | 0.000327338 | 0.0014695 | 28.9302 | 0.0743392 | 0.0337985 | 146.95 | 230
