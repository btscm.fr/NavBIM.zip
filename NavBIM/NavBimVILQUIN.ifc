Properties of the parts of a building model (IFC2X3), part 21 of 32

# IfcColumn: TUBE-C-100*100*3 (183)
Name | Center of gravity Z (mm) | Center of gravity Y (mm) | Center of gravity X (mm) | Bottom elevation | Top elevation | Part mark | Assembly mark | Phase | Class | Net weight (kg) = NetWeight (kg) | Gross weight (kg) = Weight (kg) | Net volume (m3) = NetVolume (m3) | Gross volume (m3) | Net surface area (m2) | Gross area (m2) = OuterSurfaceArea (m2) | Tekla Quantity, Length (mm) = BaseQuantities, Length (mm)
POTEAU | 4198.09 | 19450 | 395.17 | +4.034 | +4.360 | 946 | P96 | 2 | 2007 | 2.95878 | 2.93644 | 0.000376915 | 0.000374068 | 0.130724 | 0.126643 | 325.56
POTEAU | 4104.89 | 19450 | 5691.78 | +3.849 | +4.359 | 947 | P66 | 2 | 2007 | 4.6437 | 4.59965 | 0.000591554 | 0.000585942 | 0.204484 | 0.198374 | 509.958
POTEAU | 4058.55 | 19450 | 8340.09 | +3.756 | +4.359 | 948 | P67 | 2 | 2007 | 5.49067 | 5.4357 | 0.000699448 | 0.000692446 | 0.24156 | 0.234431 | 602.651
POTEAU | 4198.09 | 17320 | 395.17 | +4.034 | +4.360 | 946 | P96 | 2 | 2007 | 2.95878 | 2.93644 | 0.000376915 | 0.000374068 | 0.130724 | 0.126643 | 325.56
POTEAU | 4104.89 | 17320 | 5691.78 | +3.849 | +4.359 | 947 | P66 | 2 | 2007 | 4.6437 | 4.59965 | 0.000591554 | 0.000585942 | 0.204484 | 0.198374 | 509.958
POTEAU | 4058.55 | 17320 | 8340.09 | +3.756 | +4.359 | 948 | P67 | 2 | 2007 | 5.49067 | 5.4357 | 0.000699448 | 0.000692446 | 0.24156 | 0.234431 | 602.651
POTEAU | 4198.09 | 15190 | 395.17 | +4.034 | +4.360 | 946 | P96 | 2 | 2007 | 2.95878 | 2.93644 | 0.000376915 | 0.000374068 | 0.130724 | 0.126643 | 325.56
POTEAU | 4104.89 | 15190 | 5691.78 | +3.849 | +4.359 | 947 | P66 | 2 | 2007 | 4.6437 | 4.59965 | 0.000591554 | 0.000585942 | 0.204484 | 0.198374 | 509.958
POTEAU | 4058.55 | 15190 | 8340.09 | +3.756 | +4.359 | 948 | P67 | 2 | 2007 | 5.49067 | 5.4357 | 0.000699448 | 0.000692446 | 0.24156 | 0.234431 | 602.651
POTEAU | 4104.89 | 13060 | 5691.78 | +3.849 | +4.359 | 947 | P66 | 2 | 2007 | 4.6437 | 4.59965 | 0.000591554 | 0.000585942 | 0.204484 | 0.198374 | 509.958
POTEAU | 4054.89 | 10930 | 5691.8 | +3.849 | +4.259 | 944 | P78 | 2 | 2007 | 3.72996 | 3.69768 | 0.000475154 | 0.000471042 | 0.164484 | 0.159474 | 409.958
POTEAU | 3828.11 | 13060 | 10404.9 | +3.396 | +4.259 | 932 | P76 | 2 | 2007 | 7.87447 | 7.78698 | 0.00100312 | 0.000991972 | 0.345914 | 0.335837 | 863.335
POTEAU | 4198.09 | 13060 | 395.17 | +4.034 | +4.360 | 946 | P96 | 2 | 2007 | 2.95878 | 2.93644 | 0.000376915 | 0.000374068 | 0.130724 | 0.126643 | 325.56
POTEAU | 4144.76 | 48525 | 585.238 | +4.028 | +4.260 | 933 | P94 | 2 | 2007 | 2.10582 | 2.09447 | 0.000268257 | 0.000266812 | 0.0933851 | 0.0903305 | 232.212
POTEAU | 4144.76 | 10930 | 585.238 | +4.028 | +4.260 | 933 | P94 | 2 | 2007 | 2.10582 | 2.09447 | 0.000268257 | 0.000266812 | 0.0933851 | 0.0903305 | 232.212
POTEAU | 4008.55 | 10930 | 8340.11 | +3.756 | +4.259 | 945 | P79 | 2 | 2007 | 4.57693 | 4.53373 | 0.000583048 | 0.000577546 | 0.20156 | 0.195531 | 502.651
POTEAU | 4058.55 | 13060 | 8340.09 | +3.756 | +4.359 | 948 | P67 | 2 | 2007 | 5.49067 | 5.4357 | 0.000699448 | 0.000692446 | 0.24156 | 0.234431 | 602.651
POTEAU | 4158.08 | 18227 | 77004.1 | +3.850 | +4.465 | 951 | P56 | 1 | 1008 | 5.60892 | 5.55066 | 0.000714512 | 0.00070709 | 0.246737 | 0.239389 | 615.396
POTEAU | 4143.49 | 18227 | 77945.1 | +3.820 | +4.465 | 952 | P57 | 1 | 1008 | 5.87552 | 5.81377 | 0.000748473 | 0.000740607 | 0.258408 | 0.250737 | 644.567
POTEAU | 4207.27 | 20847 | 73830.1 | +3.948 | +4.465 | 949 | P54 | 1 | 1008 | 4.70996 | 4.66324 | 0.000599995 | 0.000594044 | 0.207384 | 0.201117 | 517.009
POTEAU | 5582.27 | 32660 | 70902.6 | +5.414 | +5.745 | 964 | P103 | 1 | 1008 | 2.97324 | 2.98998 | 0.000378757 | 0.000380889 | 0.131362 | 0.128952 | 331.496
POTEAU | 5684.48 | 31395 | 72658.8 | +5.523 | +5.845 | 965 | P104 | 1 | 1008 | 2.93338 | 2.9046 | 0.000373679 | 0.000370013 | 0.129612 | 0.12527 | 322.03
POTEAU | 5684.48 | 26895 | 72658.8 | +5.523 | +5.845 | 965 | P104 | 1 | 1008 | 2.93338 | 2.9046 | 0.000373679 | 0.000370013 | 0.129612 | 0.12527 | 322.03
POTEAU | 5684.48 | 30545 | 72658.8 | +5.523 | +5.845 | 965 | P97 | 1 | 1008 | 2.93338 | 2.9046 | 0.000373679 | 0.000370013 | 0.129612 | 0.12527 | 322.03
POTEAU | 5684.48 | 27745 | 72658.8 | +5.523 | +5.845 | 965 | P97 | 1 | 1008 | 2.93338 | 2.9046 | 0.000373679 | 0.000370013 | 0.129612 | 0.12527 | 322.03
POTEAU | 5631.78 | 24650 | 70902.5 | +5.414 | +5.844 | 963 | P74 | 1 | 1008 | 3.87785 | 3.88293 | 0.000493993 | 0.00049464 | 0.170962 | 0.167463 | 430.496
POTEAU | 5588.59 | 18660 | 68125.2 | +5.431 | +5.745 | 958 | P102 | 1 | 1008 | 2.85834 | 2.83549 | 0.00036412 | 0.000361209 | 0.126328 | 0.122289 | 314.368
POTEAU | 5549.72 | 18660 | 70600.1 | +5.354 | +5.744 | 959 | P87 | 1 | 1008 | 3.55032 | 3.51855 | 0.00045227 | 0.000448223 | 0.15662 | 0.151748 | 390.098
POTEAU | 5582.27 | 19950 | 70902.6 | +5.414 | +5.745 | 964 | P103 | 1 | 1008 | 2.97324 | 2.98998 | 0.000378757 | 0.000380889 | 0.131362 | 0.128952 | 331.496
POTEAU | 5599.72 | 17090 | 70600.1 | +5.354 | +5.844 | 956 | P71 | 1 | 1008 | 4.46406 | 4.42052 | 0.00056867 | 0.000563123 | 0.19662 | 0.190648 | 490.098
POTEAU | 5638.09 | 17090 | 68125.1 | +5.431 | +5.844 | 957 | P73 | 1 | 1008 | 3.76295 | 3.72844 | 0.000479356 | 0.00047496 | 0.165928 | 0.1608 | 413.368
POTEAU | 5599.72 | 14730 | 70600.1 | +5.354 | +5.844 | 956 | P71 | 1 | 1008 | 4.46406 | 4.42052 | 0.00056867 | 0.000563123 | 0.19662 | 0.190648 | 490.098
POTEAU | 5484.64 | 10010 | 78025.1 | +5.124 | +5.844 | 953 | P68 | 1 | 1008 | 6.56722 | 6.49657 | 0.000836588 | 0.000827588 | 0.288688 | 0.280184 | 720.268
POTEAU | 5523 | 10010 | 75550.1 | +5.200 | +5.844 | 954 | P69 | 1 | 1008 | 5.86619 | 5.80458 | 0.000747286 | 0.000739437 | 0.258 | 0.25034 | 643.548
POTEAU | 5561.36 | 10010 | 73075.1 | +5.277 | +5.844 | 955 | P70 | 1 | 1008 | 5.16508 | 5.1125 | 0.000657972 | 0.000651274 | 0.227308 | 0.220492 | 566.818
POTEAU | 5599.72 | 10010 | 70600.1 | +5.354 | +5.844 | 956 | P71 | 1 | 1008 | 4.46406 | 4.42052 | 0.00056867 | 0.000563123 | 0.19662 | 0.190648 | 490.098
POTEAU | 5638.09 | 10010 | 68125.1 | +5.431 | +5.844 | 957 | P73 | 1 | 1008 | 3.76295 | 3.72844 | 0.000479356 | 0.00047496 | 0.165928 | 0.1608 | 413.368
POTEAU | 5638.09 | 7650 | 68125.1 | +5.431 | +5.844 | 957 | P73 | 1 | 1008 | 3.76295 | 3.72844 | 0.000479356 | 0.00047496 | 0.165928 | 0.1608 | 413.368
POTEAU | 5599.72 | 7650 | 70600.1 | +5.354 | +5.844 | 956 | P71 | 1 | 1008 | 4.46406 | 4.42052 | 0.00056867 | 0.000563123 | 0.19662 | 0.190648 | 490.098
POTEAU | 5561.36 | 7650 | 73075.1 | +5.277 | +5.844 | 955 | P70 | 1 | 1008 | 5.16508 | 5.1125 | 0.000657972 | 0.000651274 | 0.227308 | 0.220492 | 566.818
POTEAU | 5484.64 | 7650 | 78025.1 | +5.124 | +5.844 | 953 | P68 | 1 | 1008 | 6.56722 | 6.49657 | 0.000836588 | 0.000827588 | 0.288688 | 0.280184 | 720.268
POTEAU | 5638.09 | 12370 | 68125.1 | +5.431 | +5.844 | 957 | P73 | 1 | 1008 | 3.76295 | 3.72844 | 0.000479356 | 0.00047496 | 0.165928 | 0.1608 | 413.368
POTEAU | 5484.64 | 2550 | 78025.1 | +5.124 | +5.844 | 953 | P68 | 1 | 1008 | 6.56722 | 6.49657 | 0.000836588 | 0.000827588 | 0.288688 | 0.280184 | 720.268
POTEAU | 5523 | 2550 | 75550.1 | +5.200 | +5.844 | 954 | P69 | 1 | 1008 | 5.86619 | 5.80458 | 0.000747286 | 0.000739437 | 0.258 | 0.25034 | 643.548
POTEAU | 5561.36 | 2550 | 73075.1 | +5.277 | +5.844 | 955 | P70 | 1 | 1008 | 5.16508 | 5.1125 | 0.000657972 | 0.000651274 | 0.227308 | 0.220492 | 566.818
POTEAU | 5599.72 | 2550 | 70600.1 | +5.354 | +5.844 | 956 | P71 | 1 | 1008 | 4.46406 | 4.42052 | 0.00056867 | 0.000563123 | 0.19662 | 0.190648 | 490.098
POTEAU | 5638.09 | 2550 | 68125.1 | +5.431 | +5.844 | 957 | P73 | 1 | 1008 | 3.76295 | 3.72844 | 0.000479356 | 0.00047496 | 0.165928 | 0.1608 | 413.368
POTEAU | 5484.64 | 5100 | 78025.1 | +5.124 | +5.844 | 953 | P68 | 1 | 1008 | 6.56722 | 6.49657 | 0.000836588 | 0.000827588 | 0.288688 | 0.280184 | 720.268
POTEAU | 5523 | 5100 | 75550.1 | +5.200 | +5.844 | 954 | P69 | 1 | 1008 | 5.86619 | 5.80458 | 0.000747286 | 0.000739437 | 0.258 | 0.25034 | 643.548
POTEAU | 5561.36 | 5100 | 73075.1 | +5.277 | +5.844 | 955 | P70 | 1 | 1008 | 5.16508 | 5.1125 | 0.000657972 | 0.000651274 | 0.227308 | 0.220492 | 566.818
POTEAU | 5599.72 | 5100 | 70600.1 | +5.354 | +5.844 | 956 | P71 | 1 | 1008 | 4.46406 | 4.42052 | 0.00056867 | 0.000563123 | 0.19662 | 0.190648 | 490.098
POTEAU | 5638.09 | 5100 | 68125.1 | +5.431 | +5.844 | 957 | P73 | 1 | 1008 | 3.76295 | 3.72844 | 0.000479356 | 0.00047496 | 0.165928 | 0.1608 | 413.368
POTEAU | 5523 | 7650 | 75550.1 | +5.200 | +5.844 | 954 | P69 | 1 | 1008 | 5.86619 | 5.80458 | 0.000747286 | 0.000739437 | 0.258 | 0.25034 | 643.548
POTEAU | 5599.72 | 12370 | 70600.1 | +5.354 | +5.844 | 956 | P71 | 1 | 1008 | 4.46406 | 4.42052 | 0.00056867 | 0.000563123 | 0.19662 | 0.190648 | 490.098
POTEAU | 5473 | 12370 | 75550.1 | +5.200 | +5.744 | 961 | P81 | 1 | 1008 | 4.95245 | 4.90262 | 0.000630886 | 0.000624537 | 0.218 | 0.21144 | 543.548
POTEAU | 5511.36 | 12370 | 73075.1 | +5.277 | +5.744 | 960 | P80 | 1 | 1008 | 4.25134 | 4.21054 | 0.000541572 | 0.000536374 | 0.187308 | 0.181592 | 466.818
POTEAU | 5434.64 | 12370 | 78025.1 | +5.124 | +5.744 | 962 | P82 | 1 | 1008 | 5.65348 | 5.5946 | 0.000720188 | 0.000712688 | 0.248688 | 0.241284 | 620.268
POTEAU | 5638.09 | 14730 | 68125.1 | +5.431 | +5.844 | 957 | P73 | 1 | 1008 | 3.76295 | 3.72844 | 0.000479356 | 0.00047496 | 0.165928 | 0.1608 | 413.368
POTEAU | 5588.59 | 650 | 68125.2 | +5.431 | +5.745 | 958 | P102 | 1 | 1008 | 2.85834 | 2.83549 | 0.00036412 | 0.000361209 | 0.126328 | 0.122289 | 314.368
POTEAU | 5549.72 | 650 | 70600.1 | +5.354 | +5.744 | 959 | P87 | 1 | 1008 | 3.55032 | 3.51855 | 0.00045227 | 0.000448223 | 0.15662 | 0.151748 | 390.098
POTEAU | 5511.36 | 650 | 73075.1 | +5.277 | +5.744 | 960 | P88 | 1 | 1008 | 4.25134 | 4.21054 | 0.000541572 | 0.000536374 | 0.187308 | 0.181592 | 466.818
POTEAU | 5473 | 650 | 75550.1 | +5.200 | +5.744 | 961 | P89 | 1 | 1008 | 4.95245 | 4.90262 | 0.000630886 | 0.000624537 | 0.218 | 0.21144 | 543.548
POTEAU | 5434.64 | 650 | 78025.1 | +5.124 | +5.744 | 962 | P90 | 1 | 1008 | 5.65348 | 5.5946 | 0.000720188 | 0.000712688 | 0.248688 | 0.241284 | 620.268
POTEAU | 5631.78 | 22050 | 70902.5 | +5.414 | +5.844 | 963 | P74 | 1 | 1008 | 3.87785 | 3.88293 | 0.000493993 | 0.00049464 | 0.170962 | 0.167463 | 430.496
POTEAU | 5631.78 | 26545 | 70902.5 | +5.414 | +5.844 | 963 | P75 | 1 | 1008 | 3.87785 | 3.88293 | 0.000493993 | 0.00049464 | 0.170962 | 0.167463 | 430.496
POTEAU | 5684.48 | 29145 | 72658.8 | +5.523 | +5.845 | 965 | P97 | 1 | 1008 | 2.93338 | 2.9046 | 0.000373679 | 0.000370013 | 0.129612 | 0.12527 | 322.03
POTEAU | 5657.49 | 31395 | 75358.8 | +5.469 | +5.845 | 966 | P105 | 1 | 1008 | 3.42671 | 3.39157 | 0.000436523 | 0.000432047 | 0.151208 | 0.146272 | 376.02
POTEAU | 5580.62 | 26895 | 78045.1 | +5.415 | +5.745 | 967 | P106 | 1 | 1008 | 3.00392 | 2.97423 | 0.000382665 | 0.000378883 | 0.1327 | 0.128273 | 329.75
POTEAU | 5580.62 | 29145 | 78045.1 | +5.415 | +5.745 | 967 | P99 | 1 | 1008 | 3.00392 | 2.97423 | 0.000382665 | 0.000378883 | 0.1327 | 0.128273 | 329.75
POTEAU | 5657.49 | 30545 | 75358.8 | +5.469 | +5.845 | 966 | P98 | 1 | 1008 | 3.42671 | 3.39157 | 0.000436523 | 0.000432047 | 0.151208 | 0.146272 | 376.02
POTEAU | 5657.49 | 27745 | 75358.8 | +5.469 | +5.845 | 966 | P98 | 1 | 1008 | 3.42671 | 3.39157 | 0.000436523 | 0.000432047 | 0.151208 | 0.146272 | 376.02
POTEAU | 5657.49 | 26895 | 75358.8 | +5.469 | +5.845 | 966 | P105 | 1 | 1008 | 3.42671 | 3.39157 | 0.000436523 | 0.000432047 | 0.151208 | 0.146272 | 376.02
POTEAU | 5657.49 | 29145 | 75358.8 | +5.469 | +5.845 | 966 | P98 | 1 | 1008 | 3.42671 | 3.39157 | 0.000436523 | 0.000432047 | 0.151208 | 0.146272 | 376.02
POTEAU | 5580.62 | 27745 | 78045.1 | +5.415 | +5.745 | 967 | P99 | 1 | 1008 | 3.00392 | 2.97423 | 0.000382665 | 0.000378883 | 0.1327 | 0.128273 | 329.75
POTEAU | 5580.62 | 30545 | 78045.1 | +5.415 | +5.745 | 967 | P99 | 1 | 1008 | 3.00392 | 2.97423 | 0.000382665 | 0.000378883 | 0.1327 | 0.128273 | 329.75
POTEAU | 5580.62 | 31395 | 78045.1 | +5.415 | +5.745 | 967 | P106 | 1 | 1008 | 3.00392 | 2.97423 | 0.000382665 | 0.000378883 | 0.1327 | 0.128273 | 329.75
POTEAU | 4176.38 | 20847 | 75824.1 | +3.886 | +4.465 | 950 | P55 | 1 | 1008 | 5.27447 | 5.22049 | 0.000671908 | 0.00066503 | 0.232096 | 0.22515 | 578.791
POTEAU | 4158.08 | 22320 | 77004.1 | +3.850 | +4.465 | 951 | P56 | 1 | 1008 | 5.60892 | 5.55066 | 0.000714512 | 0.00070709 | 0.246737 | 0.239389 | 615.396
POTEAU | 4143.49 | 22320 | 77945.1 | +3.820 | +4.465 | 952 | P57 | 1 | 1008 | 5.87552 | 5.81377 | 0.000748473 | 0.000740607 | 0.258408 | 0.250737 | 644.567
POTEAU | 4176.38 | 19800 | 75824.1 | +3.886 | +4.465 | 950 | P60 | 1 | 1008 | 5.27447 | 5.22049 | 0.000671908 | 0.00066503 | 0.232096 | 0.22515 | 578.791
POTEAU | 4207.27 | 19800 | 73830.1 | +3.948 | +4.465 | 949 | P58 | 1 | 1008 | 4.70996 | 4.66324 | 0.000599995 | 0.000594044 | 0.207384 | 0.201117 | 517.009
POTEAU | 4176.38 | 15633.3 | 75824.1 | +3.886 | +4.465 | 950 | P61 | 1 | 1008 | 5.27447 | 5.22049 | 0.000671908 | 0.00066503 | 0.232096 | 0.22515 | 578.791
POTEAU | 4207.27 | 15633.3 | 73830.1 | +3.948 | +4.465 | 949 | P59 | 1 | 1008 | 4.70996 | 4.66324 | 0.000599995 | 0.000594044 | 0.207384 | 0.201117 | 517.009
POTEAU | 4176.38 | 24940 | 75824.1 | +3.886 | +4.465 | 950 | P55 | 1 | 1008 | 5.27447 | 5.22049 | 0.000671908 | 0.00066503 | 0.232096 | 0.22515 | 578.791
POTEAU | 4207.27 | 24940 | 73830.1 | +3.948 | +4.465 | 949 | P54 | 1 | 1008 | 4.70996 | 4.66324 | 0.000599995 | 0.000594044 | 0.207384 | 0.201117 | 517.009
POTEAU | 4058.55 | 43008.3 | 8340.09 | +3.756 | +4.359 | 948 | P67 | 2 | 2007 | 5.49067 | 5.4357 | 0.000699448 | 0.000692446 | 0.24156 | 0.234431 | 602.651
POTEAU | 4104.89 | 43008.3 | 5691.78 | +3.849 | +4.359 | 947 | P66 | 2 | 2007 | 4.6437 | 4.59965 | 0.000591554 | 0.000585942 | 0.204484 | 0.198374 | 509.958
POTEAU | 4198.09 | 43008.3 | 395.17 | +4.034 | +4.360 | 946 | P96 | 2 | 2007 | 2.95878 | 2.93644 | 0.000376915 | 0.000374068 | 0.130724 | 0.126643 | 325.56
POTEAU | 4058.55 | 45766.7 | 8340.09 | +3.756 | +4.359 | 948 | P67 | 2 | 2007 | 5.49067 | 5.4357 | 0.000699448 | 0.000692446 | 0.24156 | 0.234431 | 602.651
POTEAU | 4104.89 | 45766.7 | 5691.78 | +3.849 | +4.359 | 947 | P66 | 2 | 2007 | 4.6437 | 4.59965 | 0.000591554 | 0.000585942 | 0.204484 | 0.198374 | 509.958
POTEAU | 4198.09 | 45766.7 | 395.17 | +4.034 | +4.360 | 946 | P96 | 2 | 2007 | 2.95878 | 2.93644 | 0.000376915 | 0.000374068 | 0.130724 | 0.126643 | 325.56
POTEAU | 4008.55 | 48525 | 8340.11 | +3.756 | +4.259 | 945 | P79 | 2 | 2007 | 4.57693 | 4.53373 | 0.000583048 | 0.000577546 | 0.20156 | 0.195531 | 502.651
POTEAU | 4054.89 | 48525 | 5691.8 | +3.849 | +4.259 | 944 | P78 | 2 | 2007 | 3.72996 | 3.69768 | 0.000475154 | 0.000471042 | 0.164484 | 0.159474 | 409.958
POTEAU | 3828.11 | 48065 | 10404.9 | +3.396 | +4.259 | 932 | P83 | 2 | 2007 | 7.87447 | 7.78698 | 0.00100312 | 0.000991972 | 0.345914 | 0.335837 | 863.335
POTEAU | 10625.1 | 65860 | 23191.2 | +10.489 | +10.760 | 931 | P100 | 2 | 2007 | 2.46538 | 2.44759 | 0.000314061 | 0.000311795 | 0.109125 | 0.10556 | 271.362
POTEAU | 10719 | 65970 | 20360.2 | +10.576 | +10.860 | 936 | P101 | 2 | 2007 | 2.57711 | 2.55789 | 0.000328295 | 0.000325845 | 0.114016 | 0.110317 | 283.59
POTEAU | 10493.1 | 65970 | 31675.1 | +10.226 | +10.759 | 939 | P86 | 2 | 2007 | 4.85936 | 4.81072 | 0.000619027 | 0.000612831 | 0.213924 | 0.207477 | 533.36
POTEAU | 10580.8 | 65970 | 26019.1 | +10.401 | +10.759 | 937 | P84 | 2 | 2007 | 3.25723 | 3.22923 | 0.000414933 | 0.000411368 | 0.143789 | 0.139271 | 358.022
POTEAU | 10536.9 | 65970 | 28847.1 | +10.313 | +10.759 | 938 | P85 | 2 | 2007 | 4.05838 | 4.02006 | 0.000516991 | 0.00051211 | 0.17886 | 0.173377 | 445.7
POTEAU | 10543.1 | 63750 | 31675.1 | +10.226 | +10.859 | 940 | P63 | 2 | 2007 | 5.7731 | 5.71269 | 0.000735427 | 0.000727731 | 0.253924 | 0.246377 | 633.36
POTEAU | 10630.8 | 63750 | 26019.1 | +10.401 | +10.859 | 941 | P64 | 2 | 2007 | 4.17097 | 4.1312 | 0.000531333 | 0.000526268 | 0.183789 | 0.178171 | 458.022
POTEAU | 10586.9 | 63750 | 28847.1 | +10.313 | +10.859 | 943 | P65 | 2 | 2007 | 4.97212 | 4.92203 | 0.000633391 | 0.00062701 | 0.21886 | 0.212277 | 545.7
POTEAU | 10719 | 63750 | 20360.2 | +10.576 | +10.860 | 936 | P95 | 2 | 2007 | 2.57711 | 2.55789 | 0.000328295 | 0.000325845 | 0.114016 | 0.110317 | 283.59
POTEAU | 10674.6 | 63750 | 23191.1 | +10.489 | +10.859 | 942 | P72 | 2 | 2007 | 3.36998 | 3.34054 | 0.000429297 | 0.000425546 | 0.148725 | 0.144071 | 370.362
POTEAU | 10586.9 | 60985 | 28847.1 | +10.313 | +10.859 | 943 | P65 | 2 | 2007 | 4.97212 | 4.92203 | 0.000633391 | 0.00062701 | 0.21886 | 0.212277 | 545.7
POTEAU | 10674.6 | 60985 | 23191.1 | +10.489 | +10.859 | 942 | P72 | 2 | 2007 | 3.36998 | 3.34054 | 0.000429297 | 0.000425546 | 0.148725 | 0.144071 | 370.362
POTEAU | 10630.8 | 60985 | 26019.1 | +10.401 | +10.859 | 941 | P64 | 2 | 2007 | 4.17097 | 4.1312 | 0.000531333 | 0.000526268 | 0.183789 | 0.178171 | 458.022
POTEAU | 10543.1 | 60985 | 31675.1 | +10.226 | +10.859 | 940 | P63 | 2 | 2007 | 5.7731 | 5.71269 | 0.000735427 | 0.000727731 | 0.253924 | 0.246377 | 633.36
POTEAU | 10586.9 | 58220 | 28847.1 | +10.313 | +10.859 | 943 | P65 | 2 | 2007 | 4.97212 | 4.92203 | 0.000633391 | 0.00062701 | 0.21886 | 0.212277 | 545.7
POTEAU | 10674.6 | 58220 | 23191.1 | +10.489 | +10.859 | 942 | P72 | 2 | 2007 | 3.36998 | 3.34054 | 0.000429297 | 0.000425546 | 0.148725 | 0.144071 | 370.362
POTEAU | 10630.8 | 58220 | 26019.1 | +10.401 | +10.859 | 941 | P64 | 2 | 2007 | 4.17097 | 4.1312 | 0.000531333 | 0.000526268 | 0.183789 | 0.178171 | 458.022
POTEAU | 10543.1 | 58220 | 31675.1 | +10.226 | +10.859 | 940 | P63 | 2 | 2007 | 5.7731 | 5.71269 | 0.000735427 | 0.000727731 | 0.253924 | 0.246377 | 633.36
POTEAU | 10586.9 | 55455 | 28847.1 | +10.313 | +10.859 | 943 | P65 | 2 | 2007 | 4.97212 | 4.92203 | 0.000633391 | 0.00062701 | 0.21886 | 0.212277 | 545.7
POTEAU | 10674.6 | 55455 | 23191.1 | +10.489 | +10.859 | 942 | P72 | 2 | 2007 | 3.36998 | 3.34054 | 0.000429297 | 0.000425546 | 0.148725 | 0.144071 | 370.362
POTEAU | 10630.8 | 55455 | 26019.1 | +10.401 | +10.859 | 941 | P64 | 2 | 2007 | 4.17097 | 4.1312 | 0.000531333 | 0.000526268 | 0.183789 | 0.178171 | 458.022
POTEAU | 10543.1 | 55455 | 31675.1 | +10.226 | +10.859 | 940 | P63 | 2 | 2007 | 5.7731 | 5.71269 | 0.000735427 | 0.000727731 | 0.253924 | 0.246377 | 633.36
POTEAU | 10586.9 | 52690 | 28847.1 | +10.313 | +10.859 | 943 | P65 | 2 | 2007 | 4.97212 | 4.92203 | 0.000633391 | 0.00062701 | 0.21886 | 0.212277 | 545.7
POTEAU | 10674.6 | 52690 | 23191.1 | +10.489 | +10.859 | 942 | P72 | 2 | 2007 | 3.36998 | 3.34054 | 0.000429297 | 0.000425546 | 0.148725 | 0.144071 | 370.362
POTEAU | 10630.8 | 52690 | 26019.1 | +10.401 | +10.859 | 941 | P64 | 2 | 2007 | 4.17097 | 4.1312 | 0.000531333 | 0.000526268 | 0.183789 | 0.178171 | 458.022
POTEAU | 10543.1 | 52690 | 31675.1 | +10.226 | +10.859 | 940 | P63 | 2 | 2007 | 5.7731 | 5.71269 | 0.000735427 | 0.000727731 | 0.253924 | 0.246377 | 633.36
POTEAU | 10536.9 | 50520 | 28847.1 | +10.313 | +10.759 | 938 | P92 | 2 | 2007 | 4.05838 | 4.02006 | 0.000516991 | 0.00051211 | 0.17886 | 0.173377 | 445.7
POTEAU | 10580.8 | 50520 | 26019.1 | +10.401 | +10.759 | 937 | P91 | 2 | 2007 | 3.25723 | 3.22923 | 0.000414933 | 0.000411368 | 0.143789 | 0.139271 | 358.022
POTEAU | 10493.1 | 50520 | 31675.1 | +10.226 | +10.759 | 939 | P93 | 2 | 2007 | 4.85936 | 4.81072 | 0.000619027 | 0.000612831 | 0.213924 | 0.207477 | 533.36
POTEAU | 4151.25 | 45766.7 | 3043.46 | +3.942 | +4.359 | 935 | P62 | 2 | 2007 | 3.79659 | 3.76345 | 0.000483642 | 0.000479421 | 0.1674 | 0.16231 | 417.251
POTEAU | 4151.25 | 43008.3 | 3043.46 | +3.942 | +4.359 | 935 | P62 | 2 | 2007 | 3.79659 | 3.76345 | 0.000483642 | 0.000479421 | 0.1674 | 0.16231 | 417.251
POTEAU | 4151.25 | 40250 | 3043.46 | +3.942 | +4.359 | 935 | P62 | 2 | 2007 | 3.79659 | 3.76345 | 0.000483642 | 0.000479421 | 0.1674 | 0.16231 | 417.251
POTEAU | 4151.25 | 37581.2 | 3043.46 | +3.942 | +4.359 | 935 | P62 | 2 | 2007 | 3.79659 | 3.76345 | 0.000483642 | 0.000479421 | 0.1674 | 0.16231 | 417.251
POTEAU | 4151.25 | 34912.5 | 3043.46 | +3.942 | +4.359 | 935 | P62 | 2 | 2007 | 3.79659 | 3.76345 | 0.000483642 | 0.000479421 | 0.1674 | 0.16231 | 417.251
POTEAU | 4151.25 | 32243.8 | 3043.46 | +3.942 | +4.359 | 935 | P62 | 2 | 2007 | 3.79659 | 3.76345 | 0.000483642 | 0.000479421 | 0.1674 | 0.16231 | 417.251
POTEAU | 4151.25 | 29575 | 3043.46 | +3.942 | +4.359 | 935 | P62 | 2 | 2007 | 3.79659 | 3.76345 | 0.000483642 | 0.000479421 | 0.1674 | 0.16231 | 417.251
POTEAU | 4151.25 | 27043.8 | 3043.46 | +3.942 | +4.359 | 935 | P62 | 2 | 2007 | 3.79659 | 3.76345 | 0.000483642 | 0.000479421 | 0.1674 | 0.16231 | 417.251
POTEAU | 4151.25 | 24512.5 | 3043.46 | +3.942 | +4.359 | 935 | P62 | 2 | 2007 | 3.79659 | 3.76345 | 0.000483642 | 0.000479421 | 0.1674 | 0.16231 | 417.251
POTEAU | 4151.25 | 21981.2 | 3043.46 | +3.942 | +4.359 | 935 | P62 | 2 | 2007 | 3.79659 | 3.76345 | 0.000483642 | 0.000479421 | 0.1674 | 0.16231 | 417.251
POTEAU | 4151.25 | 19450 | 3043.46 | +3.942 | +4.359 | 935 | P62 | 2 | 2007 | 3.79659 | 3.76345 | 0.000483642 | 0.000479421 | 0.1674 | 0.16231 | 417.251
POTEAU | 4151.25 | 17320 | 3043.46 | +3.942 | +4.359 | 935 | P62 | 2 | 2007 | 3.79659 | 3.76345 | 0.000483642 | 0.000479421 | 0.1674 | 0.16231 | 417.251
POTEAU | 4151.25 | 15190 | 3043.46 | +3.942 | +4.359 | 935 | P62 | 2 | 2007 | 3.79659 | 3.76345 | 0.000483642 | 0.000479421 | 0.1674 | 0.16231 | 417.251
POTEAU | 4101.25 | 48525 | 3043.5 | +3.942 | +4.259 | 934 | P77 | 2 | 2007 | 2.88285 | 2.86149 | 0.000367242 | 0.000364521 | 0.1274 | 0.12341 | 317.251
POTEAU | 4151.25 | 13060 | 3043.46 | +3.942 | +4.359 | 935 | P62 | 2 | 2007 | 3.79659 | 3.76345 | 0.000483642 | 0.000479421 | 0.1674 | 0.16231 | 417.251
POTEAU | 4101.25 | 10930 | 3043.5 | +3.942 | +4.259 | 934 | P77 | 2 | 2007 | 2.88285 | 2.86149 | 0.000367242 | 0.000364521 | 0.1274 | 0.12341 | 317.251
POTEAU | 10625.1 | 50630 | 23191.2 | +10.489 | +10.760 | 931 | P107 | 2 | 2007 | 2.46538 | 2.44759 | 0.000314061 | 0.000311795 | 0.109125 | 0.10556 | 271.362
POTEAU | 3828.11 | 15190 | 10404.9 | +3.396 | +4.259 | 932 | P76 | 2 | 2007 | 7.87447 | 7.78698 | 0.00100312 | 0.000991972 | 0.345914 | 0.335837 | 863.335
POTEAU | 3828.11 | 17320 | 10404.9 | +3.396 | +4.259 | 932 | P76 | 2 | 2007 | 7.87447 | 7.78698 | 0.00100312 | 0.000991972 | 0.345914 | 0.335837 | 863.335
POTEAU | 3828.11 | 21981.2 | 10404.9 | +3.396 | +4.259 | 932 | P76 | 2 | 2007 | 7.87447 | 7.78698 | 0.00100312 | 0.000991972 | 0.345914 | 0.335837 | 863.335
POTEAU | 3828.11 | 27043.8 | 10404.9 | +3.396 | +4.259 | 932 | P76 | 2 | 2007 | 7.87447 | 7.78698 | 0.00100312 | 0.000991972 | 0.345914 | 0.335837 | 863.335
POTEAU | 3828.11 | 32243.8 | 10404.9 | +3.396 | +4.259 | 932 | P76 | 2 | 2007 | 7.87447 | 7.78698 | 0.00100312 | 0.000991972 | 0.345914 | 0.335837 | 863.335
POTEAU | 3828.11 | 37581.2 | 10404.9 | +3.396 | +4.259 | 932 | P76 | 2 | 2007 | 7.87447 | 7.78698 | 0.00100312 | 0.000991972 | 0.345914 | 0.335837 | 863.335
POTEAU | 3828.11 | 43008.3 | 10404.9 | +3.396 | +4.259 | 932 | P76 | 2 | 2007 | 7.87447 | 7.78698 | 0.00100312 | 0.000991972 | 0.345914 | 0.335837 | 863.335
POTEAU | 3828.11 | 19450 | 10404.9 | +3.396 | +4.259 | 932 | P76 | 2 | 2007 | 7.87447 | 7.78698 | 0.00100312 | 0.000991972 | 0.345914 | 0.335837 | 863.335
POTEAU | 3828.11 | 24512.5 | 10404.9 | +3.396 | +4.259 | 932 | P76 | 2 | 2007 | 7.87447 | 7.78698 | 0.00100312 | 0.000991972 | 0.345914 | 0.335837 | 863.335
POTEAU | 3828.11 | 29575 | 10404.9 | +3.396 | +4.259 | 932 | P76 | 2 | 2007 | 7.87447 | 7.78698 | 0.00100312 | 0.000991972 | 0.345914 | 0.335837 | 863.335
POTEAU | 3828.11 | 34912.5 | 10404.9 | +3.396 | +4.259 | 932 | P76 | 2 | 2007 | 7.87447 | 7.78698 | 0.00100312 | 0.000991972 | 0.345914 | 0.335837 | 863.335
POTEAU | 3828.11 | 45766.7 | 10404.9 | +3.396 | +4.259 | 932 | P76 | 2 | 2007 | 7.87447 | 7.78698 | 0.00100312 | 0.000991972 | 0.345914 | 0.335837 | 863.335
POTEAU | 3828.11 | 40250 | 10404.9 | +3.396 | +4.259 | 932 | P76 | 2 | 2007 | 7.87447 | 7.78698 | 0.00100312 | 0.000991972 | 0.345914 | 0.335837 | 863.335

# IfcColumn: TUBE-C-100*100*4 (5)
In: Undefined
Description: TUBE-C-100*100*4; Material: STEEL/E24-2
Tekla Common - Phase: 4; Class: 4001; Finish: GRENAILLE-PEINT; Grade: E24-2; Profile: TUBE-C-100*100*4; Name: SUPPORT; sets with these values: 2
Tekla Quantity - Gross footprint area: 0.001536 m2; Area per tons: 32.6074 m2; Height: 100 mm; Width: 100 mm; sets with these values: 2
Name | Center of gravity Z (mm) | Center of gravity Y (mm) | Center of gravity X (mm) | Bottom elevation | Top elevation | Part mark | Assembly mark | Net weight (kg) = NetWeight (kg) | Gross weight (kg) = Weight (kg) | Net volume (m3) = NetVolume (m3) | Gross volume (m3) | Net surface area (m2) | Gross area (m2) = OuterSurfaceArea (m2) | Tekla Quantity, Length (mm) = BaseQuantities, Length (mm)
SUPPORT | 4915 | 26000 | 55850 | +4.247 | +5.583 | 1371 | E4 | 16.109 | 15.8153 | 0.0020521 | 0.00201469 | 0.536 | 0.515696 | 1336
SUPPORT | 4915 | 26000 | 44175 | +4.247 | +5.583 | 1371 | E4 | 16.109 | 15.8153 | 0.0020521 | 0.00201469 | 0.536 | 0.515696 | 1336
SUPPORT | 4915 | 26000 | 32500 | +4.247 | +5.583 | 1371 | E4 | 16.109 | 15.8153 | 0.0020521 | 0.00201469 | 0.536 | 0.515696 | 1336
SUPPORT | 4915 | 23100 | 67525 | +4.247 | +5.583 | 1371 | E4 | 16.109 | 15.8153 | 0.0020521 | 0.00201469 | 0.536 | 0.515696 | 1336
SUPPORT | 4946 | 18400 | 71802 | +4.010 | +5.882 | 1372 | E5 | 22.5718 | 22.1604 | 0.00287539 | 0.00282298 | 0.7504 | 0.722592 | 1872

# IfcColumn: TUBE-C-60*60*3 (5)
In: Undefined
Description: TUBE-C-60*60*3; Material: STEEL/E24-2
Tekla Common - Finish: GRENAILLE-PEINT; Grade: E24-2; Profile: TUBE-C-60*60*3; sets with these values: 2
Tekla Quantity - Gross footprint area: 0.000684 m2; Area per tons: 42.9 m2; Height: 60 mm; Width: 60 mm; sets with these values: 2
Name | Center of gravity Z (mm) | Center of gravity Y (mm) | Center of gravity X (mm) | Bottom elevation | Top elevation | Part mark | Assembly mark | Phase | Class | Name | Net weight (kg) = NetWeight (kg) | Gross weight (kg) = Weight (kg) | Net volume (m3) = NetVolume (m3) | Gross volume (m3) | Net surface area (m2) | Gross area (m2) = OuterSurfaceArea (m2) | Tekla Quantity, Length (mm) = BaseQuantities, Length (mm)
LISSE | 5002.5 | 69117 | 44095 | +4.420 | +5.585 | 1174 | L45 | 3 | 3003 | LISSE | 6.25535 | 6.21877 | 0.00079686 | 0.0007922 | 0.28032 | 0.266785 | 1165
LISSE | 5002.5 | 69117 | 55770 | +4.420 | +5.585 | 1174 | L44 | 1 | 1003 | LISSE | 6.25535 | 6.21877 | 0.00079686 | 0.0007922 | 0.28032 | 0.266785 | 1165
LISSE | 5002.5 | 69117 | 67445 | +4.420 | +5.585 | 1174 | L44 | 1 | 1003 | LISSE | 6.25535 | 6.21877 | 0.00079686 | 0.0007922 | 0.28032 | 0.266785 | 1165
POTEAUX | 1866.64 | 20670 | 78355 | +0.006 | +3.727 | 1167 | P52 | 7 | 7001 | POTEAUX | 19.9811 | 19.8642 | 0.00254536 | 0.00253048 | 0.89383 | 0.852175 | 3721.29
POTEAUX | 1637.98 | 20670 | 79315 | +0.006 | +3.270 | 1168 | P53 | 7 | 7001 | POTEAUX | 17.5255 | 17.423 | 0.00223255 | 0.00221949 | 0.78407 | 0.747447 | 3263.96

# IfcColumn: TUBE-C-70*70*3 (4)
In: Undefined
Description: TUBE-C-70*70*3; Material: STEEL/E24-2
Tekla Common - Phase: 4; Class: 4001; Finish: GRENAILLE-PEINT; Grade: E24-2; Profile: TUBE-C-70*70*3; sets with these values: 2
Tekla Quantity - Area per tons: 42.8344 m2; Height: 70 mm; Width: 70 mm; sets with these values: 2
Name | Center of gravity Z (mm) | Center of gravity Y (mm) | Center of gravity X (mm) | Bottom elevation | Top elevation | Part mark | Assembly mark | Name | Net weight (kg) = NetWeight (kg) | Gross weight (kg) = Weight (kg) | Net volume (m3) = NetVolume (m3) | Gross volume (m3) | Gross footprint area (m2) | Net surface area (m2) | Gross area (m2) = OuterSurfaceArea (m2) | Tekla Quantity, Length (mm) = BaseQuantities, Length (mm)
MONTANT | 4088.5 | 27915 | 55715 | +3.880 | +4.297 | 914 | M21 | MONTANT | 2.63185 | 2.61876 | 0.000335268 | 0.0003336 | 0.000804 | 0.1176 | 0.112173 | 417
MONTANT | 4741.1 | 27915 | 55985 | +3.880 | +5.602 | 909 | M18 | MONTANT | 10.8695 | 10.8154 | 0.00138465 | 0.00137776 | 0.000804 | 0.483056 | 0.463272 | 1722.2
LISSE | 4324 | 27916 | 58340 | +3.500 | +5.148 | 908 | L18 | LISSE | 9.95939 | 10.3494 | 0.00126871 | 0.0013184 | 0 | 0.443028 | 0.443312 | 1648
LISSE | 4324 | 23984.1 | 58340 | +3.500 | +5.148 | 908 | L18 | LISSE | 9.95939 | 10.3494 | 0.00126871 | 0.0013184 | 0 | 0.443028 | 0.443312 | 1648

# IfcColumn: UPF-100*50*4 (13)
In: Undefined
Description: UPF-100*50*4; Material: STEEL/E24-2
Tekla Common - Bottom elevation: +2.939; Phase: 2; Class: 2003; Finish: GRENAILLE-PEINT; Grade: E24-2; Profile: UPF-100*50*4; Name: ATTACHE; sets with these values: 2
Tekla Quantity - Height: 100 mm; Width: 50 mm; sets with these values: 2
Name | Center of gravity Z (mm) | Center of gravity Y (mm) | Center of gravity X (mm) | Top elevation | Part mark | Assembly mark | Net weight (kg) = Weight (kg) = NetWeight (kg) | Gross weight (kg) | Net volume (m3) = NetVolume (m3) | Gross volume (m3) | Gross footprint area (m2) | Area per tons (m2) | Net surface area (m2) = OuterSurfaceArea (m2) | Gross area (m2) | Tekla Quantity, Length (mm) = BaseQuantities, Length (mm)
ATTACHE | 3393.97 | 19928 | 4547.13 | +3.856 | 1140 | L34 | 5.2447 | 5.53142 | 0.000668115 | 0.000704639 | 0.00032 | 65.38 | 0.342899 | 0.361195 | 917.499
ATTACHE | 3418.98 | 32579.7 | 2454.37 | +3.906 | 1138 | L33 | 5.54614 | 5.83286 | 0.000706515 | 0.000743039 | 0.00032 | 65.3605 | 0.362499 | 0.380795 | 967.499
ATTACHE | 3418.98 | 27224.2 | 2881.69 | +3.906 | 1123 | L37 | 5.54614 | 5.83286 | 0.000706515 | 0.000743039 | 0.00032 | 65.3605 | 0.362499 | 0.380795 | 967.499
ATTACHE | 3181.8 | 32428.8 | 2458.62 | +3.420 | 1115 | L33 | 2.69291 | 5.83286 | 0.000343046 | 0.000743039 | 0 | 65.6561 | 0.176806 | 0.380795 | 481.499
ATTACHE | 3418.98 | 29757.4 | 2598.27 | +3.906 | 1123 | L33 | 5.54614 | 5.83286 | 0.000706515 | 0.000743039 | 0.00032 | 65.3605 | 0.362499 | 0.380795 | 967.499
ATTACHE | 3418.98 | 24689.5 | 3314.29 | +3.906 | 1123 | L37 | 5.54614 | 5.83286 | 0.000706515 | 0.000743039 | 0.00032 | 65.3605 | 0.362499 | 0.380795 | 967.499
ATTACHE | 3181.78 | 19642.3 | 4640.41 | +3.420 | 1115 | L34 | 2.69269 | 5.53142 | 0.000343018 | 0.000704639 | 0 | 65.6559 | 0.176791 | 0.361195 | 481.499
ATTACHE | 3393.97 | 22154 | 3900.68 | +3.856 | 1122 | L34 | 5.2447 | 5.53142 | 0.000668115 | 0.000704639 | 0.00032 | 65.38 | 0.342899 | 0.361195 | 917.499
ATTACHE | 3363.95 | 17483.4 | 5406.14 | +3.796 | 1119 | L36 | 4.88298 | 5.16969 | 0.000622035 | 0.000658559 | 0.00032 | 65.4065 | 0.319379 | 0.337675 | 857.499
ATTACHE | 3363.95 | 15347.3 | 6291.8 | +3.796 | 1119 | L36 | 4.88298 | 5.16969 | 0.000622035 | 0.000658559 | 0.00032 | 65.4065 | 0.319379 | 0.337675 | 857.499
ATTACHE | 3328.92 | 13212.5 | 7311.82 | +3.726 | 1117 | L35 | 4.46096 | 4.74767 | 0.000568275 | 0.000604799 | 0.00032 | 65.443 | 0.291939 | 0.310235 | 787.499
ATTACHE | 3328.92 | 11076.2 | 8478.07 | +3.726 | 1117 | L35 | 4.46096 | 4.74767 | 0.000568275 | 0.000604799 | 0.00032 | 65.443 | 0.291939 | 0.310235 | 787.499
ATTACHE | 3313.91 | 10389.4 | 8886.17 | +3.696 | 1141 | L35 | 4.2801 | 4.56681 | 0.000545235 | 0.000581759 | 0.00032 | 65.4608 | 0.280179 | 0.298475 | 757.499

# IfcColumn: UPN120, LISSE
In: Undefined
Description: UPN120; Material: STEEL/E24-2
Tekla Common - Center of gravity Z: 3300 mm; Center of gravity Y: -1910.19 mm; Center of gravity X: 32506.7 mm; Bottom elevation: +3.055; Top elevation: +3.545; Part mark: 1318; Assembly mark: L115; Phase: 3; Class: 3003; Finish: GRENAILLE-PEINT; Grade: E24-2; Profile: UPN120; Name: LISSE; sets with these values: 2
Tekla Quantity - Net weight: 6.55444 kg; Gross weight: 6.53905 kg; Weight: 6.53905 kg; Net volume: 0.00083496 m3; Gross volume: 0.000833 m3; Gross footprint area: 0.001704 m2; Area per tons: 32.2218 m2; Net surface area: 0.221948 m2; Gross area: 0.2107 m2; Height: 120 mm; Width: 55 mm; Length: 490 mm; sets with these values: 2
BaseQuantities - Length: 490 mm; OuterSurfaceArea: 0.2107 m2; NetVolume: 0.00083496 m3; NetWeight: 6.55444 kg

# IfcColumn: UPN160 (4)
In: Undefined
Description: UPN160; Material: STEEL/E24-2
Tekla Common - Center of gravity Y: 19620 mm; Phase: 7; Class: 7001; Finish: GRENAILLE-PEINT; Grade: E24-2; Profile: UPN160; sets with these values: 2
Tekla Quantity - Gross footprint area: 0.0024075 m2; Area per tons: 29.1932 m2; Height: 160 mm; Width: 65 mm; sets with these values: 2
Name | Center of gravity Z (mm) | Center of gravity X (mm) | Bottom elevation | Top elevation | Part mark | Assembly mark | Name | Net weight (kg) = NetWeight (kg) | Gross weight (kg) = Weight (kg) | Net volume (m3) = NetVolume (m3) | Gross volume (m3) | Net surface area (m2) | Gross area (m2) = OuterSurfaceArea (m2) | Tekla Quantity, Length (mm) = BaseQuantities, Length (mm)
POTEAUX | 3507.4 | 75077.7 | +3.409 | +3.578 | 1294 | L114 | POTEAUX | 2.57421 | 3.18716 | 0.000327925 | 0.000406008 | 0.0842511 | 0.0930435 | 169.17
MONTANT | 3235.5 | 75074.9 | +3.077 | +3.394 | 1296 | M23 | MONTANT | 5.99094 | 5.97228 | 0.000763177 | 0.0007608 | 0.18392 | 0.17435 | 317
POTEAUX | 1892.66 | 78115.1 | +0.010 | +3.775 | 1290 | P132 | POTEAUX | 71.1603 | 70.9386 | 0.00906501 | 0.00903677 | 2.13222 | 2.07093 | 3765.32
POTEAUX | 1502 | 75074.9 | +0.010 | +2.994 | 1291 | P133 | POTEAUX | 56.3942 | 56.2186 | 0.00718398 | 0.0071616 | 1.69077 | 1.6412 | 2984

# IfcColumn: UPN180 (8)
In: Undefined
Description: UPN180; Material: STEEL/E24-2
Tekla Common - Phase: 1; Class: 1003; Finish: GRENAILLE-PEINT; Grade: E24-2; Profile: UPN180; Name: POTEAUX; sets with these values: 2
Tekla Quantity - Gross footprint area: 0.002804 m2; Area per tons: 27.7525 m2; Height: 180 mm; Width: 70 mm; sets with these values: 2
Name | Center of gravity Z (mm) | Center of gravity Y (mm) | Center of gravity X (mm) | Bottom elevation | Top elevation | Part mark | Assembly mark | Net weight (kg) = NetWeight (kg) | Gross weight (kg) = Weight (kg) | Net volume (m3) = NetVolume (m3) | Gross volume (m3) | Net surface area (m2) | Gross area (m2) = OuterSurfaceArea (m2) | Tekla Quantity, Length (mm) = BaseQuantities, Length (mm)
POTEAUX | 1097 | -135 | 59816 | -0.200 | +2.394 | 1009 | P45 | 57.0976 | 57.0161 | 0.00727358 | 0.0072632 | 1.62426 | 1.58234 | 2594
POTEAUX | 1097 | -135 | 57674 | -0.200 | +2.394 | 1009 | P44 | 57.0976 | 57.0161 | 0.00727358 | 0.0072632 | 1.62426 | 1.58234 | 2594
POTEAUX | 2389.69 | 31311 | 79245 | -0.200 | +4.979 | 1011 | P48 | 114.005 | 113.843 | 0.014523 | 0.0145023 | 3.23754 | 3.15942 | 5179.38
POTEAUX | 2389.69 | 30269 | 79245 | -0.200 | +4.979 | 1011 | P49 | 114.005 | 113.843 | 0.014523 | 0.0145023 | 3.23754 | 3.15942 | 5179.38
POTEAUX | 2009.89 | 59924 | 79245 | +0.010 | +4.010 | 1004 | P40 | 88.0408 | 87.9152 | 0.0112154 | 0.0111994 | 2.50147 | 2.43987 | 3999.78
POTEAUX | 1202 | 61614 | 79245 | +0.010 | +2.394 | 1012 | P50 | 52.4752 | 52.4003 | 0.00668474 | 0.0066752 | 1.49322 | 1.45424 | 2384
POTEAUX | 1202 | 64256 | 79245 | +0.010 | +2.394 | 1012 | P51 | 52.4752 | 52.4003 | 0.00668474 | 0.0066752 | 1.49322 | 1.45424 | 2384
POTEAUX | 2009.89 | 66656 | 79245 | +0.010 | +4.010 | 1004 | P41 | 88.0408 | 87.9152 | 0.0112154 | 0.0111994 | 2.50147 | 2.43987 | 3999.78

# IfcElementAssembly (4665)
In: Undefined
Tekla Assembly - sets with these values: 2
Name | Assembly/Cast unit weight (kg) | Assembly/Cast unit bottom elevation | Assembly/Cast unit top elevation | Assembly/Cast unit name | Assembly/Cast unit position code | Assembly/Cast unit Mark
2 x L80*8 | 0 | +3.645 | +3.745 | L80*8 | 7'-/D1-C1 | H60
L80*8 | 0 | +2.105 | +2.205 | L80*8 | /D1-C1 | H57
L80*8 | 0 | +3.096 | +3.196 | L80*8 | /D1-C1 | H57
BLL100*50*2 | 0 | +3.515 | +3.627 | BLL100*50*2 | 7'-/D1-C1 | L121
TUBE-C-60*60*3 | 0.147706 | +3.116 | +3.176 | TUBE-C-60*60*3 | 7'-/D1-C1 | L38
BLL300*60*1.5 | 0 | +3.505 | +3.682 | BLL300*60*1.5 | 7'-/D1-C1 | L119
TUBE-C-70*70*3 | 0.205168 | +1.750 | +1.820 | TUBE-C-70*70*3 | 7'-/D1-C1 | L110
TUBE-C-70*70*3 | 0.205168 | +0.100 | +0.170 | TUBE-C-70*70*3 | 7'-/D1-C1 | L110
TUBE-C-60*60*3 | 0.147706 | +2.100 | +2.160 | TUBE-C-60*60*3 | 7'-/D1-C1 | L39
UPN160 | 1.2717 | +3.000 | +3.071 | UPN160 | 7'-/D1-C1 | L113
TUBE-C-60*60*3 | 0.610793 | +0.000 | +3.273 | TUBE-C-60*60*3 | /D1-C1 | P53
TUBE-C-60*60*3 | 0.756803 | +0.000 | +3.730 | TUBE-C-60*60*3 | 7'-/D1-C1 | P52
UPN160 | 2.72003 | +0.000 | +3.000 | UPN160 | 7'-/D1-C1 | P133
UPN160 | 2.29612 | +0.000 | +3.775 | UPN160 | 7'-/D1-C1 | P132
11 x L40*4 | 0 | +3.132 | +3.499 | L40*4 | 1-2/E-D | W5
5 x PL240*8 | 1.65792 | +3.624 | +3.706 | PL240*8 | 1-2/D-C | H42
10 x L80*8 | 0 | +3.702 | +3.723 | L80*8 | 1-2/D-C | H56
5 x L60*6 | 0 | +3.231 | +3.690 | L60*6 | 1-2/D-C | W1
2 x L80*8 | 0 | +3.523 | +3.544 | L80*8 | 1-2/E-D | H56
10 x L80*8 | 0 | +3.718 | +3.739 | L80*8 | 1-2/D-C | H56
TUBE-C-80*80*3 | 2.02473 | +3.040 | +3.527 | TUBE-C-80*80*3 | 1-2/E-D | S87
2 x TUBE-C-80*80*3 | 2.61248 | +3.120 | +3.722 | TUBE-C-80*80*3 | 1-2/D-C | S10
7 x L40*4 | 0 | +3.132 | +3.499 | L40*4 | 1-2/D-C | W5
TUBE-C-80*80*3 | 2.61248 | +3.120 | +3.722 | TUBE-C-80*80*3 | 1-2/D-C | S9
L60*6 | 0 | +3.165 | +3.225 | L60*6 | 1-2/D-C | L16
TUBE-C-80*80*3 | 2.61248 | +3.120 | +3.629 | TUBE-C-80*80*3 | 1-2/D-C | S5
2 x L80*8 | 0 | +3.625 | +3.646 | L80*8 | 1-2/D-C | H56
L60*6 | 0 | +3.165 | +3.225 | L60*6 | 1-2/D | L16
TUBE-C-80*80*3 | 2.61248 | +3.120 | +3.722 | TUBE-C-80*80*3 | 1-2/D-C | S8
2 x L40*4 | 0 | +3.132 | +3.499 | L40*4 | 1-2/D | W5
2 x L80*8 | 0 | +3.625 | +3.646 | L80*8 | 1-2/D | H56
TUBE-C-80*80*3 | 2.61248 | +3.120 | +3.629 | TUBE-C-80*80*3 | 1-2/D | S6
TUBE-C-80*80*3 | 2.61248 | +3.120 | +3.722 | TUBE-C-80*80*3 | 1-2/D | S8
2 x TUBE-C-80*80*3 | 2.61248 | +3.120 | +3.722 | TUBE-C-80*80*3 | 1-2/E-D | S7
2 x L80*8 | 0 | +3.718 | +3.739 | L80*8 | 1-2/D | H56
8 x L80*8 | 0 | +3.718 | +3.739 | L80*8 | 1-2/E-D | H56
TUBE-C-80*80*3 | 2.61248 | +3.120 | +3.722 | TUBE-C-80*80*3 | 1-2/D-C | S7
4 x PL240*8 | 1.65792 | +3.624 | +3.706 | PL240*8 | 1-2/E-D | H42
8 x L80*8 | 0 | +3.702 | +3.723 | L80*8 | 1-2/E-D | H56
4 x L60*6 | 0 | +3.231 | +3.690 | L60*6 | 1-2/E-D | W1
PL240*8 | 1.65792 | +3.624 | +3.706 | PL240*8 | 1-2/D | H42
L60*6 | 0 | +3.165 | +3.225 | L60*6 | 1-2/E-D | L16
2 x TUBE-C-80*80*3 | 2.61248 | +3.120 | +3.629 | TUBE-C-80*80*3 | 1-2/E-D | S5
2 x L80*8 | 0 | +3.702 | +3.723 | L80*8 | 1-2/D | H56
8 x L80*8 | 0 | +3.625 | +3.646 | L80*8 | 1-2/E-D | H56
3 x L70*7 | 0 | +3.160 | +3.230 | L70*7 | 1-2/E-D | H40
L60*6 | 0 | +3.165 | +3.225 | L60*6 | 1-2/E-D | L14
L60*6 | 0 | +3.231 | +3.690 | L60*6 | 1-2/D | W1
2 x TUBE-C-80*80*3 | 2.61248 | +3.120 | +3.629 | TUBE-C-80*80*3 | 1-2/E-D | S6
4 x L80*8 | 0 | +3.520 | +3.541 | L80*8 | 1-2/E-D | H56
TUBE-C-80*80*3 | 2.84327 | +3.120 | +3.523 | TUBE-C-80*80*3 | 1-2/E-D | S4
TUBE-C-80*80*3 | 0.27205 | +3.040 | +3.190 | TUBE-C-80*80*3 | 1-2/E-D | L82
TUBE-C-80*80*3 | 2.84327 | +3.120 | +3.523 | TUBE-C-80*80*3 | 1-2/E-D | S3
TUBE-C-80*80*3 | 0.27205 | +3.040 | +3.190 | TUBE-C-80*80*3 | 1-2/D-C | L83
2 x TUBE-C-80*80*3 | 0.27205 | +3.040 | +3.190 | TUBE-C-80*80*3 | 1-2/E-D | L84
TUBE-C-80*80*3 | 0.27205 | +3.040 | +3.190 | TUBE-C-80*80*3 | 1-2/E-D | L86
TUBE-C-80*80*3 | 0.27205 | +3.040 | +3.190 | TUBE-C-80*80*3 | 1-2/D-C | L81
2 x TUBE-C-80*80*3 | 0.27205 | +3.040 | +3.190 | TUBE-C-80*80*3 | 1-2/D-C | L85
TUBE-C-80*80*3 | 0.27205 | +3.040 | +3.190 | TUBE-C-80*80*3 | 1-2/E-D | L87
L40*4 | 0 | +3.003 | +4.265 | L40*4 | 1/D-C | W4
UPN100 | 1.39887 | +4.284 | +4.340 | UPN100 | 1/D-C | L54
HEA100 | 0.891132 | +2.986 | +4.284 | HEA100 | 1/D-C | L117
UPN100 | 4.03113 | +2.986 | +4.284 | UPN100 | 1/D-C | L53
UPN100 | 1.39887 | +2.930 | +2.986 | UPN100 | 1/D-C | L54
HEA100 | 4.15673 | +2.986 | +4.284 | HEA100 | 1/D-C | L32
PL3*3600 | 81.5584 | -0.000 | +3.600 | PL3*3600 | -/-D' | F2
PL3*3600 | 74.776 | -0.000 | +3.600 | PL3*3600 | -/-D' | F1
PL3*3600 | 73.6738 | -0.000 | +3.600 | PL3*3600 | /D' | F3
FPL3*3600 | 41.3726 | -0.000 | +3.600 | FPL3*3600 | 1/E-D | F4
FPL3*3600 | 41.3726 | -0.000 | +3.600 | FPL3*3600 | 1/D-C | F4
TUBE-C-70*70*3 | 0.307751 | +3.877 | +4.316 | TUBE-C-70*70*3 | 5-6/D-C | M22
TUBE-C-70*70*3 | 0.481739 | +3.877 | +5.608 | TUBE-C-70*70*3 | 6/D-C | M17
L60*6 | 0 | +4.237 | +4.297 | L60*6 | 6/D-C | H15
L60*6 | 0 | +3.880 | +3.940 | L60*6 | 6/D-C | H14
L60*6 | 0 | +5.533 | +5.593 | L60*6 | 6/D-C | H13
4 x L80*8 | 0 | +3.940 | +3.958 | L80*8 | 6/D-C | C136
4 x L80*8 | 0 | +4.219 | +4.237 | L80*8 | 6/D-C | H63
L60*6 | 0 | +3.880 | +3.940 | L60*6 | 6/D-C | H17
L70*7 | 0 | +4.733 | +4.804 | L70*7 | 6-7/D-C | C117
4 x PL8 | 9.12418 | +5.131 | +5.188 | PL8 | 6-7/D-C | G42
2 x L50*5 | 0 | +5.122 | +5.506 | L50*5 | 6-7/B-A | C26
L60*6 | 0 | +5.533 | +5.593 | L60*6 | 6/D-C | H18
3 x L80*8 | 0 | +5.593 | +5.611 | L80*8 | 6/D-C | C136
L60*6 | 0 | +3.880 | +3.940 | L60*6 | 6/D-C | H18
L60*6 | 0 | +4.237 | +4.297 | L60*6 | 6/D-C | H17
L60*6 | 0 | +4.237 | +4.297 | L60*6 | 6/D-C | H18
TUBE-C-70*70*3 | 0 | +3.500 | +5.313 | TUBE-C-70*70*3 | 6-7/D-C | L18
TUBE-C-70*70*3 | 0 | +3.500 | +4.308 | TUBE-C-70*70*3 | 5-6/D-C | L19
L60*6 | 0 | +5.533 | +5.593 | L60*6 | 6/D-C | H17
2 x HEA100 | 2.355 | +3.500 | +4.270 | HEA100 | 5-6/D-C | E6
4 x L80*8 | 0 | +4.255 | +4.288 | L80*8 | 5-6/D-C | H61
4 x L80*8 | 0 | +5.221 | +5.254 | L80*8 | 6-7/D-C | H61
UPF-100*50*4 | 1.35648 | +10.403 | +10.543 | UPF-100*50*4 | >/B'> | U7
2 x HEA100 | 2.355 | +3.500 | +5.236 | HEA100 | 6-7/D-C | E7
8 x L80*8 | 0 | +4.219 | +4.237 | L80*8 | 5/E-D | H63
8 x L60*6 | 0 | +4.237 | +4.297 | L60*6 | 5/E-D | H17
2 x L60*6 | 0 | +3.605 | +4.382 | L60*6 | 5/E-D | M11
8 x L80*8 | 0 | +3.940 | +3.958 | L80*8 | 5/E-D | C136
8 x L60*6 | 0 | +3.880 | +3.940 | L60*6 | 5/E-D | H18
6 x L60*6 | 0 | +3.605 | +4.382 | L60*6 | 5/E-D | M7
3 x TUBE-C-70*70*3 | 0.205167 | +4.317 | +4.387 | TUBE-C-70*70*3 | 5/E-D | L70
TUBE-C-70*70*3 | 0.205167 | +3.600 | +3.670 | TUBE-C-70*70*3 | 5/E-D | L58
L60*6 | 0 | +3.605 | +4.382 | L60*6 | 5/E | M11
2 x L60*6 | 0 | +3.880 | +3.940 | L60*6 | 5/E | H18
2 x L80*8 | 0 | +3.940 | +3.958 | L80*8 | 5/E | C136
2 x L80*8 | 0 | +4.219 | +4.237 | L80*8 | 5/E | H63
2 x L60*6 | 0 | +4.237 | +4.297 | L60*6 | 5/E | H17
TUBE-C-70*70*3 | 0.205167 | +4.317 | +4.387 | TUBE-C-70*70*3 | 5/E-D | L69
L60*6 | 0 | +3.605 | +4.312 | L60*6 | 5/F-E | M8
4 x L60*6 | 0 | +3.880 | +3.940 | L60*6 | 5/F-E | H18
4 x L80*8 | 0 | +3.940 | +3.958 | L80*8 | 5/F-E | C136
4 x L60*6 | 0 | +4.237 | +4.297 | L60*6 | 5/F-E | H17
4 x L80*8 | 0 | +4.219 | +4.237 | L80*8 | 5/F-E | H63
TUBE-C-70*70*3 | 0.205167 | +4.247 | +4.317 | TUBE-C-70*70*3 | 5/F-E | L68
L60*6 | 0 | +3.605 | +4.312 | L60*6 | 5/E | M8
L60*6 | 0 | +3.670 | +3.730 | L60*6 | 5/F-E | M9
L60*6 | 0 | +3.605 | +4.382 | L60*6 | 5/F-E | M11
TUBE-C-70*70*3 | 0.205168 | +4.317 | +4.387 | TUBE-C-70*70*3 | 5/F-E | L67
TUBE-C-70*70*3 | 0.205168 | +3.600 | +3.670 | TUBE-C-70*70*3 | 5/F-E | L57
2 x L60*6 | 0 | +3.605 | +4.382 | L60*6 | 5/F-E | M7
TUBE-C-70*70*3 | 0.205168 | +4.317 | +4.387 | TUBE-C-70*70*3 | 5/F-E | L66
TUBE-C-70*70*3 | 0.205168 | +3.600 | +3.670 | TUBE-C-70*70*3 | 5/F-E | L56
L80*8 | 0 | +3.940 | +3.958 | L80*8 | 5/F | C136
L80*8 | 0 | +4.219 | +4.237 | L80*8 | 5/F | H63
2 x PL120*12 | 6.25154 | +5.640 | +5.840 | PL120*12 | 7'/D1-C1 | E1
2 x PL120*12 | 6.25154 | +4.340 | +4.540 | PL120*12 | 7'/D1-C1 | E1
2 x TUBE-C-100*100*4 | 0.434074 | +4.007 | +5.885 | TUBE-C-100*100*4 | 7'/D1-C1 | E5
L80*8 | 0 | +4.000 | +4.080 | L80*8 | 7'/D1-C1 | H64
L80*8 | 0 | +5.812 | +5.892 | L80*8 | 7'/D1-C1 | H66
L80*8 | 0 | +4.000 | +4.080 | L80*8 | 7'/D1-C1 | H65
L80*8 | 0 | +5.812 | +5.892 | L80*8 | 7'/D1-C1 | H67
2 x TUBE-C-100*100*4 | 0.434074 | +4.244 | +5.586 | TUBE-C-100*100*4 | 7/D-C | E4
2 x PL120*12 | 6.92978 | +4.690 | +4.890 | PL120*12 | 6-7/D-C | E2
L80*8 | 0 | +4.237 | +4.317 | L80*8 | 7/D-C | H68
L80*8 | 0 | +5.513 | +5.593 | L80*8 | 7/D-C | H69
2 x PL120*12 | 6.92978 | +5.340 | +5.540 | PL120*12 | 6-7/D-C | E2
L80*8 | 0 | +5.513 | +5.593 | L80*8 | 7/D-C | H68
L80*8 | 0 | +4.237 | +4.317 | L80*8 | 7/D-C | H69
2 x PL120*12 | 6.92978 | +5.340 | +5.540 | PL120*12 | 3-4/D-C | E2
2 x TUBE-C-100*100*4 | 0.434074 | +4.244 | +5.586 | TUBE-C-100*100*4 | 4/D-C | E4
L80*8 | 0 | +5.513 | +5.593 | L80*8 | 4/D-C | H68
L80*8 | 0 | +5.513 | +5.593 | L80*8 | 4/D-C | H69
2 x PL120*12 | 6.92978 | +4.690 | +4.890 | PL120*12 | 3-4/D-C | E2
L80*8 | 0 | +4.237 | +4.317 | L80*8 | 4/D-C | H69
2 x PL120*12 | 6.92978 | +5.340 | +5.540 | PL120*12 | 4-5/D-C | E2
2 x TUBE-C-100*100*4 | 0.434074 | +4.244 | +5.586 | TUBE-C-100*100*4 | 5/D-C | E4
L80*8 | 0 | +5.513 | +5.593 | L80*8 | 5/D-C | H68
L80*8 | 0 | +5.513 | +5.593 | L80*8 | 5/D-C | H69
L80*8 | 0 | +4.237 | +4.317 | L80*8 | 4/D-C | H68
2 x PL120*12 | 6.92978 | +4.690 | +4.890 | PL120*12 | 4-5/D-C | E2
2 x TUBE-C-100*100*4 | 0.434074 | +4.244 | +5.586 | TUBE-C-100*100*4 | 6/D-C | E4
2 x PL120*12 | 6.92978 | +4.690 | +4.890 | PL120*12 | 5-6/D-C | E2
L80*8 | 0 | +4.237 | +4.317 | L80*8 | 6/D-C | H69
L80*8 | 0 | +5.513 | +5.593 | L80*8 | 6/D-C | H68
2 x PL120*12 | 6.92978 | +5.340 | +5.540 | PL120*12 | 5-6/D-C | E2
L80*8 | 0 | +4.237 | +4.317 | L80*8 | 5/D-C | H68
L80*8 | 0 | +5.513 | +5.593 | L80*8 | 6/D-C | H69
L80*8 | 0 | +4.237 | +4.317 | L80*8 | 6/D-C | H68
L80*8 | 0 | +4.237 | +4.317 | L80*8 | 5/D-C | H69
2 x FPL60*5 | 0.506325 | +5.319 | +5.383 | FPL60*5 | 7-8/F-E | H93
2 x UPF-100*50*4 | 0 | +5.300 | +5.415 | UPF-100*50*4 | 7-8/F-E | U8
2 x FPL60*5 | 0.506325 | +5.332 | +5.395 | FPL60*5 | 7-8/F-E | H93
2 x FPL60*5 | 0.506325 | +5.013 | +5.076 | FPL60*5 | 7-8/F-E | H93
2 x FPL60*5 | 0.506325 | +5.025 | +5.088 | FPL60*5 | 7-8/F-E | H93
2 x UPF-100*50*4 | 0 | +4.993 | +5.108 | UPF-100*50*4 | 7-8/F-E | U8
2 x PL60*6 | 0.49455 | +5.091 | +5.099 | PL60*6 | 8/F-E | H9
2 x PL60*6 | 0.49455 | +5.108 | +5.116 | PL60*6 | 7-8/F-E | H9
UPF-100*50*4 | 0 | +4.991 | +5.092 | UPF-100*50*4 | 8/F-E | U9
UPF-100*50*4 | 0 | +5.315 | +5.416 | UPF-100*50*4 | 7-8/F-E | U9
UPF-100*50*4 | 0 | +5.008 | +5.110 | UPF-100*50*4 | 7-8/F-E | U10
PL60*6 | 0.49455 | +5.398 | +5.406 | PL60*6 | 7-8/F-E | H9
PL60*6 | 0.49455 | +5.415 | +5.423 | PL60*6 | 7-8/F-E | H9
PL60*6 | 0.49455 | +5.415 | +5.423 | PL60*6 | 7-8/F | H9
PL60*6 | 0.49455 | +5.398 | +5.406 | PL60*6 | 7-8/F | H9
UPF-100*50*4 | 0 | +5.298 | +5.399 | UPF-100*50*4 | 7-8/F-E | U10
L100*10 | 0 | +4.752 | +4.962 | L100*10 | 3-4/C-B | H72
UPN120 | 0 | +3.000 | +3.600 | UPN120 | 3/1-F | L116
TUBE-C-70*70*3 | 0 | +3.038 | +3.149 | TUBE-C-70*70*3 | 3-4/1-F | W7
IPEA300 | 10.5911 | +3.023 | +3.342 | IPEA300 | 4-5/8-F | K51
IPEA300 | 10.5911 | +3.023 | +3.356 | IPEA300 | 3-4/1-F | K52
IPEA300 | 10.5911 | +3.023 | +3.352 | IPEA300 | 4/8-F | K53
IPEA300 | 10.5911 | +3.023 | +3.359 | IPEA300 | 3-4/1-F | K50
PL8 | 6.82104 | +4.774 | +4.831 | PL8 | 4-5/A | G7
PL140*10 | 4.47264 | +4.871 | +5.041 | PL140*10 | 4-5/A | H1
L50*5 | 0 | +4.732 | +5.097 | L50*5 | 4-5/B-A | C44
PL8 | 9.49466 | +4.385 | +4.442 | PL8 | 4-5/B-A | G23
4 x L100*10 | 0 | +5.516 | +5.726 | L100*10 | 4/B-A | H71
2 x L100*10 | 0 | +5.533 | +5.743 | L100*10 | 4/A | H71
8 x L100*10 | 0 | +5.516 | +5.726 | L100*10 | 4/C-B | H71
PL10 | 5.67839 | +5.631 | +5.851 | PL10 | 3/C-B | H2
2 x UPN160 | 0 | +3.000 | +3.065 | UPN160 | 3-4/F | L112
L80*8 | 0 | +4.650 | +4.730 | L80*8 | 3/C-B | H59
L70*7 | 0 | +3.817 | +4.650 | L70*7 | 3/C-B | L20
PL8 | 2.19791 | +5.482 | +5.509 | PL8 | 3/C-B | G63
PL8 | 4.80149 | +1.515 | +1.725 | PL8 | 1/C-B | G67
PL200*20 | 22.5756 | -0.400 | -0.165 | PL200*20 | 2-3/C-B | H78
2 x L100*10 | 0 | +3.462 | +3.672 | L100*10 | 3/C-B | H73
2 x L70*7 | 0 | +3.832 | +3.992 | L70*7 | 1/C-B | H37
TUBE-168.3*4.5 | 10.6823 | -0.361 | +3.061 | TUBE-168.3*4.5 | 2-3/C-B | B18
2 x PL50*8 | 0.157 | +3.718 | +3.729 | PL50*8 | 1/D-C | Y3
2 x PL50*8 | 0.157 | +3.708 | +3.719 | PL50*8 | 1-2/D-C | Y3
2 x PL50*8 | 0.157 | +3.698 | +3.708 | PL50*8 | 1-2/D-C | Y3
2 x PL50*8 | 0.157 | +3.688 | +3.698 | PL50*8 | 1-2/D-C | Y3
2 x PL50*8 | 0.157 | +3.678 | +3.688 | PL50*8 | 1-2/D-C | Y3
2 x PL50*8 | 0.157 | +3.667 | +3.678 | PL50*8 | 1-2/D-C | Y3
2 x PL50*8 | 0.157 | +3.586 | +3.597 | PL50*8 | 1-2/D-C | Y3
2 x PL50*8 | 0.157 | +3.596 | +3.607 | PL50*8 | 1-2/D-C | Y3
2 x PL50*8 | 0.157 | +3.606 | +3.617 | PL50*8 | 1-2/D-C | Y3
2 x PL50*8 | 0.157 | +3.617 | +3.627 | PL50*8 | 1-2/D-C | Y3
2 x PL50*8 | 0.157 | +3.627 | +3.637 | PL50*8 | 1-2/D-C | Y3
2 x PL50*8 | 0.157 | +3.637 | +3.648 | PL50*8 | 1-2/D-C | Y3
6 x PL60*8 | 0.22608 | +3.571 | +3.581 | PL60*8 | 1-2/D-C | Y2
2 x PL8 | 2.41204 | +3.410 | +3.424 | PL8 | 2/D-C | G17
2 x PL8 | 2.41204 | +3.728 | +3.742 | PL8 | 1/D-C | G17
PL8 | 7.81314 | +3.648 | +3.667 | PL8 | 1-2/D-C | G58
PL8 | 7.81314 | +3.485 | +3.505 | PL8 | 1-2/D-C | G58
2 x PL8 | 7.66486 | +3.566 | +3.586 | PL8 | 1-2/D-C | G59
PL8 | 1.79922 | +3.570 | +3.582 | PL8 | 1-2/E-D | G60
2 x PL8 | 2.57354 | +3.570 | +3.582 | PL8 | 1-2/C-B | G18
PL8 | 2.57354 | +3.570 | +3.582 | PL8 | 1-2/C | G18
5 x PL8 | 2.57354 | +3.570 | +3.582 | PL8 | 1-2/D-C | G18
PL8 | 1.79922 | +3.570 | +3.582 | PL8 | 1-2/C-B | G60
3 x PL8 | 2.57354 | +3.570 | +3.582 | PL8 | 1-2/E-D | G18
PL8 | 2.57354 | +3.570 | +3.582 | PL8 | 1-2/D | G18
24 x PL60*8 | 0.22608 | +3.381 | +3.391 | PL60*8 | 2-3/D-C | Y2
FPL8*210 | 3.12315 | +3.207 | +3.221 | FPL8*210 | 2/C-B | G83
2 x L50*5 | 0 | +3.301 | +3.439 | L50*5 | 2-3/D-C | C49
2 x L50*5 | 0 | +3.215 | +3.350 | L50*5 | 2-3/D-C | C50
2 x FPL6*50 | 0.393167 | +3.314 | +3.366 | FPL6*50 | 2-3/C-B | H47
2 x FPL6*50 | 0.393167 | +3.312 | +3.364 | FPL6*50 | 2-3/C-B | H47
PL2*340 | 1.25977 | +3.384 | +3.393 | PL2*340 | 2-3/E-D | Y7
2 x FPL6*50 | 0.393167 | +3.314 | +3.366 | FPL6*50 | 2-3/E-D | H47
HEA100 | 0 | +3.290 | +3.389 | HEA100 | 2-3/E-D | N62
5 x L60*6 | 0 | +4.369 | +4.461 | L60*6 | 1-2/C-B | H26
5 x L60*6 | 0 | +4.269 | +4.461 | L60*6 | 1-2/C-B | H21
13 x L60*6 | 0 | +4.269 | +4.461 | L60*6 | 1-2/C-B | H25
4 x UPF-100*50*4 | 0 | +4.365 | +4.465 | UPF-100*50*4 | 1-3/C-B | S81
5 x UPF-100*50*4 | 0 | +4.365 | +4.465 | UPF-100*50*4 | 1-2/C-B | S54
4 x L60*6 | 0 | +4.269 | +4.461 | L60*6 | 2-3/C-B | H25
9 x L60*6 | 0 | +4.369 | +4.461 | L60*6 | 1/E-D | H26
L60*6 | 0 | +4.369 | +4.461 | L60*6 | 1/D | H26
15 x L60*6 | 0 | +4.369 | +4.461 | L60*6 | 1/D-C | H26
L60*6 | 0 | +4.369 | +4.461 | L60*6 | 1/C | H26
7 x L60*6 | 0 | +4.369 | +4.461 | L60*6 | 1/C-B | H26
2 x UPF-100*50*4 | 0 | +4.365 | +4.465 | UPF-100*50*4 | 1/D-C | S72
UPF-100*50*4 | 0 | +4.365 | +4.465 | UPF-100*50*4 | 1/E-D | S71
UPF-100*50*4 | 0 | +4.365 | +4.465 | UPF-100*50*4 | 1/E-D | S48
2 x UPF-100*50*4 | 0 | +4.365 | +4.465 | UPF-100*50*4 | 1/D-C | S70
UPF-100*50*4 | 0 | +4.365 | +4.465 | UPF-100*50*4 | 1/C-B | S69
UPF-100*50*4 | 0 | +4.365 | +4.465 | UPF-100*50*4 | 1/C-B | S43
TUBE-C-100*100*3 | 5.52766 | +10.480 | +10.825 | TUBE-C-100*100*3 | >/B'> | P107
L60*6 | 0 | +4.265 | +4.325 | L60*6 | 2-3/C | H20
TUBE-C-100*100*3 | 7.18432 | +3.386 | +4.265 | TUBE-C-100*100*3 | 2-3/C | P76
IPEA300 | 2.9432 | +3.418 | +4.036 | IPEA300 | 1-2/E-D | K80
PL2*340 | 1.44126 | +3.382 | +3.394 | PL2*340 | 2-3/C | Y6
8 x L60*6 | 0 | +4.269 | +4.461 | L60*6 | 2-3/D-C | H25
2 x L70*7 | 0 | +3.497 | +3.677 | L70*7 | 3/D | H35
5 x L60*6 | 0 | +4.269 | +4.461 | L60*6 | 2-3/E-D | H25
L60*6 | 0 | +4.265 | +4.325 | L60*6 | 2-3/C-B | H20
2 x L70*7 | 0 | +3.812 | +3.992 | L70*7 | 1/D | H35
2 x PL2*340 | 1.44126 | +3.382 | +3.394 | PL2*340 | 2-3/C-B | Y6
3 x L60*6 | 0 | +4.265 | +4.325 | L60*6 | 2-3/D-C | H20
10 x L70*7 | 0 | +3.499 | +3.679 | L70*7 | 3/D-C | H35
7 x PL2*340 | 1.44126 | +3.382 | +3.394 | PL2*340 | 2-3/D-C | Y6
2 x TUBE-C-100*100*3 | 7.18432 | +3.386 | +4.265 | TUBE-C-100*100*3 | 2-3/C-B | P76
10 x L70*7 | 0 | +3.812 | +3.992 | L70*7 | 1/D-C | H35
7 x TUBE-C-100*100*3 | 7.18432 | +3.386 | +4.265 | TUBE-C-100*100*3 | 2-3/D-C | P76
IPEA300 | 2.9432 | +3.418 | +4.036 | IPEA300 | 1-2/D-C | K76
L60*6 | 0 | +4.265 | +4.325 | L60*6 | 2-3/D | H20
TUBE-C-100*100*3 | 7.18432 | +3.386 | +4.265 | TUBE-C-100*100*3 | 2-3/D | P76
PL2*340 | 1.44126 | +3.382 | +3.394 | PL2*340 | 2-3/D | Y6
2 x L60*6 | 0 | +4.265 | +4.325 | L60*6 | 2-3/C-B | H24
IPEA300 | 5.52273 | +3.059 | +3.707 | IPEA300 | 2-3/D | K66
4 x L60*6 | 0 | +4.265 | +4.325 | L60*6 | 2-3/D-C | H24
8 x L70*7 | 0 | +3.812 | +3.992 | L70*7 | 1/E-D | H35
2 x IPEA300 | 9.4689 | +3.059 | +3.708 | IPEA300 | 2-3/D-C | K71
3 x TUBE-C-100*100*3 | 7.18432 | +3.386 | +4.265 | TUBE-C-100*100*3 | 2-3/E-D | P76
3 x L60*6 | 0 | +4.265 | +4.325 | L60*6 | 2-3/E-D | H24
L60*6 | 0 | +4.265 | +4.325 | L60*6 | 2-3/E-D | H20
3 x PL2*340 | 1.44126 | +3.382 | +3.394 | PL2*340 | 2-3/E-D | Y6
IPEA300 | 2.9432 | +3.418 | +4.036 | IPEA300 | 1-2/D-C | K77
5 x TUBE-C-100*100*3 | 7.8018 | +10.479 | +10.865 | TUBE-C-100*100*3 | >/B'> | P72
IPEA300 | 13.0523 | +3.059 | +3.708 | IPEA300 | 2-3/D-C | K69
IPEA300 | 12.185 | +3.059 | +3.708 | IPEA300 | 2-3/D-C | K62
TUBE-C-100*100*3 | 7.18432 | +3.932 | +4.265 | TUBE-C-100*100*3 | 1-2/E-D | P77
3 x TUBE-C-100*100*3 | 7.80298 | +3.932 | +4.365 | TUBE-C-100*100*3 | 1-2/E-D | P62
9 x UPF-100*50*4 | 0 | +4.265 | +4.365 | UPF-100*50*4 | 1-2/E-D | S77
3 x UPF-100*50*4 | 0 | +4.265 | +4.365 | UPF-100*50*4 | 1-2/E-D | S55
3 x PL2*340 | 1.44126 | +3.928 | +3.941 | PL2*340 | 1-2/C-B | Y6
6 x L60*6 | 0 | +4.365 | +4.425 | L60*6 | 1-2/E-D | H24
3 x L60*6 | 0 | +4.265 | +4.325 | L60*6 | 1-2/C-B | H24
3 x L60*6 | 0 | +4.265 | +4.325 | L60*6 | 1-2/E-D | H24
TUBE-C-100*100*3 | 7.18432 | +3.932 | +4.265 | TUBE-C-100*100*3 | 1-2/C-B | P77
20 x L60*6 | 0 | +4.269 | +4.461 | L60*6 | 1-2/E-D | H25
PL2*340 | 1.44126 | +3.928 | +3.941 | PL2*340 | 1-2/C | Y6
7 x PL2*340 | 1.44126 | +3.928 | +3.941 | PL2*340 | 1-2/D-C | Y6
2 x L60*6 | 0 | +4.365 | +4.425 | L60*6 | 1-2/D | H24
TUBE-C-100*100*3 | 7.80298 | +3.932 | +4.365 | TUBE-C-100*100*3 | 1-2/D | P62
12 x UPF-100*50*4 | 0 | +4.265 | +4.365 | UPF-100*50*4 | 1-2/D-C | S76
7 x TUBE-C-100*100*3 | 7.80298 | +3.932 | +4.365 | TUBE-C-100*100*3 | 1-2/D-C | P62
14 x L60*6 | 0 | +4.365 | +4.425 | L60*6 | 1-2/D-C | H24
28 x L60*6 | 0 | +4.269 | +4.461 | L60*6 | 1-2/D-C | H25
PL2*340 | 1.44126 | +3.928 | +3.941 | PL2*340 | 1-2/D | Y6
4 x PL2*340 | 1.44126 | +3.928 | +3.941 | PL2*340 | 1-2/E-D | Y6
12 x UPF-100*50*4 | 0 | +4.265 | +4.365 | UPF-100*50*4 | 1-2/D-C | S78
2 x L60*6 | 0 | +4.365 | +4.425 | L60*6 | 1-2/C | H24
3 x L60*6 | 0 | +4.269 | +4.461 | L60*6 | 1-2/C-B | H27
TUBE-C-100*100*3 | 7.80298 | +3.932 | +4.365 | TUBE-C-100*100*3 | 1-2/C | P62
6 x UPF-100*50*4 | 0 | +4.265 | +4.365 | UPF-100*50*4 | 1-2/C-B | S82
PL2*340 | 1.25977 | +3.384 | +3.393 | PL2*340 | 2-3/C-B | Y7
2 x TUBE-C-100*100*3 | 7.80298 | +3.932 | +4.365 | TUBE-C-100*100*3 | 1-2/C-B | P62
2 x PL8 | 1.45892 | +10.027 | +10.040 | PL8 | >/B'> | G29
TUBE-C-100*100*3 | 5.52765 | +5.407 | +5.810 | TUBE-C-100*100*3 | 7-8/D-C | P106
TUBE-C-100*100*3 | 5.9974 | +5.406 | +5.810 | TUBE-C-100*100*3 | 7'-/C1> | P99
UPF-100*50*4 | 0 | +5.750 | +5.850 | UPF-100*50*4 | 7'-/C1> | S30
2 x PL2*340 | 1.44126 | +5.457 | +5.465 | PL2*340 | 7-8/D-C | Y6
TUBE-C-100*100*3 | 5.52765 | +5.461 | +5.910 | TUBE-C-100*100*3 | 7'-/C1> | P105
2 x PL2*340 | 1.44126 | +5.403 | +5.412 | PL2*340 | 7-8/D-C | Y6
2 x TUBE-C-100*100*3 | 5.9974 | +5.460 | +5.910 | TUBE-C-100*100*3 | 7-8/D-C | P98
TUBE-C-60*60*3 | 1.60768 | +10.281 | +10.363 | TUBE-C-60*60*3 | >/B'> | B10
4 x L60*6 | 0 | +9.967 | +10.124 | L60*6 | >/B'> | C3
6 x L60*6 | 0 | +10.166 | +10.322 | L60*6 | >/B'> | C1
2 x L60*6 | 0 | +9.969 | +10.124 | L60*6 | >/B'> | C1
PL8 | 1.45892 | +10.413 | +10.427 | PL8 | -/B'> | G29
6 x L60*6 | 0 | +10.066 | +10.222 | L60*6 | >/B'> | C1
L60*6 | 0 | +10.263 | +10.419 | L60*6 | ->/B'> | C1
3 x UPF-100*50*4 | 6.83783 | +5.844 | +5.950 | UPF-100*50*4 | 7-8/D-C | S39
2 x TUBE-C-60*60*3 | 1.60768 | +10.084 | +10.166 | TUBE-C-60*60*3 | >/B'> | B10
3 x UPF-100*50*4 | 0 | +10.765 | +10.865 | UPF-100*50*4 | >/B'> | S45
2 x TUBE-C-100*100*3 | 5.9974 | +5.406 | +5.810 | TUBE-C-100*100*3 | 7-8/D-C | P99
8 x UPF-100*50*4 | 0 | +10.865 | +10.965 | UPF-100*50*4 | ->/B'> | S74
8 x UPF-100*50*4 | 0 | +10.865 | +10.965 | UPF-100*50*4 | >/B'> | S73
8 x L60*6 | 0 | +10.869 | +10.961 | L60*6 | >/B'> | H26
2 x L60*6 | 0 | +10.769 | +10.961 | L60*6 | >/B'> | H22
11 x L60*6 | 0 | +10.769 | +10.961 | L60*6 | >/B'> | H27
UPF-100*50*4 | 6.83783 | +5.844 | +5.950 | UPF-100*50*4 | <7'-/C1> | S39
PL2*340 | 1.25977 | +5.458 | +5.464 | PL2*340 | 7-8/D-C | Y7
TUBE-C-100*100*3 | 5.9974 | +5.460 | +5.910 | TUBE-C-100*100*3 | 7'-/C1> | P98
HEA100 | 0 | +5.309 | +5.407 | HEA100 | 7-8/D-C | N54
HEA100 | 0 | +5.363 | +5.461 | HEA100 | 7'-/C1> | N54
HEA100 | 0 | +5.363 | +5.461 | HEA100 | 7-8/D-C | N54
PL2*340 | 1.25977 | +5.404 | +5.411 | PL2*340 | 7-8/D-C | Y7
15 x L60*6 | 0 | +10.769 | +10.961 | L60*6 | >/B'> | H25
UPF-100*50*4 | 0 | +10.765 | +10.865 | UPF-100*50*4 | >/B'> | S60
UPF-100*50*4 | 0 | +5.850 | +5.950 | UPF-100*50*4 | 7'-/C1> | S32
PL2*340 | 1.44126 | +5.457 | +5.465 | PL2*340 | 7'-/C1> | Y6
2 x UPF-100*50*4 | 1.65321 | +5.850 | +5.950 | UPF-100*50*4 | 7'-/C1> | S29
TUBE-C-100*100*3 | 5.52765 | +5.407 | +5.810 | TUBE-C-100*100*3 | 7'-/C1> | P106
UPF-100*50*4 | 0 | +5.850 | +5.950 | UPF-100*50*4 | 7'-/C1> | S36
2 x PL2*340 | 1.25977 | +10.214 | +10.223 | PL2*340 | >/B'> | Y7
6 x L60*6 | 0 | +10.765 | +10.825 | L60*6 | >/B'> | H24
TUBE-C-100*100*3 | 6.71458 | +10.217 | +10.765 | TUBE-C-100*100*3 | >/B'> | P93
6 x L60*6 | 0 | +10.769 | +10.961 | L60*6 | >/B'> | H21
HEA100 | 0 | +10.295 | +10.394 | HEA100 | >/B'> | N60
HEA100 | 0 | +10.470 | +10.570 | HEA100 | -/B'> | N57
TUBE-C-100*100*3 | 5.52765 | +5.461 | +5.910 | TUBE-C-100*100*3 | 7-8/D-C | P105
3 x UPF-100*50*4 | 0 | +5.850 | +5.950 | UPF-100*50*4 | 7-8/D-C | S36
2 x L40*4 | 0 | +5.910 | +5.950 | L40*4 | 7'-/C1> | H55
HEA100 | 0 | +5.309 | +5.407 | HEA100 | 7'-/C1> | N54
4 x L40*4 | 0 | +5.910 | +5.950 | L40*4 | 7-8/D-C | H55
2 x PL2*340 | 1.44126 | +5.511 | +5.519 | PL2*340 | 7-8/D-C | Y6
3 x UPF-100*50*4 | 0 | +5.850 | +5.950 | UPF-100*50*4 | 7-8/D-C | S32
PL2*340 | 1.44126 | +5.403 | +5.412 | PL2*340 | 7'-/C1> | Y6
HEA100 | 0 | +5.308 | +5.416 | HEA100 | <7'/D1-C1 | N52
2 x PL2*340 | 1.44126 | +5.389 | +5.432 | PL2*340 | <7'/D1-C1 | Y6
HEA100 | 0 | +5.308 | +5.416 | HEA100 | <7'/D1-C1> | N53
UPF-100*50*4 | 0 | +5.750 | +5.850 | UPF-100*50*4 | <7'/D1-C1 | S20
2 x FPL6*50 | 0.393167 | +10.493 | +10.545 | FPL6*50 | /B'> | H47
HEA100 | 0 | +10.207 | +10.306 | HEA100 | >/B'> | N56
2 x FPL6*50 | 0.393167 | +10.142 | +10.194 | FPL6*50 | >/B'> | H47
UPF-100*50*4 | 0 | +5.750 | +5.850 | UPF-100*50*4 | <7'/D1-C1 | S27
L60*6 | 0 | +5.850 | +5.910 | L60*6 | <7'/C1> | H24
7 x L60*6 | 0 | +5.754 | +5.946 | L60*6 | <7'/D1-C1 | H25
4 x L60*6 | 0 | +5.850 | +5.910 | L60*6 | <7'/D1-C1 | H24
2 x TUBE-C-100*100*3 | 7.8018 | +5.398 | +5.850 | TUBE-C-100*100*3 | <7'/D1-C1 | P74
TUBE-C-100*100*3 | 7.33206 | +5.405 | +5.850 | TUBE-C-100*100*3 | <7'/C1> | P75
15 x L60*6 | 0 | +10.865 | +10.925 | L60*6 | >/B'> | H24
2 x FPL6*50 | 0.393167 | +10.232 | +10.284 | FPL6*50 | >/B'> | H47
2 x FPL6*50 | 0.393167 | +10.230 | +10.282 | FPL6*50 | >/B'> | H47
5 x TUBE-C-100*100*3 | 7.80298 | +10.216 | +10.865 | TUBE-C-100*100*3 | >/B'> | P63
10 x L100*10 | 0 | +9.916 | +10.126 | L100*10 | >/B'> | H73
5 x TUBE-C-100*100*3 | 7.80298 | +10.391 | +10.865 | TUBE-C-100*100*3 | >/B'> | P64
2 x FPL6*50 | 0.393167 | +10.320 | +10.372 | FPL6*50 | >/B'> | H47
5 x L60*6 | 0 | +10.865 | +10.925 | L60*6 | >/B'> | H20
4 x L60*6 | 0 | +5.750 | +5.810 | L60*6 | 7-8/F-E | H24
UPF-100*50*4 | 0 | +5.750 | +5.850 | UPF-100*50*4 | <7'/D1-C1 | S26
PL2*340 | 1.25977 | +5.112 | +5.121 | PL2*340 | 7-8/F-E | Y7
PL2*340 | 1.25977 | +5.188 | +5.198 | PL2*340 | 7-8/F-E | Y7
PL2*340 | 1.25977 | +5.419 | +5.428 | PL2*340 | 7-8/F-E | Y7
PL2*340 | 1.25977 | +5.342 | +5.351 | PL2*340 | 7-8/F-E | Y7
PL2*340 | 1.25977 | +5.265 | +5.274 | PL2*340 | 7-8/F-E | Y7
PL2*340 | 1.44126 | +5.187 | +5.199 | PL2*340 | 7'-/7'-D1 | Y6
PL2*340 | 1.44126 | +5.263 | +5.276 | PL2*340 | 7'-/7'-D1 | Y6
