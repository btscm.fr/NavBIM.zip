Properties of the parts of a building model (IFC2X3), part 14 of 32

# IfcBeam: PL50*8 (542)
Name | Center of gravity Z (mm) | Center of gravity Y (mm) | Center of gravity X (mm) | Bottom elevation | Top elevation | Phase | Class
CALE | 5199.05 | 26742 | 70143 | +5.191 | +5.207 | 1 | 1009
CALE | 5167.41 | 26394 | 70402 | +5.159 | +5.176 | 1 | 1009
CALE | 5197.77 | 25172 | 70153.5 | +5.190 | +5.206 | 1 | 1009
CALE | 5165.05 | 25532 | 70421.4 | +5.157 | +5.173 | 1 | 1009
CALE | 5298.25 | 25159.6 | 69330.8 | +5.290 | +5.306 | 1 | 1009
CALE | 5334.57 | 25508.7 | 69033.5 | +5.326 | +5.343 | 1 | 1009
CALE | 5465.7 | 26768.8 | 67959.9 | +5.457 | +5.474 | 1 | 1009
CALE | 5429.37 | 26419.8 | 68257.3 | +5.421 | +5.438 | 1 | 1009
CALE | 5425.82 | 25514.4 | 68286.4 | +5.418 | +5.434 | 1 | 1009
CALE | 5465.3 | 25135 | 67963.1 | +5.457 | +5.474 | 1 | 1009
CALE | 5337.14 | 26366.7 | 69012.5 | +5.329 | +5.345 | 1 | 1009
CALE | 5299.63 | 26727.1 | 69319.5 | +5.291 | +5.308 | 1 | 1009
CALE | 5466.21 | 27744.7 | 67955.7 | +5.458 | +5.474 | 1 | 1009
CALE | 5427.59 | 28130.1 | 68271.9 | +5.419 | +5.436 | 1 | 1009
CALE | 5336.25 | 28124.8 | 69019.7 | +5.328 | +5.344 | 1 | 1009
CALE | 5299.14 | 27768.2 | 69323.6 | +5.291 | +5.307 | 1 | 1009
CALE | 5342.15 | 28983 | 68971.4 | +5.334 | +5.350 | 1 | 1009
CALE | 5306.63 | 29337.6 | 69262.2 | +5.298 | +5.315 | 1 | 1009
CALE | 5430.07 | 29026.4 | 68251.6 | +5.422 | +5.438 | 1 | 1009
CALE | 5467.57 | 29386.9 | 67944.6 | +5.459 | +5.476 | 1 | 1009
CALE | 5468.26 | 30341.7 | 67938.9 | +5.460 | +5.476 | 1 | 1009
CALE | 5430.48 | 30732.7 | 68248.2 | +5.422 | +5.439 | 1 | 1009
CALE | 5307.11 | 30367.2 | 69258.3 | +5.299 | +5.315 | 1 | 1009
CALE | 5342.64 | 30721.8 | 68967.4 | +5.334 | +5.351 | 1 | 1009
CALE | 5469.2 | 31985.2 | 67931.2 | +5.461 | +5.477 | 1 | 1009
CALE | 5433.29 | 31626.8 | 68225.2 | +5.425 | +5.442 | 1 | 1009
CALE | 5348.7 | 31579.1 | 68917.8 | +5.340 | +5.357 | 1 | 1009
CALE | 5314.7 | 31931 | 69196.2 | +5.306 | +5.323 | 1 | 1009
CALE | 5468.83 | 32935.8 | 67934.3 | +5.461 | +5.477 | 1 | 1009
CALE | 5432.18 | 33315.1 | 68234.3 | +5.424 | +5.440 | 1 | 1009
CALE | 5314.32 | 32965.1 | 69199.2 | +5.306 | +5.323 | 1 | 1009
CALE | 5347.57 | 33309.2 | 68927 | +5.339 | +5.356 | 1 | 1009
CALE | 5434.64 | 34210.4 | 68214.2 | +5.426 | +5.443 | 1 | 1009
CALE | 5470.15 | 34577.9 | 67923.4 | +5.462 | +5.478 | 1 | 1009
CALE | 5349.84 | 34167.3 | 68908.5 | +5.342 | +5.358 | 1 | 1009
CALE | 5315.08 | 34527.1 | 69193 | +5.307 | +5.323 | 1 | 1009
CALE | 4977.29 | 34067.4 | 71958.6 | +4.969 | +4.985 | 1 | 1009
CALE | 4927.72 | 34346.4 | 72364.4 | +4.920 | +4.936 | 1 | 1009
CALE | 4878.16 | 34625.5 | 72770.2 | +4.870 | +4.886 | 1 | 1009
CALE | 5187.91 | 32881.5 | 70234.2 | +5.180 | +5.196 | 1 | 1009
CALE | 5138.84 | 33157.8 | 70635.9 | +5.131 | +5.147 | 1 | 1009
CALE | 5089.78 | 33434 | 71037.6 | +5.082 | +5.098 | 1 | 1009
CALE | 4877.91 | 32873.1 | 72772.3 | +4.870 | +4.886 | 1 | 1009
CALE | 4925.97 | 33143.7 | 72378.8 | +4.918 | +4.934 | 1 | 1009
CALE | 4974.04 | 33414.3 | 71985.2 | +4.966 | +4.982 | 1 | 1009
CALE | 5094.03 | 34089.9 | 71002.8 | +5.086 | +5.102 | 1 | 1009
CALE | 5142.1 | 34360.5 | 70609.3 | +5.134 | +5.150 | 1 | 1009
CALE | 5190.16 | 34631.2 | 70215.8 | +5.182 | +5.198 | 1 | 1009
CALE | 4835.77 | 3808.13 | 77326.8 | +4.831 | +4.841 | 1 | 1009
CALE | 4847.94 | 3540.96 | 76934.3 | +4.843 | +4.853 | 1 | 1009
CALE | 4860.11 | 3273.79 | 76541.7 | +4.855 | +4.865 | 1 | 1009
CALE | 4872.28 | 3006.62 | 76149.2 | +4.867 | +4.877 | 1 | 1009
CALE | 4823.6 | 4075.3 | 77719.4 | +4.819 | +4.829 | 1 | 1009
CALE | 4811.44 | 4342.47 | 78111.9 | +4.806 | +4.817 | 1 | 1009
CALE | 4799.27 | 4609.64 | 78504.5 | +4.794 | +4.804 | 1 | 1009
CALE | 4872.28 | 2093.38 | 76149.2 | +4.867 | +4.877 | 1 | 1009
CALE | 4860.11 | 1826.21 | 76541.7 | +4.855 | +4.865 | 1 | 1009
CALE | 4847.94 | 1559.04 | 76934.3 | +4.843 | +4.853 | 1 | 1009
CALE | 4835.77 | 1291.87 | 77326.8 | +4.831 | +4.841 | 1 | 1009
CALE | 4823.6 | 1024.7 | 77719.4 | +4.819 | +4.829 | 1 | 1009
CALE | 4811.44 | 757.529 | 78111.9 | +4.806 | +4.817 | 1 | 1009
CALE | 4799.27 | 490.359 | 78504.5 | +4.794 | +4.804 | 1 | 1009
CALE | 5089.06 | 26368 | 71043.5 | +5.081 | +5.097 | 1 | 1009
CALE | 5056.34 | 26728 | 71311.4 | +5.048 | +5.065 | 1 | 1009
CALE | 2598.26 | 11150.3 | 79225 | +2.563 | +2.634 | 1 | 1002
CALE | 373.9 | 12646.5 | 79225 | +0.339 | +0.409 | 1 | 1002
CALE | 3248.8 | 11909.8 | 79225 | +3.214 | +3.284 | 1 | 1002
CALE | 2923.53 | 11530.1 | 79225 | +2.888 | +2.959 | 1 | 1002
CALE | 699.17 | 8933.23 | 79225 | +0.664 | +0.734 | 1 | 1002
CALE | 1024.44 | 9312.97 | 79225 | +0.989 | +1.060 | 1 | 1002
CALE | 1349.71 | 9692.71 | 79225 | +1.314 | +1.385 | 1 | 1002
CALE | 1674.98 | 10072.5 | 79225 | +1.640 | +1.710 | 1 | 1002
CALE | 373.9 | 8553.49 | 79225 | +0.339 | +0.409 | 1 | 1002
CALE | 48.6298 | 8173.75 | 79225 | +0.013 | +0.084 | 1 | 1002
CALE | 3574.07 | 8910.45 | 79225 | +3.539 | +3.609 | 1 | 1002
CALE | 3899.34 | 8530.71 | 79225 | +3.864 | +3.935 | 1 | 1002
CALE | 4224.61 | 8150.97 | 79225 | +4.189 | +4.260 | 1 | 1002
CALE | 3248.8 | 9290.19 | 79225 | +3.214 | +3.284 | 1 | 1002
CALE | 2923.53 | 9669.93 | 79225 | +2.888 | +2.959 | 1 | 1002
CALE | 2598.26 | 10049.7 | 79225 | +2.563 | +2.634 | 1 | 1002
CALE | 3899.34 | 12669.3 | 79225 | +3.864 | +3.935 | 1 | 1002
CALE | 3574.07 | 12289.6 | 79225 | +3.539 | +3.609 | 1 | 1002
CALE | 1674.98 | 11127.5 | 79225 | +1.640 | +1.710 | 1 | 1002
CALE | 1349.71 | 11507.3 | 79225 | +1.314 | +1.385 | 1 | 1002
CALE | 1024.44 | 11887 | 79225 | +0.989 | +1.060 | 1 | 1002
CALE | 699.17 | 12266.8 | 79225 | +0.664 | +0.734 | 1 | 1002
CALE | 4224.61 | 13049 | 79225 | +4.189 | +4.260 | 1 | 1002
CALE | 3632.12 | 31411.5 | 3048.39 | +3.627 | +3.637 | 2 | 2004
CALE | 3642.32 | 31746.3 | 2756.9 | +3.637 | +3.648 | 2 | 2004
CALE | 3601.51 | 30407.2 | 3922.86 | +3.596 | +3.607 | 2 | 2004
CALE | 3591.31 | 30072.5 | 4214.35 | +3.586 | +3.597 | 2 | 2004
CALE | 3642.32 | 32741.2 | 2756.9 | +3.637 | +3.648 | 2 | 2004
CALE | 3632.12 | 33076 | 3048.39 | +3.627 | +3.637 | 2 | 2004
CALE | 3621.92 | 33410.7 | 3339.88 | +3.617 | +3.627 | 2 | 2004
CALE | 3611.72 | 33745.5 | 3631.37 | +3.606 | +3.617 | 2 | 2004
CALE | 3601.51 | 34080.3 | 3922.86 | +3.596 | +3.607 | 2 | 2004
CALE | 3591.31 | 34415 | 4214.35 | +3.586 | +3.597 | 2 | 2004
CALE | 3723.66 | 34415 | 433.132 | +3.718 | +3.729 | 2 | 2004
CALE | 3713.45 | 34080.3 | 724.624 | +3.708 | +3.719 | 2 | 2004
CALE | 3703.25 | 33745.5 | 1016.12 | +3.698 | +3.708 | 2 | 2004
CALE | 3693.05 | 33410.7 | 1307.61 | +3.688 | +3.698 | 2 | 2004
CALE | 3682.85 | 33076 | 1599.1 | +3.678 | +3.688 | 2 | 2004
CALE | 3672.64 | 32741.2 | 1890.59 | +3.667 | +3.678 | 2 | 2004
CALE | 3672.64 | 31746.3 | 1890.59 | +3.667 | +3.678 | 2 | 2004
CALE | 3682.85 | 31411.5 | 1599.1 | +3.678 | +3.688 | 2 | 2004
CALE | 3693.05 | 31076.8 | 1307.61 | +3.688 | +3.698 | 2 | 2004
CALE | 3703.25 | 30742 | 1016.12 | +3.698 | +3.708 | 2 | 2004
CALE | 3713.45 | 30407.2 | 724.624 | +3.708 | +3.719 | 2 | 2004
CALE | 3723.66 | 30072.5 | 433.132 | +3.718 | +3.729 | 2 | 2004
CALE | 5408.04 | 770.528 | 21731.9 | +5.400 | +5.416 | 3 | 3004

# IfcBeam: PL56*3 (17)
In: Undefined
Description: PL56*3; Material: STEEL/E24-2
BaseQuantities - Length: 56 mm; OuterSurfaceArea: 0.006944 m2; NetVolume: 0.000009408 m3; NetWeight: 0.0738528 kg
Tekla Common - Part mark: 1241; Finish: GRENAILLE-PEINT; Grade: E24-2; Profile: PL56*3; sets with these values: 2
Tekla Quantity - Net weight: 0.0738528 kg; Gross weight: 0.0738528 kg; Weight: 0.0738528 kg; Net volume: 0.000009408 m3; Gross volume: 0.000009408 m3; Gross footprint area: 0.000168 m2; Area per tons: 94.0249 m2; Net surface area: 0.006944 m2; Gross area: 0.006944 m2; Height: 56 mm; Width: 3 mm; Length: 56 mm; sets with these values: 2
Name | Center of gravity Z (mm) | Center of gravity Y (mm) | Center of gravity X (mm) | Bottom elevation | Top elevation | Assembly mark | Phase | Class
 | 4760 | 29695 | 55770 | +4.732 | +4.788 | L47 | 1 | 1003
 | 5620 | 29695 | 55770 | +5.592 | +5.648 | L47 | 1 | 1003
 | 5620 | 21895 | 55770 | +5.592 | +5.648 | L47 | 1 | 1003
 | 4760 | 21895 | 55770 | +4.732 | +4.788 | L47 | 1 | 1003
 | 4760 | 21895 | 44095 | +4.732 | +4.788 | L47 | 1 | 1003
 | 4760 | 21895 | 32420 | +4.732 | +4.788 | L47 | 3 | 3003
 | 5620 | 29695 | 32420 | +5.592 | +5.648 | L47 | 3 | 3003
 | 4760 | 29695 | 32420 | +4.732 | +4.788 | L47 | 3 | 3003
 | 4760 | 40083.5 | 20745 | +4.732 | +4.788 | L48 | 2 | 2003
 | 4760 | 29695 | 20745 | +4.732 | +4.788 | L47 | 2 | 2003
 | 5620 | 29695 | 20745 | +5.592 | +5.648 | L47 | 2 | 2003
 | 4760 | 29695 | 44095 | +4.732 | +4.788 | L47 | 1 | 1003
 | 5620 | 29695 | 44095 | +5.592 | +5.648 | L47 | 1 | 1003
 | 5620 | 21895 | 44095 | +5.592 | +5.648 | L47 | 1 | 1003
 | 5620 | 21895 | 32420 | +5.592 | +5.648 | L47 | 3 | 3003
 | 5620 | 40083.5 | 20745 | +5.592 | +5.648 | L48 | 2 | 2003
 | 4760 | 48103.5 | 20745 | +4.732 | +4.788 | N46 | 2 | 2006

# IfcBeam: PL5680*200 (2)
In: Undefined
Description: PL5680*200; Material: CONCRETE/BETON COURANT
Tekla Common - Bottom elevation: -0.000; Top elevation: +5.680; Phase: 10; Class: 75; Grade: BETON COURANT; Profile: PL5680*200; sets with these values: 2
Tekla Quantity - Height: 5680 mm; Width: 200 mm; sets with these values: 2
Name | Center of gravity Z (mm) | Center of gravity Y (mm) | Center of gravity X (mm) | Part mark = Assembly mark | Name | Net weight (kg) = Weight (kg) = NetWeight (kg) | Gross weight (kg) | Net volume (m3) = NetVolume (m3) | Gross volume (m3) | Gross footprint area (m2) | Area per tons (m2) | Net surface area (m2) = OuterSurfaceArea (m2) | Gross area (m2) | Tekla Quantity, Length (mm) = BaseQuantities, Length (mm)
MACONNERIE | 2314.97 | 48715 | 15056.6 | Z40 | MACONNERIE | 21663.4 | 26718.5 | 10.3159 | 12.7231 | 0.19998 | 5.07358 | 109.911 | 133.983 | 11199.9
PREFA | 2324.89 | 10735 | 15161.9 | Z37 | PREFA | 22080.8 | 27136 | 10.5147 | 12.9219 | 0.23498 | 5.07086 | 111.969 | 136.041 | 11374.9

# IfcBeam: PL5920*200, MACONNERIE
In: Undefined
Description: PL5920*200; Material: CONCRETE/BETON COURANT
Tekla Common - Center of gravity Z: 3013.82 mm; Center of gravity Y: 65646.5 mm; Center of gravity X: 22399.9 mm; Bottom elevation: +0.000; Top elevation: +5.920; Part mark: Z47; Assembly mark: Z47; Phase: 10; Class: 75; Grade: BETON COURANT; Profile: PL5920*200; Name: MACONNERIE; sets with these values: 2
Tekla Quantity - Net weight: 15126.3 kg; Gross weight: 16484.8 kg; Weight: 15126.3 kg; Net volume: 7.203 m3; Gross volume: 7.84992 m3; Gross footprint area: 1.001 m2; Area per tons: 5.16436 m2; Net surface area: 78.1176 m2; Gross area: 83.5192 m2; Height: 5920 mm; Width: 200 mm; Length: 6630 mm; sets with these values: 2
BaseQuantities - Length: 6630 mm; OuterSurfaceArea: 78.1176 m2; NetVolume: 7.203 m3; NetWeight: 15126.3 kg

# IfcBeam: PL5940*200, MACONNERIE
In: Undefined
Description: PL5940*200; Material: CONCRETE/BETON COURANT
Tekla Common - Center of gravity Z: 2970 mm; Center of gravity Y: 58725 mm; Center of gravity X: 20639.9 mm; Bottom elevation: +0.000; Top elevation: +5.940; Part mark: Z15; Assembly mark: Z15; Phase: 10; Class: 75; Grade: BETON COURANT; Profile: PL5940*200; Name: MACONNERIE; sets with these values: 2
Tekla Quantity - Net weight: 52889.8 kg; Gross weight: 52889.8 kg; Weight: 52889.8 kg; Net volume: 25.1856 m3; Gross volume: 25.1856 m3; Gross footprint area: 4.24 m2; Area per tons: 4.96716 m2; Net surface area: 262.712 m2; Gross area: 262.712 m2; Height: 5940 mm; Width: 200 mm; Length: 21200 mm; sets with these values: 2
BaseQuantities - Length: 21200 mm; OuterSurfaceArea: 262.712 m2; NetVolume: 25.1856 m3; NetWeight: 52889.8 kg

# IfcBeam: PL5950*200 (4)
In: Undefined
Description: PL5950*200; Material: CONCRETE/BETON COURANT
Tekla Common - Phase: 10; Class: 75; Grade: BETON COURANT; Profile: PL5950*200; Name: MACONNERIE; sets with these values: 2
Tekla Quantity - Width: 200 mm; sets with these values: 2
Name | Center of gravity Z (mm) | Center of gravity Y (mm) | Center of gravity X (mm) | Bottom elevation | Top elevation | Part mark = Assembly mark | Net weight (kg) = Weight (kg) = NetWeight (kg) | Gross weight (kg) | Net volume (m3) = NetVolume (m3) | Gross volume (m3) | Gross footprint area (m2) | Area per tons (m2) | Net surface area (m2) = OuterSurfaceArea (m2) | Gross area (m2) | Height (mm) | Tekla Quantity, Length (mm) = BaseQuantities, Length (mm)
MACONNERIE | 3080.04 | 28845 | 70883.9 | +0.000 | +5.574 | Z50 | 4499.12 | 5314.56 | 2.14244 | 2.70154 | 0 | 5.64399 | 25.393 | 30.3035 | 5573.84 | 2270.2
MACONNERIE | 2326.82 | 25565.4 | 72035 | -0.000 | +5.528 | Z51 | 25773.3 | 31624.8 | 12.273 | 16.2078 | 0 | 5.10562 | 131.589 | 169.906 | 5528.43 | 13620
MACONNERIE | 2561.26 | 32045 | 71418.8 | +0.000 | +5.950 | Z42 | 8119.18 | 10806.6 | 3.86628 | 5.146 | 0.49394 | 5.26808 | 42.7725 | 55.5698 | 5950 | 4324.37
MACONNERIE | 2754.73 | 42674.2 | 69764.9 | +0.000 | +5.561 | Z41 | 64027.7 | 64646.1 | 30.4894 | 32.9392 | 0 | 4.97005 | 318.221 | 342.844 | 5560.67 | 27680

# IfcBeam: PL5960*200, MACONNERIE
In: Undefined
Description: PL5960*200; Material: CONCRETE/BETON COURANT
Tekla Common - Center of gravity Z: 2980 mm; Center of gravity Y: 69225 mm; Center of gravity X: 26532.5 mm; Bottom elevation: -0.000; Top elevation: +5.960; Part mark: Z14; Assembly mark: Z14; Phase: 10; Class: 75; Grade: BETON COURANT; Profile: PL5960*200; Name: MACONNERIE; sets with these values: 2
Tekla Quantity - Net weight: 28999.8 kg; Gross weight: 28999.8 kg; Weight: 28999.8 kg; Net volume: 13.8094 m3; Gross volume: 13.8094 m3; Gross footprint area: 2.31702 m2; Area per tons: 5.00391 m2; Net surface area: 145.112 m2; Gross area: 145.112 m2; Height: 5960 mm; Width: 200 mm; Length: 11585.1 mm; sets with these values: 2
BaseQuantities - Length: 11585.1 mm; OuterSurfaceArea: 145.112 m2; NetVolume: 13.8094 m3; NetWeight: 28999.8 kg

# IfcBeam: PL6*210 (127)
In: Undefined
Description: PL6*210; Material: STEEL/S235JR
Tekla Common - Part mark: 334; Finish: GALVANISE; Grade: S235JR; Profile: PL6*210; Name: TOLE; sets with these values: 2
Tekla Quantity - Net weight: 1.18692 kg; Gross weight: 1.18692 kg; Weight: 1.18692 kg; Net volume: 0.0001512 m3; Gross volume: 0.0001512 m3; Gross footprint area: 0.0252 m2; Area per tons: 45.7992 m2; Net surface area: 0.05436 m2; Gross area: 0.05436 m2; Height: 210 mm; Width: 6 mm; Length: 120 mm; sets with these values: 2
BaseQuantities - Length: 120 mm; OuterSurfaceArea: 0.05436 m2; NetVolume: 0.0001512 m3; NetWeight: 1.18692 kg
Name | Center of gravity Z (mm) | Center of gravity Y (mm) | Center of gravity X (mm) | Bottom elevation | Top elevation | Assembly mark | Phase | Class
TOLE | 10762 | 50520 | 26019 | +10.759 | +10.765 | P91 | 2 | 2007
TOLE | 4362 | 40250 | 8340 | +4.359 | +4.365 | P67 | 2 | 2007
TOLE | 4362 | 40250 | 5691.67 | +4.359 | +4.365 | P66 | 2 | 2007
TOLE | 4362 | 37581.2 | 8340 | +4.359 | +4.365 | P67 | 2 | 2007
TOLE | 4362 | 37581.2 | 5691.67 | +4.359 | +4.365 | P66 | 2 | 2007
TOLE | 4362 | 34912.5 | 8340 | +4.359 | +4.365 | P67 | 2 | 2007
TOLE | 4362 | 34912.5 | 5691.67 | +4.359 | +4.365 | P66 | 2 | 2007
TOLE | 4362 | 32243.8 | 5691.67 | +4.359 | +4.365 | P66 | 2 | 2007
TOLE | 4362 | 32243.8 | 8340 | +4.359 | +4.365 | P67 | 2 | 2007
TOLE | 4362 | 29575 | 8340 | +4.359 | +4.365 | P67 | 2 | 2007
TOLE | 4362 | 29575 | 5691.67 | +4.359 | +4.365 | P66 | 2 | 2007
TOLE | 4362 | 27043.8 | 8340 | +4.359 | +4.365 | P67 | 2 | 2007
TOLE | 4362 | 27043.8 | 5691.67 | +4.359 | +4.365 | P66 | 2 | 2007
TOLE | 4362 | 24512.5 | 8340 | +4.359 | +4.365 | P67 | 2 | 2007
TOLE | 4362 | 24512.5 | 5691.67 | +4.359 | +4.365 | P66 | 2 | 2007
TOLE | 4362 | 21981.2 | 5691.67 | +4.359 | +4.365 | P66 | 2 | 2007
TOLE | 4362 | 21981.2 | 8340 | +4.359 | +4.365 | P67 | 2 | 2007
TOLE | 4362 | 19450 | 5691.67 | +4.359 | +4.365 | P66 | 2 | 2007
TOLE | 4362 | 19450 | 8340 | +4.359 | +4.365 | P67 | 2 | 2007
TOLE | 4362 | 17320 | 5691.67 | +4.359 | +4.365 | P66 | 2 | 2007
TOLE | 4362 | 17320 | 8340 | +4.359 | +4.365 | P67 | 2 | 2007
TOLE | 4362 | 15190 | 5691.67 | +4.359 | +4.365 | P66 | 2 | 2007
TOLE | 4362 | 15190 | 8340 | +4.359 | +4.365 | P67 | 2 | 2007
TOLE | 4362 | 13060 | 5691.67 | +4.359 | +4.365 | P66 | 2 | 2007
TOLE | 4262 | 10930 | 5691.67 | +4.259 | +4.265 | P78 | 2 | 2007
TOLE | 4262 | 10930 | 8340 | +4.259 | +4.265 | P79 | 2 | 2007
TOLE | 4362 | 13060 | 8340 | +4.359 | +4.365 | P67 | 2 | 2007
TOLE | 4262 | 13060 | 10405 | +4.259 | +4.265 | P76 | 2 | 2007
TOLE | 5747 | 18660 | 70600 | +5.744 | +5.750 | P87 | 1 | 1008
TOLE | 5847 | 17090 | 70600 | +5.844 | +5.850 | P71 | 1 | 1008
TOLE | 5847 | 17090 | 68125 | +5.844 | +5.850 | P73 | 1 | 1008
TOLE | 5847 | 14730 | 70600 | +5.844 | +5.850 | P71 | 1 | 1008
TOLE | 5847 | 10010 | 78025 | +5.844 | +5.850 | P68 | 1 | 1008
TOLE | 5847 | 10010 | 75550 | +5.844 | +5.850 | P69 | 1 | 1008
TOLE | 5847 | 10010 | 73075 | +5.844 | +5.850 | P70 | 1 | 1008
TOLE | 5847 | 10010 | 70600 | +5.844 | +5.850 | P71 | 1 | 1008
TOLE | 5847 | 10010 | 68125 | +5.844 | +5.850 | P73 | 1 | 1008
TOLE | 5847 | 7650 | 68125 | +5.844 | +5.850 | P73 | 1 | 1008
TOLE | 5847 | 7650 | 70600 | +5.844 | +5.850 | P71 | 1 | 1008
TOLE | 5847 | 7650 | 73075 | +5.844 | +5.850 | P70 | 1 | 1008
TOLE | 5847 | 7650 | 78025 | +5.844 | +5.850 | P68 | 1 | 1008
TOLE | 5847 | 12370 | 68125 | +5.844 | +5.850 | P73 | 1 | 1008
TOLE | 5847 | 2550 | 78025 | +5.844 | +5.850 | P68 | 1 | 1008
TOLE | 5847 | 2550 | 75550 | +5.844 | +5.850 | P69 | 1 | 1008
TOLE | 5847 | 2550 | 73075 | +5.844 | +5.850 | P70 | 1 | 1008
TOLE | 5847 | 2550 | 70600 | +5.844 | +5.850 | P71 | 1 | 1008
TOLE | 5847 | 2550 | 68125 | +5.844 | +5.850 | P73 | 1 | 1008
TOLE | 5847 | 5100 | 78025 | +5.844 | +5.850 | P68 | 1 | 1008
TOLE | 5847 | 5100 | 75550 | +5.844 | +5.850 | P69 | 1 | 1008
TOLE | 5847 | 5100 | 73075 | +5.844 | +5.850 | P70 | 1 | 1008
TOLE | 5847 | 5100 | 70600 | +5.844 | +5.850 | P71 | 1 | 1008
TOLE | 5847 | 5100 | 68125 | +5.844 | +5.850 | P73 | 1 | 1008
TOLE | 5847 | 7650 | 75550 | +5.844 | +5.850 | P69 | 1 | 1008
TOLE | 5847 | 12370 | 70600 | +5.844 | +5.850 | P71 | 1 | 1008
TOLE | 5747 | 12370 | 75550 | +5.744 | +5.750 | P81 | 1 | 1008
TOLE | 5847 | 14730 | 68125 | +5.844 | +5.850 | P73 | 1 | 1008
TOLE | 5747 | 12370 | 73075 | +5.744 | +5.750 | P80 | 1 | 1008
TOLE | 5747 | 12370 | 78025 | +5.744 | +5.750 | P82 | 1 | 1008
TOLE | 5747 | 650 | 70600 | +5.744 | +5.750 | P87 | 1 | 1008
TOLE | 5747 | 650 | 73075 | +5.744 | +5.750 | P88 | 1 | 1008
TOLE | 5747 | 650 | 75550 | +5.744 | +5.750 | P89 | 1 | 1008
TOLE | 5747 | 650 | 78025 | +5.744 | +5.750 | P90 | 1 | 1008
TOLE | 5847 | 22050 | 70902 | +5.844 | +5.850 | P74 | 1 | 1008
TOLE | 5847 | 24650 | 70902 | +5.844 | +5.850 | P74 | 1 | 1008
TOLE | 5847 | 26545 | 70902 | +5.844 | +5.850 | P75 | 1 | 1008
TOLE | 4362 | 43008.3 | 8340 | +4.359 | +4.365 | P67 | 2 | 2007
TOLE | 4362 | 43008.3 | 5691.67 | +4.359 | +4.365 | P66 | 2 | 2007
TOLE | 4362 | 45766.7 | 8340 | +4.359 | +4.365 | P67 | 2 | 2007
TOLE | 4362 | 45766.7 | 5691.67 | +4.359 | +4.365 | P66 | 2 | 2007
TOLE | 4262 | 11385 | 10405 | +4.259 | +4.265 | P83 | 2 | 2007
TOLE | 4262 | 48525 | 8340 | +4.259 | +4.265 | P79 | 2 | 2007
TOLE | 4262 | 48525 | 5691.67 | +4.259 | +4.265 | P78 | 2 | 2007
TOLE | 4262 | 48065 | 10405 | +4.259 | +4.265 | P83 | 2 | 2007
TOLE | 10762 | 65970 | 28847 | +10.759 | +10.765 | P85 | 2 | 2007
TOLE | 10762 | 65970 | 31675 | +10.759 | +10.765 | P86 | 2 | 2007
TOLE | 10762 | 65970 | 26019 | +10.759 | +10.765 | P84 | 2 | 2007
TOLE | 10862 | 63750 | 31675 | +10.859 | +10.865 | P63 | 2 | 2007
TOLE | 10862 | 63750 | 26019 | +10.859 | +10.865 | P64 | 2 | 2007
TOLE | 10862 | 63750 | 28847 | +10.859 | +10.865 | P65 | 2 | 2007
TOLE | 10862 | 63750 | 23191 | +10.859 | +10.865 | P72 | 2 | 2007
TOLE | 10862 | 60985 | 28847 | +10.859 | +10.865 | P65 | 2 | 2007
TOLE | 10862 | 60985 | 23191 | +10.859 | +10.865 | P72 | 2 | 2007
TOLE | 10862 | 60985 | 26019 | +10.859 | +10.865 | P64 | 2 | 2007
TOLE | 10862 | 60985 | 31675 | +10.859 | +10.865 | P63 | 2 | 2007
TOLE | 10862 | 58220 | 28847 | +10.859 | +10.865 | P65 | 2 | 2007
TOLE | 10862 | 58220 | 23191 | +10.859 | +10.865 | P72 | 2 | 2007
TOLE | 10862 | 58220 | 26019 | +10.859 | +10.865 | P64 | 2 | 2007
TOLE | 10862 | 58220 | 31675 | +10.859 | +10.865 | P63 | 2 | 2007
TOLE | 10862 | 55455 | 28847 | +10.859 | +10.865 | P65 | 2 | 2007
TOLE | 10862 | 55455 | 23191 | +10.859 | +10.865 | P72 | 2 | 2007
TOLE | 10862 | 55455 | 26019 | +10.859 | +10.865 | P64 | 2 | 2007
TOLE | 10862 | 55455 | 31675 | +10.859 | +10.865 | P63 | 2 | 2007
TOLE | 10862 | 52690 | 28847 | +10.859 | +10.865 | P65 | 2 | 2007
TOLE | 10862 | 52690 | 23191 | +10.859 | +10.865 | P72 | 2 | 2007
TOLE | 10862 | 52690 | 26019 | +10.859 | +10.865 | P64 | 2 | 2007
TOLE | 10862 | 52690 | 31675 | +10.859 | +10.865 | P63 | 2 | 2007
TOLE | 10762 | 50520 | 31675 | +10.759 | +10.765 | P93 | 2 | 2007
TOLE | 10762 | 50520 | 28847 | +10.759 | +10.765 | P92 | 2 | 2007
TOLE | 4362 | 45766.7 | 3043.33 | +4.359 | +4.365 | P62 | 2 | 2007
TOLE | 4362 | 43008.3 | 3043.33 | +4.359 | +4.365 | P62 | 2 | 2007
TOLE | 4362 | 40250 | 3043.33 | +4.359 | +4.365 | P62 | 2 | 2007
TOLE | 4362 | 37581.2 | 3043.33 | +4.359 | +4.365 | P62 | 2 | 2007
TOLE | 4362 | 34912.5 | 3043.33 | +4.359 | +4.365 | P62 | 2 | 2007
TOLE | 4362 | 32243.8 | 3043.33 | +4.359 | +4.365 | P62 | 2 | 2007
TOLE | 4362 | 29575 | 3043.33 | +4.359 | +4.365 | P62 | 2 | 2007
TOLE | 4362 | 27043.8 | 3043.33 | +4.359 | +4.365 | P62 | 2 | 2007
TOLE | 4362 | 24512.5 | 3043.33 | +4.359 | +4.365 | P62 | 2 | 2007
TOLE | 4362 | 21981.2 | 3043.33 | +4.359 | +4.365 | P62 | 2 | 2007
TOLE | 4362 | 19450 | 3043.33 | +4.359 | +4.365 | P62 | 2 | 2007
TOLE | 4362 | 17320 | 3043.33 | +4.359 | +4.365 | P62 | 2 | 2007
TOLE | 4362 | 15190 | 3043.33 | +4.359 | +4.365 | P62 | 2 | 2007
TOLE | 4262 | 10930 | 3043.33 | +4.259 | +4.265 | P77 | 2 | 2007
TOLE | 4362 | 13060 | 3043.33 | +4.359 | +4.365 | P62 | 2 | 2007
TOLE | 4262 | 48525 | 3043.33 | +4.259 | +4.265 | P77 | 2 | 2007
TOLE | 4262 | 17320 | 10405 | +4.259 | +4.265 | P76 | 2 | 2007
TOLE | 4262 | 15190 | 10405 | +4.259 | +4.265 | P76 | 2 | 2007
TOLE | 4262 | 21981.2 | 10405 | +4.259 | +4.265 | P76 | 2 | 2007
TOLE | 4262 | 27043.8 | 10405 | +4.259 | +4.265 | P76 | 2 | 2007
TOLE | 4262 | 32243.8 | 10405 | +4.259 | +4.265 | P76 | 2 | 2007
TOLE | 4262 | 37581.2 | 10405 | +4.259 | +4.265 | P76 | 2 | 2007
TOLE | 4262 | 43008.3 | 10405 | +4.259 | +4.265 | P76 | 2 | 2007
TOLE | 4262 | 19450 | 10405 | +4.259 | +4.265 | P76 | 2 | 2007
TOLE | 4262 | 24512.5 | 10405 | +4.259 | +4.265 | P76 | 2 | 2007
TOLE | 4262 | 29575 | 10405 | +4.259 | +4.265 | P76 | 2 | 2007
TOLE | 4262 | 34912.5 | 10405 | +4.259 | +4.265 | P76 | 2 | 2007
TOLE | 4262 | 45766.7 | 10405 | +4.259 | +4.265 | P76 | 2 | 2007
TOLE | 4262 | 40250 | 10405 | +4.259 | +4.265 | P76 | 2 | 2007

# IfcBeam: PL6*240 (32)
In: Undefined
Description: PL6*240; Material: STEEL/E36-3
Tekla Common - Part mark: H8; Assembly mark: H8; Finish: GRENAILLE-PEINT; Grade: E36-3; Profile: PL6*240; Name: ECLISSE; sets with these values: 2
Tekla Quantity - Net weight: 3.73032 kg; Gross weight: 3.73032 kg; Weight: 3.73032 kg; Net volume: 0.0004752 m3; Gross volume: 0.0004752 m3; Gross footprint area: 0.00198 m2; Area per tons: 44.2965 m2; Net surface area: 0.16524 m2; Gross area: 0.16524 m2; Height: 240 mm; Width: 6 mm; Length: 330 mm; sets with these values: 2
BaseQuantities - Length: 330 mm; OuterSurfaceArea: 0.16524 m2; NetVolume: 0.0004752 m3; NetWeight: 3.73032 kg
Name | Center of gravity Z (mm) | Center of gravity Y (mm) | Center of gravity X (mm) | Bottom elevation | Top elevation | Phase | Class
ECLISSE | 4088.5 | 28324.9 | 20844 | +3.968 | +4.208 | 2 | 2006
ECLISSE | 4088.5 | 28324.9 | 20856 | +3.968 | +4.208 | 2 | 2006
ECLISSE | 5741.5 | 28324.9 | 20856 | +5.621 | +5.861 | 2 | 2006
ECLISSE | 5741.5 | 28324.9 | 20844 | +5.621 | +5.861 | 2 | 2006
ECLISSE | 4088.5 | 28324.9 | 67544 | +3.968 | +4.208 | 1 | 1006
ECLISSE | 4088.5 | 28324.9 | 67556 | +3.968 | +4.208 | 1 | 1006
ECLISSE | 5741.5 | 28324.9 | 67556 | +5.621 | +5.861 | 1 | 1006
ECLISSE | 5741.5 | 28324.9 | 67544 | +5.621 | +5.861 | 1 | 1006
ECLISSE | 4088.5 | 52175.1 | 67556 | +3.969 | +4.209 | 1 | 1006
ECLISSE | 4088.5 | 52175.1 | 67544 | +3.969 | +4.209 | 1 | 1006
ECLISSE | 5741.5 | 52175.1 | 67544 | +5.622 | +5.862 | 1 | 1006
ECLISSE | 5741.5 | 52175.1 | 67556 | +5.622 | +5.862 | 1 | 1006
ECLISSE | 4088.5 | 28324.9 | 55869 | +3.968 | +4.208 | 1 | 1006
ECLISSE | 4088.5 | 28324.9 | 55881 | +3.968 | +4.208 | 1 | 1006
ECLISSE | 5741.5 | 28324.9 | 55881 | +5.621 | +5.861 | 1 | 1006
ECLISSE | 5741.5 | 28324.9 | 55869 | +5.621 | +5.861 | 1 | 1006
ECLISSE | 4088.5 | 52175.1 | 55881 | +3.969 | +4.209 | 1 | 1006
ECLISSE | 4088.5 | 52175.1 | 55869 | +3.969 | +4.209 | 1 | 1006
ECLISSE | 5741.5 | 52175.1 | 55869 | +5.622 | +5.862 | 1 | 1006
ECLISSE | 5741.5 | 52175.1 | 55881 | +5.622 | +5.862 | 1 | 1006
ECLISSE | 4088.5 | 28324.9 | 32531 | +3.968 | +4.208 | 3 | 3006
ECLISSE | 4088.5 | 28324.9 | 32519 | +3.968 | +4.208 | 3 | 3006
ECLISSE | 5741.5 | 28324.9 | 32531 | +5.621 | +5.861 | 3 | 3006
ECLISSE | 5741.5 | 28324.9 | 32519 | +5.621 | +5.861 | 3 | 3006
ECLISSE | 4088.5 | 28324.9 | 44194 | +3.968 | +4.209 | 1 | 1006
ECLISSE | 4088.5 | 28324.9 | 44206 | +3.968 | +4.209 | 1 | 1006
ECLISSE | 5741.5 | 28324.9 | 44206 | +5.621 | +5.862 | 1 | 1006
ECLISSE | 5741.5 | 28324.9 | 44194 | +5.621 | +5.862 | 1 | 1006
ECLISSE | 4088.5 | 52175.1 | 44206 | +3.969 | +4.209 | 1 | 1006
ECLISSE | 4088.5 | 52175.1 | 44194 | +3.969 | +4.209 | 1 | 1006
ECLISSE | 5741.5 | 52175.1 | 44194 | +5.622 | +5.862 | 1 | 1006
ECLISSE | 5741.5 | 52175.1 | 44206 | +5.622 | +5.862 | 1 | 1006

# IfcBeam: PL60*10 (6)
In: Undefined
Description: PL60*10; Material: STEEL/E24-2
Tekla Common - Center of gravity Z: 3996.5 mm; Bottom elevation: +3.966; Top elevation: +4.026; Phase: 2; Class: 2006; Finish: GRENAILLE-PEINT; Grade: E24-2; Profile: PL60*10; sets with these values: 2
Tekla Quantity - Height: 60 mm; Width: 10 mm; sets with these values: 2
Name | Center of gravity Y (mm) | Center of gravity X (mm) | Part mark | Assembly mark | Name | Net weight (kg) = Gross weight (kg) = Weight (kg) = NetWeight (kg) | Net volume (m3) = Gross volume (m3) = NetVolume (m3) | Gross footprint area (m2) | Area per tons (m2) | Net surface area (m2) = Gross area (m2) = OuterSurfaceArea (m2) | Tekla Quantity, Length (mm) = BaseQuantities, Length (mm)
PLAT | 18601 | 95 | 291 | N19 | PLAT | 0.2826 | 0.000036 | 0.0006 | 33.9703 | 0.0096 | 60
ATTACHE | 18560 | 105 | H7 | H7 | ATTACHE | 0.66882 | 0.0000852 | 0.00142 | 31.5182 | 0.02108 | 142
PLAT | 18519 | 95 | 291 | N20 | PLAT | 0.2826 | 0.000036 | 0.0006 | 33.9703 | 0.0096 | 60
ATTACHE | 26100 | 105 | H7 | H7 | ATTACHE | 0.66882 | 0.0000852 | 0.00142 | 31.5182 | 0.02108 | 142
PLAT | 26059 | 95 | 291 | N19 | PLAT | 0.2826 | 0.000036 | 0.0006 | 33.9703 | 0.0096 | 60
PLAT | 26141 | 95 | 291 | N21 | PLAT | 0.2826 | 0.000036 | 0.0006 | 33.9703 | 0.0096 | 60

# IfcBeam: PL60*6 (114)
In: Undefined
Description: PL60*6
Tekla Common - Finish: GRENAILLE-PEINT; Profile: PL60*6; sets with these values: 2
Tekla Quantity - Height: 60 mm; Width: 6 mm; sets with these values: 2
Name | Material | Center of gravity Z (mm) | Center of gravity Y (mm) | Center of gravity X (mm) | Bottom elevation | Top elevation | Part mark | Assembly mark | Phase | Class | Grade | Name | Net weight (kg) = Gross weight (kg) = Weight (kg) = NetWeight (kg) | Net volume (m3) = Gross volume (m3) = NetVolume (m3) | Gross footprint area (m2) | Area per tons (m2) | Net surface area (m2) = Gross area (m2) = OuterSurfaceArea (m2) | Tekla Quantity, Length (mm) = BaseQuantities, Length (mm)
PLAT | STEEL/S235JR | 4427.62 | 7580 | 32266.3 | +4.421 | +4.434 | 336 | U11 | 3 | 3003 | S235JR | PLAT | 0.33912 | 0.0000432 | 0 | 48.8323 | 0.01656 | 120
PLAT | STEEL/S235JR | 4470.06 | 7580 | 31918.9 | +4.463 | +4.477 | 336 | U11 | 3 | 3003 | S235JR | PLAT | 0.33912 | 0.0000432 | 0 | 48.8323 | 0.01656 | 120
PLAT | STEEL/S235JR | 4427.62 | 5170 | 32266.3 | +4.421 | +4.434 | 336 | U11 | 3 | 3003 | S235JR | PLAT | 0.33912 | 0.0000432 | 0 | 48.8323 | 0.01656 | 120
PLAT | STEEL/S235JR | 4470.06 | 5170 | 31918.9 | +4.463 | +4.477 | 336 | U11 | 3 | 3003 | S235JR | PLAT | 0.33912 | 0.0000432 | 0 | 48.8323 | 0.01656 | 120
PLAT | STEEL/S235JR | 4427.62 | 19540 | 32266.3 | +4.421 | +4.434 | 336 | U12 | 3 | 3003 | S235JR | PLAT | 0.33912 | 0.0000432 | 0 | 48.8323 | 0.01656 | 120
PLAT | STEEL/S235JR | 4470.06 | 19540 | 31918.9 | +4.463 | +4.477 | 336 | U12 | 3 | 3003 | S235JR | PLAT | 0.33912 | 0.0000432 | 0 | 48.8323 | 0.01656 | 120
PLAT | STEEL/S235JR | 4427.62 | 21980 | 32266.3 | +4.421 | +4.434 | 336 | U12 | 3 | 3003 | S235JR | PLAT | 0.33912 | 0.0000432 | 0 | 48.8323 | 0.01656 | 120
PLAT | STEEL/S235JR | 4470.06 | 21980 | 31918.9 | +4.463 | +4.477 | 336 | U12 | 3 | 3003 | S235JR | PLAT | 0.33912 | 0.0000432 | 0 | 48.8323 | 0.01656 | 120
PLAT | STEEL/S235JR | 4427.62 | 40340 | 32266.3 | +4.421 | +4.434 | 336 | U12 | 3 | 3003 | S235JR | PLAT | 0.33912 | 0.0000432 | 0 | 48.8323 | 0.01656 | 120
PLAT | STEEL/S235JR | 4470.06 | 40340 | 31918.9 | +4.463 | +4.477 | 336 | U12 | 3 | 3003 | S235JR | PLAT | 0.33912 | 0.0000432 | 0 | 48.8323 | 0.01656 | 120
PLAT | STEEL/S235JR | 4427.62 | 42780 | 32266.3 | +4.421 | +4.434 | 336 | U12 | 3 | 3003 | S235JR | PLAT | 0.33912 | 0.0000432 | 0 | 48.8323 | 0.01656 | 120
PLAT | STEEL/S235JR | 4470.06 | 42780 | 31918.9 | +4.463 | +4.477 | 336 | U12 | 3 | 3003 | S235JR | PLAT | 0.33912 | 0.0000432 | 0 | 48.8323 | 0.01656 | 120
PLAT | STEEL/S235JR | 4427.62 | 60965 | 43941.3 | +4.421 | +4.434 | 336 | U13 | 3 | 3003 | S235JR | PLAT | 0.33912 | 0.0000432 | 0 | 48.8323 | 0.01656 | 120
PLAT | STEEL/S235JR | 4482.18 | 60965 | 43494.6 | +4.476 | +4.489 | 336 | U13 | 3 | 3003 | S235JR | PLAT | 0.33912 | 0.0000432 | 0 | 48.8323 | 0.01656 | 120
PLAT | STEEL/S235JR | 4482.18 | 58525 | 43494.6 | +4.476 | +4.489 | 336 | U13 | 3 | 3003 | S235JR | PLAT | 0.33912 | 0.0000432 | 0 | 48.8323 | 0.01656 | 120
PLAT | STEEL/S235JR | 4427.62 | 58525 | 43941.3 | +4.421 | +4.434 | 336 | U13 | 3 | 3003 | S235JR | PLAT | 0.33912 | 0.0000432 | 0 | 48.8323 | 0.01656 | 120
PLAT | STEEL/S235JR | 4470.06 | 42780 | 43593.9 | +4.463 | +4.477 | 336 | U12 | 3 | 3003 | S235JR | PLAT | 0.33912 | 0.0000432 | 0 | 48.8323 | 0.01656 | 120
PLAT | STEEL/S235JR | 4427.62 | 42780 | 43941.3 | +4.421 | +4.434 | 336 | U12 | 3 | 3003 | S235JR | PLAT | 0.33912 | 0.0000432 | 0 | 48.8323 | 0.01656 | 120
PLAT | STEEL/S235JR | 4470.06 | 40340 | 43593.9 | +4.463 | +4.477 | 336 | U12 | 3 | 3003 | S235JR | PLAT | 0.33912 | 0.0000432 | 0 | 48.8323 | 0.01656 | 120
PLAT | STEEL/S235JR | 4427.62 | 40340 | 43941.3 | +4.421 | +4.434 | 336 | U12 | 3 | 3003 | S235JR | PLAT | 0.33912 | 0.0000432 | 0 | 48.8323 | 0.01656 | 120
PLAT | STEEL/S235JR | 4470.06 | 21980 | 43593.9 | +4.463 | +4.477 | 336 | U12 | 3 | 3003 | S235JR | PLAT | 0.33912 | 0.0000432 | 0 | 48.8323 | 0.01656 | 120
PLAT | STEEL/S235JR | 4427.62 | 21980 | 43941.3 | +4.421 | +4.434 | 336 | U12 | 3 | 3003 | S235JR | PLAT | 0.33912 | 0.0000432 | 0 | 48.8323 | 0.01656 | 120
PLAT | STEEL/S235JR | 4470.06 | 19540 | 43593.9 | +4.463 | +4.477 | 336 | U12 | 3 | 3003 | S235JR | PLAT | 0.33912 | 0.0000432 | 0 | 48.8323 | 0.01656 | 120
PLAT | STEEL/S235JR | 4427.62 | 19540 | 43941.3 | +4.421 | +4.434 | 336 | U12 | 3 | 3003 | S235JR | PLAT | 0.33912 | 0.0000432 | 0 | 48.8323 | 0.01656 | 120
PLAT | STEEL/S235JR | 4470.06 | 5170 | 43593.9 | +4.463 | +4.477 | 336 | U11 | 3 | 3003 | S235JR | PLAT | 0.33912 | 0.0000432 | 0 | 48.8323 | 0.01656 | 120
PLAT | STEEL/S235JR | 4427.62 | 5170 | 43941.3 | +4.421 | +4.434 | 336 | U11 | 3 | 3003 | S235JR | PLAT | 0.33912 | 0.0000432 | 0 | 48.8323 | 0.01656 | 120
PLAT | STEEL/S235JR | 4470.06 | 7580 | 43593.9 | +4.463 | +4.477 | 336 | U11 | 3 | 3003 | S235JR | PLAT | 0.33912 | 0.0000432 | 0 | 48.8323 | 0.01656 | 120
PLAT | STEEL/S235JR | 4427.62 | 7580 | 43941.3 | +4.421 | +4.434 | 336 | U11 | 3 | 3003 | S235JR | PLAT | 0.33912 | 0.0000432 | 0 | 48.8323 | 0.01656 | 120
PLAT | STEEL/E24-2 | 3899.4 | 43078.3 | 4102.44 | +3.895 | +3.903 | 346 | U6 | 2 | 2003 | E24-2 | PLAT | 0.33912 | 0.0000432 | 0 | 48.8323 | 0.01656 | 120
PLAT | STEEL/E24-2 | 3929.14 | 43078.3 | 3252.96 | +3.925 | +3.933 | 346 | U6 | 2 | 2003 | E24-2 | PLAT | 0.33912 | 0.0000432 | 0 | 48.8323 | 0.01656 | 120
PLAT | STEEL/E24-2 | 3899.4 | 45696.6 | 4102.44 | +3.895 | +3.903 | 346 | U6 | 2 | 2003 | E24-2 | PLAT | 0.33912 | 0.0000432 | 0 | 48.8323 | 0.01656 | 120
PLAT | STEEL/E24-2 | 3929.14 | 45696.6 | 3252.96 | +3.925 | +3.933 | 346 | U6 | 2 | 2003 | E24-2 | PLAT | 0.33912 | 0.0000432 | 0 | 48.8323 | 0.01656 | 120
PLAT | STEEL/E24-2 | 10562 | 60910 | 20650.2 | +10.558 | +10.566 | 346 | U5 | 2 | 2003 | E24-2 | PLAT | 0.33912 | 0.0000432 | 0 | 48.8323 | 0.01656 | 120
PLAT | STEEL/E24-2 | 10549.6 | 60910 | 21050 | +10.546 | +10.553 | 346 | U5 | 2 | 2003 | E24-2 | PLAT | 0.33912 | 0.0000432 | 0 | 48.8323 | 0.01656 | 120
PLAT | STEEL/E24-2 | 10562 | 58295 | 20650.2 | +10.558 | +10.566 | 346 | U5 | 2 | 2003 | E24-2 | PLAT | 0.33912 | 0.0000432 | 0 | 48.8323 | 0.01656 | 120
PLAT | STEEL/E24-2 | 10549.6 | 58295 | 21050 | +10.546 | +10.553 | 346 | U5 | 2 | 2003 | E24-2 | PLAT | 0.33912 | 0.0000432 | 0 | 48.8323 | 0.01656 | 120
PLAT | STEEL/E24-2 | 10303.4 | 58295 | 28990.1 | +10.299 | +10.307 | 346 | U1 | 2 | 2003 | E24-2 | PLAT | 0.33912 | 0.0000432 | 0 | 48.8323 | 0.01656 | 120
PLAT | STEEL/E24-2 | 10292.6 | 58295 | 29339.9 | +10.289 | +10.296 | 346 | U1 | 2 | 2003 | E24-2 | PLAT | 0.33912 | 0.0000432 | 0 | 48.8323 | 0.01656 | 120
PLAT | STEEL/E24-2 | 10292.6 | 60910 | 29339.9 | +10.289 | +10.296 | 346 | U1 | 2 | 2003 | E24-2 | PLAT | 0.33912 | 0.0000432 | 0 | 48.8323 | 0.01656 | 120
PLAT | STEEL/E24-2 | 10303.4 | 60910 | 28990.1 | +10.299 | +10.307 | 346 | U1 | 2 | 2003 | E24-2 | PLAT | 0.33912 | 0.0000432 | 0 | 48.8323 | 0.01656 | 120
PLAT | STEEL/E24-2 | 3373.96 | 17390 | 9880.79 | +3.370 | +3.378 | 346 | U16 | 2 | 2003 | E24-2 | PLAT | 0.33912 | 0.0000432 | 0 | 48.8323 | 0.01656 | 120
PLAT | STEEL/E24-2 | 3360.01 | 17390 | 9431 | +3.356 | +3.364 | 346 | U16 | 2 | 2003 | E24-2 | PLAT | 0.33912 | 0.0000432 | 0 | 48.8323 | 0.01656 | 120
PLAT | STEEL/E24-2 | 3360.01 | 19380 | 9431 | +3.356 | +3.364 | 346 | U16 | 2 | 2003 | E24-2 | PLAT | 0.33912 | 0.0000432 | 0 | 48.8323 | 0.01656 | 120
PLAT | STEEL/E24-2 | 3373.96 | 19380 | 9880.79 | +3.370 | +3.378 | 346 | U16 | 2 | 2003 | E24-2 | PLAT | 0.33912 | 0.0000432 | 0 | 48.8323 | 0.01656 | 120
PLAT | STEEL/E24-2 | 3373.96 | 29505 | 9880.79 | +3.370 | +3.378 | 346 | U15 | 2 | 2003 | E24-2 | PLAT | 0.33912 | 0.0000432 | 0 | 48.8323 | 0.01656 | 120
PLAT | STEEL/E24-2 | 3360.01 | 29505 | 9431.01 | +3.356 | +3.364 | 346 | U15 | 2 | 2003 | E24-2 | PLAT | 0.33912 | 0.0000432 | 0 | 48.8323 | 0.01656 | 120
PLAT | STEEL/E24-2 | 3373.96 | 27113.7 | 9880.79 | +3.370 | +3.378 | 346 | U15 | 2 | 2003 | E24-2 | PLAT | 0.33912 | 0.0000432 | 0 | 48.8323 | 0.01656 | 120
PLAT | STEEL/E24-2 | 3360.01 | 27113.7 | 9431.01 | +3.356 | +3.364 | 346 | U15 | 2 | 2003 | E24-2 | PLAT | 0.33912 | 0.0000432 | 0 | 48.8323 | 0.01656 | 120
PLAT | STEEL/E24-2 | 3373.96 | 40180 | 9880.79 | +3.370 | +3.378 | 346 | U14 | 2 | 2003 | E24-2 | PLAT | 0.33912 | 0.0000432 | 0 | 48.8323 | 0.01656 | 120
PLAT | STEEL/E24-2 | 3360.01 | 40180 | 9431.01 | +3.356 | +3.364 | 346 | U14 | 2 | 2003 | E24-2 | PLAT | 0.33912 | 0.0000432 | 0 | 48.8323 | 0.01656 | 120
PLAT | STEEL/E24-2 | 3360.01 | 37651.2 | 9431.01 | +3.356 | +3.364 | 346 | U14 | 2 | 2003 | E24-2 | PLAT | 0.33912 | 0.0000432 | 0 | 48.8323 | 0.01656 | 120
PLAT | STEEL/E24-2 | 3373.96 | 37651.2 | 9880.79 | +3.370 | +3.378 | 346 | U14 | 2 | 2003 | E24-2 | PLAT | 0.33912 | 0.0000432 | 0 | 48.8323 | 0.01656 | 120
PLAT | STEEL/E24-2 | 4470.06 | 7580 | 55268.9 | +4.463 | +4.477 | 346 | U2 | 1 | 1003 | E24-2 | PLAT | 0.33912 | 0.0000432 | 0 | 48.8323 | 0.01656 | 120
PLAT | STEEL/E24-2 | 4427.62 | 7580 | 55616.3 | +4.421 | +4.434 | 346 | U2 | 1 | 1003 | E24-2 | PLAT | 0.33912 | 0.0000432 | 0 | 48.8323 | 0.01656 | 120
PLAT | STEEL/E24-2 | 4470.06 | 5170 | 55268.9 | +4.463 | +4.477 | 346 | U2 | 1 | 1003 | E24-2 | PLAT | 0.33912 | 0.0000432 | 0 | 48.8323 | 0.01656 | 120
PLAT | STEEL/E24-2 | 4427.62 | 5170 | 55616.3 | +4.421 | +4.434 | 346 | U2 | 1 | 1003 | E24-2 | PLAT | 0.33912 | 0.0000432 | 0 | 48.8323 | 0.01656 | 120
PLAT | STEEL/E24-2 | 4427.62 | 5170 | 67291.3 | +4.421 | +4.434 | 346 | U2 | 1 | 1003 | E24-2 | PLAT | 0.33912 | 0.0000432 | 0 | 48.8323 | 0.01656 | 120
PLAT | STEEL/E24-2 | 4470.06 | 5170 | 66943.9 | +4.463 | +4.477 | 346 | U2 | 1 | 1003 | E24-2 | PLAT | 0.33912 | 0.0000432 | 0 | 48.8323 | 0.01656 | 120
PLAT | STEEL/E24-2 | 4427.62 | 7580 | 67291.3 | +4.421 | +4.434 | 346 | U2 | 1 | 1003 | E24-2 | PLAT | 0.33912 | 0.0000432 | 0 | 48.8323 | 0.01656 | 120
PLAT | STEEL/E24-2 | 4470.06 | 7580 | 66943.9 | +4.463 | +4.477 | 346 | U2 | 1 | 1003 | E24-2 | PLAT | 0.33912 | 0.0000432 | 0 | 48.8323 | 0.01656 | 120
PLAT | STEEL/E24-2 | 4470.06 | 19540 | 66943.9 | +4.463 | +4.477 | 346 | U3 | 1 | 1003 | E24-2 | PLAT | 0.33912 | 0.0000432 | 0 | 48.8323 | 0.01656 | 120
PLAT | STEEL/E24-2 | 4427.62 | 19540 | 67291.3 | +4.421 | +4.434 | 346 | U3 | 1 | 1003 | E24-2 | PLAT | 0.33912 | 0.0000432 | 0 | 48.8323 | 0.01656 | 120
PLAT | STEEL/E24-2 | 4470.06 | 21980 | 66943.9 | +4.463 | +4.477 | 346 | U3 | 1 | 1003 | E24-2 | PLAT | 0.33912 | 0.0000432 | 0 | 48.8323 | 0.01656 | 120
PLAT | STEEL/E24-2 | 4427.62 | 21980 | 67291.3 | +4.421 | +4.434 | 346 | U3 | 1 | 1003 | E24-2 | PLAT | 0.33912 | 0.0000432 | 0 | 48.8323 | 0.01656 | 120
PLAT | STEEL/E24-2 | 4427.62 | 21980 | 55616.3 | +4.421 | +4.434 | 346 | U3 | 1 | 1003 | E24-2 | PLAT | 0.33912 | 0.0000432 | 0 | 48.8323 | 0.01656 | 120
PLAT | STEEL/E24-2 | 4470.06 | 21980 | 55268.9 | +4.463 | +4.477 | 346 | U3 | 1 | 1003 | E24-2 | PLAT | 0.33912 | 0.0000432 | 0 | 48.8323 | 0.01656 | 120
PLAT | STEEL/E24-2 | 4427.62 | 19540 | 55616.3 | +4.421 | +4.434 | 346 | U3 | 1 | 1003 | E24-2 | PLAT | 0.33912 | 0.0000432 | 0 | 48.8323 | 0.01656 | 120
PLAT | STEEL/E24-2 | 4470.06 | 19540 | 55268.9 | +4.463 | +4.477 | 346 | U3 | 1 | 1003 | E24-2 | PLAT | 0.33912 | 0.0000432 | 0 | 48.8323 | 0.01656 | 120
PLAT | STEEL/E24-2 | 4470.06 | 40340 | 55268.9 | +4.463 | +4.477 | 346 | U3 | 1 | 1003 | E24-2 | PLAT | 0.33912 | 0.0000432 | 0 | 48.8323 | 0.01656 | 120
PLAT | STEEL/E24-2 | 4427.62 | 40340 | 55616.3 | +4.421 | +4.434 | 346 | U3 | 1 | 1003 | E24-2 | PLAT | 0.33912 | 0.0000432 | 0 | 48.8323 | 0.01656 | 120
PLAT | STEEL/E24-2 | 4470.06 | 42780 | 55268.9 | +4.463 | +4.477 | 346 | U3 | 1 | 1003 | E24-2 | PLAT | 0.33912 | 0.0000432 | 0 | 48.8323 | 0.01656 | 120
PLAT | STEEL/E24-2 | 4427.62 | 42780 | 55616.3 | +4.421 | +4.434 | 346 | U3 | 1 | 1003 | E24-2 | PLAT | 0.33912 | 0.0000432 | 0 | 48.8323 | 0.01656 | 120
PLAT | STEEL/E24-2 | 4427.62 | 42780 | 67291.3 | +4.421 | +4.434 | 346 | U3 | 1 | 1003 | E24-2 | PLAT | 0.33912 | 0.0000432 | 0 | 48.8323 | 0.01656 | 120
PLAT | STEEL/E24-2 | 4470.06 | 42780 | 66943.9 | +4.463 | +4.477 | 346 | U3 | 1 | 1003 | E24-2 | PLAT | 0.33912 | 0.0000432 | 0 | 48.8323 | 0.01656 | 120
PLAT | STEEL/E24-2 | 4427.62 | 40340 | 67291.3 | +4.421 | +4.434 | 346 | U3 | 1 | 1003 | E24-2 | PLAT | 0.33912 | 0.0000432 | 0 | 48.8323 | 0.01656 | 120
PLAT | STEEL/E24-2 | 4470.06 | 40340 | 66943.9 | +4.463 | +4.477 | 346 | U3 | 1 | 1003 | E24-2 | PLAT | 0.33912 | 0.0000432 | 0 | 48.8323 | 0.01656 | 120
PLAT | STEEL/E24-2 | 4427.62 | 60980 | 55616.3 | +4.421 | +4.434 | 346 | U4 | 1 | 1003 | E24-2 | PLAT | 0.33912 | 0.0000432 | 0 | 48.8323 | 0.01656 | 120
PLAT | STEEL/E24-2 | 4470.06 | 60980 | 55268.9 | +4.463 | +4.477 | 346 | U4 | 1 | 1003 | E24-2 | PLAT | 0.33912 | 0.0000432 | 0 | 48.8323 | 0.01656 | 120
PLAT | STEEL/E24-2 | 4470.06 | 58520 | 55268.9 | +4.463 | +4.477 | 346 | U4 | 1 | 1003 | E24-2 | PLAT | 0.33912 | 0.0000432 | 0 | 48.8323 | 0.01656 | 120
PLAT | STEEL/E24-2 | 4427.62 | 58520 | 55616.3 | +4.421 | +4.434 | 346 | U4 | 1 | 1003 | E24-2 | PLAT | 0.33912 | 0.0000432 | 0 | 48.8323 | 0.01656 | 120
PLAT | STEEL/E24-2 | 4470.06 | 53180 | 66943.9 | +4.463 | +4.477 | 346 | U4 | 1 | 1003 | E24-2 | PLAT | 0.33912 | 0.0000432 | 0 | 48.8323 | 0.01656 | 120
PLAT | STEEL/E24-2 | 4427.62 | 53180 | 67291.3 | +4.421 | +4.434 | 346 | U4 | 1 | 1003 | E24-2 | PLAT | 0.33912 | 0.0000432 | 0 | 48.8323 | 0.01656 | 120
PLAT | STEEL/E24-2 | 4470.06 | 50720 | 66943.9 | +4.463 | +4.477 | 346 | U4 | 1 | 1003 | E24-2 | PLAT | 0.33912 | 0.0000432 | 0 | 48.8323 | 0.01656 | 120
PLAT | STEEL/E24-2 | 4427.62 | 50720 | 67291.3 | +4.421 | +4.434 | 346 | U4 | 1 | 1003 | E24-2 | PLAT | 0.33912 | 0.0000432 | 0 | 48.8323 | 0.01656 | 120
PLAT | STEEL/E24-2 | 4434.91 | 50580 | 78906.6 | +4.428 | +4.442 | 346 | U4 | 1 | 1003 | E24-2 | PLAT | 0.33912 | 0.0000432 | 0 | 48.8323 | 0.01656 | 120
PLAT | STEEL/E24-2 | 4477.35 | 50580 | 78559.2 | +4.471 | +4.484 | 346 | U4 | 1 | 1003 | E24-2 | PLAT | 0.33912 | 0.0000432 | 0 | 48.8323 | 0.01656 | 120
PLAT | STEEL/E24-2 | 4434.91 | 48120 | 78906.6 | +4.428 | +4.442 | 346 | U4 | 1 | 1003 | E24-2 | PLAT | 0.33912 | 0.0000432 | 0 | 48.8323 | 0.01656 | 120
PLAT | STEEL/E24-2 | 4477.35 | 48120 | 78559.2 | +4.471 | +4.484 | 346 | U4 | 1 | 1003 | E24-2 | PLAT | 0.33912 | 0.0000432 | 0 | 48.8323 | 0.01656 | 120
PLAT | STEEL/E24-2 | 4434.91 | 40180 | 78906.6 | +4.428 | +4.442 | 346 | U4 | 1 | 1003 | E24-2 | PLAT | 0.33912 | 0.0000432 | 0 | 48.8323 | 0.01656 | 120
PLAT | STEEL/E24-2 | 4477.35 | 40180 | 78559.2 | +4.471 | +4.484 | 346 | U4 | 1 | 1003 | E24-2 | PLAT | 0.33912 | 0.0000432 | 0 | 48.8323 | 0.01656 | 120
PLAT | STEEL/E24-2 | 4477.35 | 37720 | 78559.2 | +4.471 | +4.484 | 346 | U4 | 1 | 1003 | E24-2 | PLAT | 0.33912 | 0.0000432 | 0 | 48.8323 | 0.01656 | 120
PLAT | STEEL/E24-2 | 4434.91 | 37720 | 78906.6 | +4.428 | +4.442 | 346 | U4 | 1 | 1003 | E24-2 | PLAT | 0.33912 | 0.0000432 | 0 | 48.8323 | 0.01656 | 120
PLAT | STEEL/E24-2 | 5100.24 | 5170 | 78606.7 | +5.096 | +5.104 | 346 | U2 | 1 | 1003 | E24-2 | PLAT | 0.33912 | 0.0000432 | 0 | 48.8323 | 0.01656 | 120
PLAT | STEEL/E24-2 | 5089.4 | 5170 | 78956.5 | +5.085 | +5.093 | 346 | U2 | 1 | 1003 | E24-2 | PLAT | 0.33912 | 0.0000432 | 0 | 48.8323 | 0.01656 | 120
PLAT | STEEL/E24-2 | 5089.4 | 7580 | 78956.5 | +5.085 | +5.093 | 346 | U2 | 1 | 1003 | E24-2 | PLAT | 0.33912 | 0.0000432 | 0 | 48.8323 | 0.01656 | 120
PLAT | STEEL/E24-2 | 5100.24 | 7580 | 78606.7 | +5.096 | +5.104 | 346 | U2 | 1 | 1003 | E24-2 | PLAT | 0.33912 | 0.0000432 | 0 | 48.8323 | 0.01656 | 120
 | STEEL/S235JR | 5897 | 13550 | 71812 | +5.894 | +5.900 | 351 | L10 | 1 | 1003 | S235JR |  | 0.327816 | 0.00004176 | 0.00696 | 48.9055 | 0.016032 | 116
 | STEEL/S235JR | 5897 | 21970 | 71812 | +5.894 | +5.900 | 350 | L9 | 1 | 1003 | S235JR |  | 0.327816 | 0.00004176 | 0.00696 | 48.9055 | 0.016032 | 116
 | STEEL/S235JR | 5897 | 22130 | 71812 | +5.894 | +5.900 | 350 | L8 | 1 | 1003 | S235JR |  | 0.327816 | 0.00004176 | 0.00696 | 48.9055 | 0.016032 | 116
 | STEEL/S235JR | 5897 | 17170 | 71812 | +5.894 | +5.900 | 350 | L9 | 1 | 1003 | S235JR |  | 0.327816 | 0.00004176 | 0.00696 | 48.9055 | 0.016032 | 116
 | STEEL/S235JR | 5897 | 17010 | 71812 | +5.894 | +5.900 | 350 | L10 | 1 | 1003 | S235JR |  | 0.327816 | 0.00004176 | 0.00696 | 48.9055 | 0.016032 | 116
 | STEEL/E24-2 | 5780 | 19540 | 71761 | +5.720 | +5.840 | 345 | M1 | 1 | 1007 | E24-2 |  | 0.33912 | 0.0000432 | 0.00036 | 48.8323 | 0.01656 | 120
ATTACHE | STEEL/S235JR | 5111.76 | 5002.5 | 78234.7 | +5.108 | +5.116 | H9 | H9 | 3 | 3003 | S235JR | ATTACHE | 0.49455 | 0.000063 | 0 | 48.165 | 0.02382 | 175
ATTACHE | STEEL/S235JR | 5094.72 | 5002.51 | 78784.5 | +5.091 | +5.099 | H9 | H9 | 3 | 3003 | S235JR | ATTACHE | 0.49455 | 0.000063 | 0 | 48.165 | 0.02382 | 175
ATTACHE | STEEL/S235JR | 5111.76 | 2647.5 | 78234.7 | +5.108 | +5.116 | H9 | H9 | 3 | 3003 | S235JR | ATTACHE | 0.49455 | 0.000063 | 0 | 48.165 | 0.02382 | 175
ATTACHE | STEEL/S235JR | 5401.62 | 2452.51 | 68884.5 | +5.398 | +5.406 | H9 | H9 | 3 | 3003 | S235JR | ATTACHE | 0.49455 | 0.000063 | 0 | 48.165 | 0.02382 | 175
ATTACHE | STEEL/S235JR | 5418.66 | 2452.5 | 68334.7 | +5.415 | +5.423 | H9 | H9 | 3 | 3003 | S235JR | ATTACHE | 0.49455 | 0.000063 | 0 | 48.165 | 0.02382 | 175
ATTACHE | STEEL/S235JR | 5418.66 | 97.5 | 68334.7 | +5.415 | +5.423 | H9 | H9 | 3 | 3003 | S235JR | ATTACHE | 0.49455 | 0.000063 | 0 | 48.165 | 0.02382 | 175
ATTACHE | STEEL/S235JR | 5401.62 | 97.4904 | 68884.5 | +5.398 | +5.406 | H9 | H9 | 3 | 3003 | S235JR | ATTACHE | 0.49455 | 0.000063 | 0 | 48.165 | 0.02382 | 175
ATTACHE | STEEL/S235JR | 5094.72 | 2647.49 | 78784.5 | +5.091 | +5.099 | H9 | H9 | 3 | 3003 | S235JR | ATTACHE | 0.49455 | 0.000063 | 0 | 48.165 | 0.02382 | 175
PLAT | STEEL/E24-2 | 10506.9 | 63825 | 22424.6 | +10.503 | +10.511 | 346 | U7 | 4 | 4001 | E24-2 | PLAT | 0.33912 | 0.0000432 | 0 | 48.8323 | 0.01656 | 120
PLAT | STEEL/E24-2 | 10539.5 | 63825 | 21375.1 | +10.536 | +10.543 | 346 | U7 | 4 | 4001 | E24-2 | PLAT | 0.33912 | 0.0000432 | 0 | 48.8323 | 0.01656 | 120
PLAT | STEEL/E24-2 | 10506.9 | 66450 | 22424.6 | +10.503 | +10.511 | 346 | U7 | 4 | 4001 | E24-2 | PLAT | 0.33912 | 0.0000432 | 0 | 48.8323 | 0.01656 | 120
PLAT | STEEL/E24-2 | 10539.5 | 66450 | 21375.1 | +10.536 | +10.543 | 346 | U7 | 4 | 4001 | E24-2 | PLAT | 0.33912 | 0.0000432 | 0 | 48.8323 | 0.01656 | 120

# IfcBeam: PL60*8 (225)
In: Undefined
Description: PL60*8
Tekla Common - Finish: GRENAILLE-PEINT; Profile: PL60*8; sets with these values: 2
Tekla Quantity - Height: 60 mm; Width: 8 mm; sets with these values: 2
Name | Material | Center of gravity Z (mm) | Center of gravity Y (mm) | Center of gravity X (mm) | Bottom elevation | Top elevation | Part mark | Assembly mark | Phase | Class | Grade | Name | Net weight (kg) = Gross weight (kg) = Weight (kg) = NetWeight (kg) | Net volume (m3) = Gross volume (m3) = NetVolume (m3) | Gross footprint area (m2) | Area per tons (m2) | Net surface area (m2) = Gross area (m2) = OuterSurfaceArea (m2) | Tekla Quantity, Length (mm) = BaseQuantities, Length (mm)
CALE | STEEL/E24-2 | 4802.76 | 4375 | 26687.5 | +4.795 | +4.810 | Y2 | Y2 | 3 | 3004 | E24-2 | CALE | 0.22608 | 0.0000288 | 0 | 40.3397 | 0.00912 | 60
 | STEEL/S235JR | 4194 | 13550 | 71929 | +4.164 | +4.224 | 801 | P123 | 1 | 1011 | S235JR |  | 0.7536 | 0.000096 | 0.0016 | 37.3673 | 0.02816 | 200
 | STEEL/S235JR | 4994 | 13550 | 71929 | +4.964 | +5.024 | 801 | P123 | 1 | 1011 | S235JR |  | 0.7536 | 0.000096 | 0.0016 | 37.3673 | 0.02816 | 200
CALE | STEEL/E24-2 | 4802.76 | 34340 | 73387.5 | +4.795 | +4.810 | Y2 | Y2 | 1 | 1009 | E24-2 | CALE | 0.22608 | 0.0000288 | 0 | 40.3397 | 0.00912 | 60
CALE | STEEL/E24-2 | 4802.76 | 33755 | 73387.5 | +4.795 | +4.810 | Y2 | Y2 | 1 | 1009 | E24-2 | CALE | 0.22608 | 0.0000288 | 0 | 40.3397 | 0.00912 | 60
CALE | STEEL/E24-2 | 4802.76 | 33170 | 73387.5 | +4.795 | +4.810 | Y2 | Y2 | 1 | 1009 | E24-2 | CALE | 0.22608 | 0.0000288 | 0 | 40.3397 | 0.00912 | 60
CALE | STEEL/E24-2 | 4802.76 | 38950 | 73387.5 | +4.795 | +4.810 | Y2 | Y2 | 1 | 1004 | E24-2 | CALE | 0.22608 | 0.0000288 | 0 | 40.3397 | 0.00912 | 60
CALE | STEEL/E24-2 | 4802.76 | 39535 | 73387.5 | +4.795 | +4.810 | Y2 | Y2 | 1 | 1004 | E24-2 | CALE | 0.22608 | 0.0000288 | 0 | 40.3397 | 0.00912 | 60
CALE | STEEL/E24-2 | 4802.76 | 38365 | 73387.5 | +4.795 | +4.810 | Y2 | Y2 | 1 | 1004 | E24-2 | CALE | 0.22608 | 0.0000288 | 0 | 40.3397 | 0.00912 | 60
CALE | STEEL/E24-2 | 4802.76 | 35765 | 73387.5 | +4.795 | +4.810 | Y2 | Y2 | 1 | 1004 | E24-2 | CALE | 0.22608 | 0.0000288 | 0 | 40.3397 | 0.00912 | 60
CALE | STEEL/E24-2 | 4802.76 | 36350 | 73387.5 | +4.795 | +4.810 | Y2 | Y2 | 1 | 1004 | E24-2 | CALE | 0.22608 | 0.0000288 | 0 | 40.3397 | 0.00912 | 60
CALE | STEEL/E24-2 | 4802.76 | 36935 | 73387.5 | +4.795 | +4.810 | Y2 | Y2 | 1 | 1004 | E24-2 | CALE | 0.22608 | 0.0000288 | 0 | 40.3397 | 0.00912 | 60
CALE | STEEL/E24-2 | 4802.76 | 44150 | 73387.5 | +4.795 | +4.810 | Y2 | Y2 | 1 | 1004 | E24-2 | CALE | 0.22608 | 0.0000288 | 0 | 40.3397 | 0.00912 | 60
CALE | STEEL/E24-2 | 4802.76 | 44735 | 73387.5 | +4.795 | +4.810 | Y2 | Y2 | 1 | 1004 | E24-2 | CALE | 0.22608 | 0.0000288 | 0 | 40.3397 | 0.00912 | 60
CALE | STEEL/E24-2 | 4802.76 | 49935 | 73387.5 | +4.795 | +4.810 | Y2 | Y2 | 1 | 1004 | E24-2 | CALE | 0.22608 | 0.0000288 | 0 | 40.3397 | 0.00912 | 60
CALE | STEEL/E24-2 | 4802.76 | 49350 | 73387.5 | +4.795 | +4.810 | Y2 | Y2 | 1 | 1004 | E24-2 | CALE | 0.22608 | 0.0000288 | 0 | 40.3397 | 0.00912 | 60
CALE | STEEL/E24-2 | 4802.76 | 48765 | 73387.5 | +4.795 | +4.810 | Y2 | Y2 | 1 | 1004 | E24-2 | CALE | 0.22608 | 0.0000288 | 0 | 40.3397 | 0.00912 | 60
CALE | STEEL/E24-2 | 4802.76 | 51365 | 73387.5 | +4.795 | +4.810 | Y2 | Y2 | 1 | 1004 | E24-2 | CALE | 0.22608 | 0.0000288 | 0 | 40.3397 | 0.00912 | 60
CALE | STEEL/E24-2 | 4802.76 | 51950 | 73387.5 | +4.795 | +4.810 | Y2 | Y2 | 1 | 1004 | E24-2 | CALE | 0.22608 | 0.0000288 | 0 | 40.3397 | 0.00912 | 60
CALE | STEEL/E24-2 | 4802.76 | 52535 | 73387.5 | +4.795 | +4.810 | Y2 | Y2 | 1 | 1004 | E24-2 | CALE | 0.22608 | 0.0000288 | 0 | 40.3397 | 0.00912 | 60
CALE | STEEL/E24-2 | 4802.76 | 53965 | 73387.5 | +4.795 | +4.810 | Y2 | Y2 | 1 | 1004 | E24-2 | CALE | 0.22608 | 0.0000288 | 0 | 40.3397 | 0.00912 | 60
CALE | STEEL/E24-2 | 4802.76 | 54550 | 73387.5 | +4.795 | +4.810 | Y2 | Y2 | 1 | 1004 | E24-2 | CALE | 0.22608 | 0.0000288 | 0 | 40.3397 | 0.00912 | 60
CALE | STEEL/E24-2 | 4802.76 | 55135 | 73387.5 | +4.795 | +4.810 | Y2 | Y2 | 1 | 1004 | E24-2 | CALE | 0.22608 | 0.0000288 | 0 | 40.3397 | 0.00912 | 60
CALE | STEEL/E24-2 | 4802.76 | 57735 | 73387.5 | +4.795 | +4.810 | Y2 | Y2 | 1 | 1004 | E24-2 | CALE | 0.22608 | 0.0000288 | 0 | 40.3397 | 0.00912 | 60
CALE | STEEL/E24-2 | 4802.76 | 57150 | 73387.5 | +4.795 | +4.810 | Y2 | Y2 | 1 | 1004 | E24-2 | CALE | 0.22608 | 0.0000288 | 0 | 40.3397 | 0.00912 | 60
CALE | STEEL/E24-2 | 4802.76 | 59165 | 73387.5 | +4.795 | +4.810 | Y2 | Y2 | 1 | 1004 | E24-2 | CALE | 0.22608 | 0.0000288 | 0 | 40.3397 | 0.00912 | 60
CALE | STEEL/E24-2 | 4802.76 | 59750 | 73387.5 | +4.795 | +4.810 | Y2 | Y2 | 1 | 1004 | E24-2 | CALE | 0.22608 | 0.0000288 | 0 | 40.3397 | 0.00912 | 60
CALE | STEEL/E24-2 | 4802.76 | 60335 | 73387.5 | +4.795 | +4.810 | Y2 | Y2 | 1 | 1004 | E24-2 | CALE | 0.22608 | 0.0000288 | 0 | 40.3397 | 0.00912 | 60
CALE | STEEL/E24-2 | 4802.76 | 62985 | 73387.5 | +4.795 | +4.810 | Y2 | Y2 | 1 | 1004 | E24-2 | CALE | 0.22608 | 0.0000288 | 0 | 40.3397 | 0.00912 | 60
CALE | STEEL/E24-2 | 4802.76 | 62400 | 73387.5 | +4.795 | +4.810 | Y2 | Y2 | 1 | 1004 | E24-2 | CALE | 0.22608 | 0.0000288 | 0 | 40.3397 | 0.00912 | 60
CALE | STEEL/E24-2 | 4802.76 | 42135 | 73387.5 | +4.795 | +4.810 | Y2 | Y2 | 1 | 1004 | E24-2 | CALE | 0.22608 | 0.0000288 | 0 | 40.3397 | 0.00912 | 60
CALE | STEEL/E24-2 | 4802.76 | 41550 | 73387.5 | +4.795 | +4.810 | Y2 | Y2 | 1 | 1004 | E24-2 | CALE | 0.22608 | 0.0000288 | 0 | 40.3397 | 0.00912 | 60
CALE | STEEL/E24-2 | 4802.76 | 43565 | 73387.5 | +4.795 | +4.810 | Y2 | Y2 | 1 | 1004 | E24-2 | CALE | 0.22608 | 0.0000288 | 0 | 40.3397 | 0.00912 | 60
CALE | STEEL/E24-2 | 4802.76 | 40965 | 73387.5 | +4.795 | +4.810 | Y2 | Y2 | 1 | 1004 | E24-2 | CALE | 0.22608 | 0.0000288 | 0 | 40.3397 | 0.00912 | 60
CALE | STEEL/E24-2 | 4802.76 | 46750 | 73387.5 | +4.795 | +4.810 | Y2 | Y2 | 1 | 1004 | E24-2 | CALE | 0.22608 | 0.0000288 | 0 | 40.3397 | 0.00912 | 60
CALE | STEEL/E24-2 | 4802.76 | 47335 | 73387.5 | +4.795 | +4.810 | Y2 | Y2 | 1 | 1004 | E24-2 | CALE | 0.22608 | 0.0000288 | 0 | 40.3397 | 0.00912 | 60
CALE | STEEL/E24-2 | 4802.76 | 46165 | 73387.5 | +4.795 | +4.810 | Y2 | Y2 | 1 | 1004 | E24-2 | CALE | 0.22608 | 0.0000288 | 0 | 40.3397 | 0.00912 | 60
CALE | STEEL/E24-2 | 4802.76 | 56565 | 73387.5 | +4.795 | +4.810 | Y2 | Y2 | 1 | 1004 | E24-2 | CALE | 0.22608 | 0.0000288 | 0 | 40.3397 | 0.00912 | 60
CALE | STEEL/E24-2 | -5.53823 | 69150 | 45016.5 | -0.045 | +0.034 | Y2 | Y2 | 1 | 1002 | E24-2 | CALE | 0.22608 | 0.0000288 | 0 | 40.3397 | 0.00912 | 60
CALE | STEEL/E24-2 | 268.602 | 69150 | 45622.3 | +0.229 | +0.308 | Y2 | Y2 | 1 | 1002 | E24-2 | CALE | 0.22608 | 0.0000288 | 0 | 40.3397 | 0.00912 | 60
CALE | STEEL/E24-2 | 542.742 | 69150 | 46228.2 | +0.503 | +0.582 | Y2 | Y2 | 1 | 1002 | E24-2 | CALE | 0.22608 | 0.0000288 | 0 | 40.3397 | 0.00912 | 60
CALE | STEEL/E24-2 | 816.882 | 69150 | 46834.1 | +0.777 | +0.857 | Y2 | Y2 | 1 | 1002 | E24-2 | CALE | 0.22608 | 0.0000288 | 0 | 40.3397 | 0.00912 | 60
CALE | STEEL/E24-2 | 1091.02 | 69150 | 47439.9 | +1.051 | +1.131 | Y2 | Y2 | 1 | 1002 | E24-2 | CALE | 0.22608 | 0.0000288 | 0 | 40.3397 | 0.00912 | 60
CALE | STEEL/E24-2 | 1365.16 | 69150 | 48045.8 | +1.325 | +1.405 | Y2 | Y2 | 1 | 1002 | E24-2 | CALE | 0.22608 | 0.0000288 | 0 | 40.3397 | 0.00912 | 60
CALE | STEEL/E24-2 | 1639.3 | 69150 | 48651.6 | +1.600 | +1.679 | Y2 | Y2 | 1 | 1002 | E24-2 | CALE | 0.22608 | 0.0000288 | 0 | 40.3397 | 0.00912 | 60
CALE | STEEL/E24-2 | 1913.44 | 69150 | 49257.5 | +1.874 | +1.953 | Y2 | Y2 | 1 | 1002 | E24-2 | CALE | 0.22608 | 0.0000288 | 0 | 40.3397 | 0.00912 | 60
CALE | STEEL/E24-2 | 5059.54 | 69150 | 45019.6 | +5.019 | +5.100 | Y2 | Y2 | 1 | 1002 | E24-2 | CALE | 0.22608 | 0.0000288 | 0 | 40.3397 | 0.00912 | 60
CALE | STEEL/E24-2 | 4721.52 | 69150 | 45626.8 | +4.681 | +4.762 | Y2 | Y2 | 1 | 1002 | E24-2 | CALE | 0.22608 | 0.0000288 | 0 | 40.3397 | 0.00912 | 60
CALE | STEEL/E24-2 | 4383.5 | 69150 | 46234.1 | +4.343 | +4.424 | Y2 | Y2 | 1 | 1002 | E24-2 | CALE | 0.22608 | 0.0000288 | 0 | 40.3397 | 0.00912 | 60
CALE | STEEL/E24-2 | 4045.48 | 69150 | 46841.3 | +4.005 | +4.086 | Y2 | Y2 | 1 | 1002 | E24-2 | CALE | 0.22608 | 0.0000288 | 0 | 40.3397 | 0.00912 | 60
CALE | STEEL/E24-2 | 3707.46 | 69150 | 47448.6 | +3.667 | +3.748 | Y2 | Y2 | 1 | 1002 | E24-2 | CALE | 0.22608 | 0.0000288 | 0 | 40.3397 | 0.00912 | 60
CALE | STEEL/E24-2 | 3369.44 | 69150 | 48055.9 | +3.329 | +3.410 | Y2 | Y2 | 1 | 1002 | E24-2 | CALE | 0.22608 | 0.0000288 | 0 | 40.3397 | 0.00912 | 60
CALE | STEEL/E24-2 | 3031.42 | 69150 | 48663.1 | +2.991 | +3.072 | Y2 | Y2 | 1 | 1002 | E24-2 | CALE | 0.22608 | 0.0000288 | 0 | 40.3397 | 0.00912 | 60
CALE | STEEL/E24-2 | 2693.4 | 69150 | 49270.4 | +2.653 | +2.734 | Y2 | Y2 | 1 | 1002 | E24-2 | CALE | 0.22608 | 0.0000288 | 0 | 40.3397 | 0.00912 | 60
CALE | STEEL/E24-2 | 1912.41 | 69150 | 50819.8 | +1.873 | +1.952 | Y2 | Y2 | 1 | 1002 | E24-2 | CALE | 0.22608 | 0.0000288 | 0 | 40.3397 | 0.00912 | 60
CALE | STEEL/E24-2 | 1636.2 | 69150 | 51430.2 | +1.596 | +1.676 | Y2 | Y2 | 1 | 1002 | E24-2 | CALE | 0.22608 | 0.0000288 | 0 | 40.3397 | 0.00912 | 60
CALE | STEEL/E24-2 | 1359.99 | 69150 | 52040.6 | +1.320 | +1.400 | Y2 | Y2 | 1 | 1002 | E24-2 | CALE | 0.22608 | 0.0000288 | 0 | 40.3397 | 0.00912 | 60
CALE | STEEL/E24-2 | 1083.78 | 69150 | 52651 | +1.044 | +1.123 | Y2 | Y2 | 1 | 1002 | E24-2 | CALE | 0.22608 | 0.0000288 | 0 | 40.3397 | 0.00912 | 60
CALE | STEEL/E24-2 | 807.569 | 69150 | 53261.5 | +0.768 | +0.847 | Y2 | Y2 | 1 | 1002 | E24-2 | CALE | 0.22608 | 0.0000288 | 0 | 40.3397 | 0.00912 | 60
CALE | STEEL/E24-2 | 2551.93 | 8.51035e-17 | 50951.8 | +2.514 | +2.590 | Y2 | Y2 | 1 | 1002 | E24-2 | CALE | 0.22608 | 0.0000288 | 0 | 40.3397 | 0.00912 | 60
CALE | STEEL/E24-2 | 2760.64 | 8.54046e-17 | 51619.9 | +2.723 | +2.798 | Y2 | Y2 | 1 | 1002 | E24-2 | CALE | 0.22608 | 0.0000288 | 0 | 40.3397 | 0.00912 | 60
CALE | STEEL/E24-2 | 2969.35 | -4.06124e-17 | 52288.1 | +2.932 | +3.007 | Y2 | Y2 | 1 | 1002 | E24-2 | CALE | 0.22608 | 0.0000288 | 0 | 40.3397 | 0.00912 | 60
CALE | STEEL/E24-2 | 3178.06 | 2.12326e-16 | 52956.3 | +3.140 | +3.216 | Y2 | Y2 | 1 | 1002 | E24-2 | CALE | 0.22608 | 0.0000288 | 0 | 40.3397 | 0.00912 | 60
CALE | STEEL/E24-2 | 3386.77 | 2.12627e-16 | 53624.4 | +3.349 | +3.424 | Y2 | Y2 | 1 | 1002 | E24-2 | CALE | 0.22608 | 0.0000288 | 0 | 40.3397 | 0.00912 | 60
CALE | STEEL/E24-2 | 3595.48 | 2.12928e-16 | 54292.6 | +3.558 | +3.633 | Y2 | Y2 | 1 | 1002 | E24-2 | CALE | 0.22608 | 0.0000288 | 0 | 40.3397 | 0.00912 | 60
CALE | STEEL/E24-2 | 3804.19 | 8.69108e-17 | 54960.7 | +3.767 | +3.842 | Y2 | Y2 | 1 | 1002 | E24-2 | CALE | 0.22608 | 0.0000288 | 0 | 40.3397 | 0.00912 | 60
CALE | STEEL/E24-2 | -21.0609 | -3.96452e-17 | 55092.7 | -0.061 | +0.019 | Y2 | Y2 | 1 | 1002 | E24-2 | CALE | 0.22608 | 0.0000288 | 0 | 40.3397 | 0.00912 | 60
CALE | STEEL/E24-2 | 255.149 | 8.64342e-17 | 54482.3 | +0.215 | +0.295 | Y2 | Y2 | 1 | 1002 | E24-2 | CALE | 0.22608 | 0.0000288 | 0 | 40.3397 | 0.00912 | 60
CALE | STEEL/E24-2 | 531.359 | -4.01238e-17 | 53871.9 | +0.492 | +0.571 | Y2 | Y2 | 1 | 1002 | E24-2 | CALE | 0.22608 | 0.0000288 | 0 | 40.3397 | 0.00912 | 60
CALE | STEEL/E24-2 | 807.569 | -4.03632e-17 | 53261.5 | +0.768 | +0.847 | Y2 | Y2 | 1 | 1002 | E24-2 | CALE | 0.22608 | 0.0000288 | 0 | 40.3397 | 0.00912 | 60
CALE | STEEL/E24-2 | 1083.78 | -4.06025e-17 | 52651 | +1.044 | +1.123 | Y2 | Y2 | 1 | 1002 | E24-2 | CALE | 0.22608 | 0.0000288 | 0 | 40.3397 | 0.00912 | 60
CALE | STEEL/E24-2 | 1359.99 | -4.0842e-17 | 52040.6 | +1.320 | +1.400 | Y2 | Y2 | 1 | 1002 | E24-2 | CALE | 0.22608 | 0.0000288 | 0 | 40.3397 | 0.00912 | 60
CALE | STEEL/E24-2 | 1636.2 | 8.52374e-17 | 51430.2 | +1.596 | +1.676 | Y2 | Y2 | 1 | 1002 | E24-2 | CALE | 0.22608 | 0.0000288 | 0 | 40.3397 | 0.00912 | 60
CALE | STEEL/E24-2 | 1912.41 | -1.67639e-16 | 50819.8 | +1.873 | +1.952 | Y2 | Y2 | 1 | 1002 | E24-2 | CALE | 0.22608 | 0.0000288 | 0 | 40.3397 | 0.00912 | 60
CALE | STEEL/E24-2 | -46.4703 | -1.70299e-16 | 44940.8 | -0.086 | -0.007 | Y2 | Y2 | 1 | 1002 | E24-2 | CALE | 0.22608 | 0.0000288 | 0 | 40.3397 | 0.00912 | 60
CALE | STEEL/E24-2 | 225.16 | -1.70017e-16 | 45553.3 | +0.186 | +0.265 | Y2 | Y2 | 1 | 1002 | E24-2 | CALE | 0.22608 | 0.0000288 | 0 | 40.3397 | 0.00912 | 60
CALE | STEEL/E24-2 | 496.79 | 8.29029e-17 | 46165.8 | +0.457 | +0.536 | Y2 | Y2 | 1 | 1002 | E24-2 | CALE | 0.22608 | 0.0000288 | 0 | 40.3397 | 0.00912 | 60
CALE | STEEL/E24-2 | 768.42 | -4.31336e-17 | 46778.2 | +0.729 | +0.808 | Y2 | Y2 | 1 | 1002 | E24-2 | CALE | 0.22608 | 0.0000288 | 0 | 40.3397 | 0.00912 | 60
CALE | STEEL/E24-2 | 1040.05 | -4.28514e-17 | 47390.7 | +1.000 | +1.080 | Y2 | Y2 | 1 | 1002 | E24-2 | CALE | 0.22608 | 0.0000288 | 0 | 40.3397 | 0.00912 | 60
CALE | STEEL/E24-2 | 1311.68 | -4.2569e-17 | 48003.2 | +1.272 | +1.351 | Y2 | Y2 | 1 | 1002 | E24-2 | CALE | 0.22608 | 0.0000288 | 0 | 40.3397 | 0.00912 | 60
CALE | STEEL/E24-2 | 1583.31 | -4.22866e-17 | 48615.6 | +1.544 | +1.623 | Y2 | Y2 | 1 | 1002 | E24-2 | CALE | 0.22608 | 0.0000288 | 0 | 40.3397 | 0.00912 | 60
CALE | STEEL/E24-2 | 1854.94 | -4.20045e-17 | 49228.1 | +1.815 | +1.895 | Y2 | Y2 | 1 | 1002 | E24-2 | CALE | 0.22608 | 0.0000288 | 0 | 40.3397 | 0.00912 | 60
CALE | STEEL/E24-2 | 5010.2 | 12942.5 | 71700.1 | +5.005 | +5.015 | Y2 | Y2 | 1 | 1009 | E24-2 | CALE | 0.22608 | 0.0000288 | 0 | 40.3397 | 0.00912 | 60
CALE | STEEL/E24-2 | 5010.2 | 14157.5 | 71700.1 | +5.005 | +5.015 | Y2 | Y2 | 1 | 1009 | E24-2 | CALE | 0.22608 | 0.0000288 | 0 | 40.3397 | 0.00912 | 60
CALE | STEEL/E24-2 | 5010.2 | 3275 | 71700.1 | +5.005 | +5.015 | Y2 | Y2 | 1 | 1009 | E24-2 | CALE | 0.22608 | 0.0000288 | 0 | 40.3397 | 0.00912 | 60
CALE | STEEL/E24-2 | 5010.2 | 3825 | 71700.1 | +5.005 | +5.015 | Y2 | Y2 | 1 | 1009 | E24-2 | CALE | 0.22608 | 0.0000288 | 0 | 40.3397 | 0.00912 | 60
CALE | STEEL/E24-2 | 5010.2 | 4375 | 71700.1 | +5.005 | +5.015 | Y2 | Y2 | 1 | 1009 | E24-2 | CALE | 0.22608 | 0.0000288 | 0 | 40.3397 | 0.00912 | 60
CALE | STEEL/E24-2 | 5132.64 | 1875 | 71703.9 | +5.128 | +5.138 | Y2 | Y2 | 1 | 1009 | E24-2 | CALE | 0.22608 | 0.0000288 | 0 | 40.3397 | 0.00912 | 60
CALE | STEEL/E24-2 | 5132.64 | 1325 | 71703.9 | +5.128 | +5.138 | Y2 | Y2 | 1 | 1009 | E24-2 | CALE | 0.22608 | 0.0000288 | 0 | 40.3397 | 0.00912 | 60
CALE | STEEL/E24-2 | 5132.64 | 775 | 71703.9 | +5.128 | +5.138 | Y2 | Y2 | 1 | 1009 | E24-2 | CALE | 0.22608 | 0.0000288 | 0 | 40.3397 | 0.00912 | 60
