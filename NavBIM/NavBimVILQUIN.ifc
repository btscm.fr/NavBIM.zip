Properties of the parts of a building model (IFC2X3), part 31 of 32

# IfcPlate: PL8*203, GOUSSET
Tekla Common - Center of gravity Z: 5008.94 mm; Center of gravity Y: 27168 mm; Center of gravity X: 71699.5 mm; Bottom elevation: +4.991; Top elevation: +5.033; Part mark: 804; Assembly mark: N5; Phase: 1; Class: 1011; Finish: GRENAILLE-PEINT; Grade: E24-2; Profile: PL8*203; Name: GOUSSET; sets with these values: 2
Tekla Quantity - Net weight: 3.65856 kg; Gross weight: 4.58093 kg; Weight: 3.65856 kg; Net volume: 0.000466059 m3; Gross volume: 0.000466059 m3; Gross footprint area: 0 m2; Area per tons: 34.4282 m2; Net surface area: 0.125958 m2; Gross area: 0.0729448 m2; Height: 203.016 mm; Width: 8 mm; Length: 359.306 mm; sets with these values: 2

# IfcPlate: PL8*204
In: Undefined
Description: PL8*204; Material: STEEL/E24-2
Tekla Common - Center of gravity Z: -348.534 mm; Center of gravity Y: 1.01168e-16 mm; Center of gravity X: 44282.6 mm; Bottom elevation: -0.510; Top elevation: -0.260; Part mark: 856; Assembly mark: P22; Phase: 1; Class: 1001; Finish: GRENAILLE-PEINT; Grade: E24-2; Profile: PL8*204; sets with these values: 2
Tekla Quantity - Net weight: 1.90702 kg; Gross weight: 3.19654 kg; Weight: 1.90702 kg; Net volume: 0.000242933 m3; Gross volume: 0.000242933 m3; Gross footprint area: 0.00143421 m2; Area per tons: 35.0828 m2; Net surface area: 0.0669036 m2; Gross area: 0.0509003 m2; Height: 203.601 mm; Width: 8 mm; Length: 250 mm; sets with these values: 2

# IfcPlate: PL8*207 (4)
In: Undefined
Description: PL8*207; Material: STEEL/E24-2
Tekla Common - Part mark: G26; Assembly mark: G26; Phase: 1; Class: 1002; Finish: GRENAILLE-PEINT; Grade: E24-2; Profile: PL8*207; Name: GOUSSET; sets with these values: 2
Tekla Quantity - Gross footprint area: 0.00048 m2; Area per tons: 34.6866 m2; Width: 8 mm; Length: 220 mm; sets with these values: 2
Name | Center of gravity Z (mm) | Center of gravity Y (mm) | Center of gravity X (mm) | Bottom elevation | Top elevation | Net weight (kg) = Weight (kg) | Gross weight (kg) | Net volume (m3) = Gross volume (m3) | Net surface area (m2) | Gross area (m2) | Height (mm)
GOUSSET | -102.843 | 7650 | 44555.7 | -0.220 | -0.000 | 2.03499 | 2.85587 | 0.000259235 | 0.070587 | 0.0454756 | 206.707
GOUSSET | 3983.12 | 7650 | 55649.3 | +3.880 | +4.100 | 2.035 | 2.85588 | 0.000259236 | 0.0705873 | 0.0454758 | 206.708
GOUSSET | 3983.12 | 61050 | 55649.3 | +3.880 | +4.100 | 2.035 | 2.85588 | 0.000259236 | 0.0705873 | 0.0454758 | 206.708
GOUSSET | -102.843 | 61050 | 44555.7 | -0.220 | +0.000 | 2.03499 | 2.85587 | 0.000259235 | 0.070587 | 0.0454756 | 206.707

# IfcPlate: PL8*208, GOUSSET
In: Undefined
Description: PL8*208; Material: STEEL/E24-2
Tekla Common - Center of gravity Z: 5259.31 mm; Center of gravity Y: 32551.3 mm; Center of gravity X: 69649.6 mm; Bottom elevation: +5.230; Top elevation: +5.288; Part mark: 815; Assembly mark: K99; Phase: 1; Class: 1010; Finish: GRENAILLE-PEINT; Grade: E24-2; Profile: PL8*208; Name: GOUSSET; sets with these values: 2
Tekla Quantity - Net weight: 5.01289 kg; Gross weight: 5.376 kg; Weight: 5.01289 kg; Net volume: 0.000638585 m3; Gross volume: 0.000638585 m3; Gross footprint area: 0 m2; Area per tons: 33.7444 m2; Net surface area: 0.169157 m2; Gross area: 0.085605 m2; Height: 208.223 mm; Width: 8 mm; Length: 411.122 mm; sets with these values: 2

# IfcPlate: PL8*209 (3)
In: Undefined
Description: PL8*209; Material: STEEL/E24-2
Tekla Common - Finish: GRENAILLE-PEINT; Grade: E24-2; Profile: PL8*209; Name: GOUSSET; sets with these values: 2
Tekla Quantity - Width: 8 mm; sets with these values: 2
Name | Center of gravity Z (mm) | Center of gravity Y (mm) | Center of gravity X (mm) | Bottom elevation | Top elevation | Part mark = Assembly mark | Phase | Class | Net weight (kg) = Weight (kg) | Gross weight (kg) | Net volume (m3) = Gross volume (m3) | Gross footprint area (m2) | Area per tons (m2) | Net surface area (m2) | Gross area (m2) | Height (mm) | Length (mm)
GOUSSET | 5442.34 | 50611.6 | 32854 | +5.427 | +5.460 | G15 | 3 | 3004 | 2.89301 | 3.62261 | 0.000368537 | 0 | 34.2365 | 0.0990466 | 0.0576849 | 208.988 | 276.02
GOUSSET | 1620 | 44387.5 | 4.29163e-16 | +1.515 | +1.725 | G67 | 2 | 2002 | 4.80149 | 4.8015 | 0.000611655 | 0.00292426 | 33.7622 | 0.162109 | 0.076457 | 209.166 | 365.532
GOUSSET | 5442.34 | 69111.6 | 32854 | +5.427 | +5.460 | G15 | 3 | 3004 | 2.89301 | 3.62261 | 0.000368537 | 0 | 34.2365 | 0.0990466 | 0.0576849 | 208.988 | 276.02

# IfcPlate: PL8*210 (11)
In: Undefined
Description: PL8*210; Material: STEEL/E24-2
Tekla Common - Finish: GRENAILLE-PEINT; Grade: E24-2; Profile: PL8*210; sets with these values: 2
Tekla Quantity - Width: 8 mm; sets with these values: 2
Name | Center of gravity Z (mm) | Center of gravity Y (mm) | Center of gravity X (mm) | Bottom elevation | Top elevation | Part mark | Assembly mark | Phase | Class | Name | Net weight (kg) = Weight (kg) | Gross weight (kg) | Net volume (m3) = Gross volume (m3) | Gross footprint area (m2) | Area per tons (m2) | Net surface area (m2) | Gross area (m2) | Height (mm) | Length (mm)
GOUSSET | 4104.31 | 69122.8 | 44080.9 | +4.086 | +4.123 | 771 | P26 | 1 | 1001 | GOUSSET | 2.98519 | 3.16111 | 0.000380279 | 0 | 34.1403 | 0.101915 | 0.0503361 | 210.009 | 239.685
GOUSSET | 4104.31 | 69122.8 | 67430.9 | +4.086 | +4.123 | 771 | P23 | 1 | 1001 | GOUSSET | 2.98519 | 3.16111 | 0.000380279 | 0 | 34.1403 | 0.101915 | 0.0503361 | 210.009 | 239.685
GOUSSET | 4104.31 | 27.1866 | 67430.9 | +4.086 | +4.123 | 769 | P24 | 1 | 1001 | GOUSSET | 2.98519 | 3.16111 | 0.000380279 | 0 | 34.1403 | 0.101915 | 0.0503361 | 210.009 | 239.685
GOUSSET | 4104.31 | 69122.8 | 55755.9 | +4.086 | +4.123 | 771 | P27 | 1 | 1001 | GOUSSET | 2.98519 | 3.16111 | 0.000380279 | 0 | 34.1403 | 0.101915 | 0.0503361 | 210.009 | 239.685
GOUSSET | 4104.31 | 27.1866 | 55755.9 | +4.086 | +4.123 | 769 | P25 | 1 | 1001 | GOUSSET | 2.98519 | 3.16111 | 0.000380279 | 0 | 34.1403 | 0.101915 | 0.0503361 | 210.009 | 239.685
GOUSSET | 4104.31 | 27.1866 | 44080.9 | +4.086 | +4.123 | 769 | P22 | 1 | 1001 | GOUSSET | 2.98519 | 3.16111 | 0.000380279 | 0 | 34.1403 | 0.101915 | 0.0503361 | 210.009 | 239.685
GOUSSET | 5336.38 | 7650 | 44556.4 | +5.239 | +5.459 | G25 | G25 | 1 | 1002 | GOUSSET | 2.05316 | 2.89667 | 0.000261549 | 0.00048 | 34.7037 | 0.0712521 | 0.0461253 | 209.661 | 220
GOUSSET | -97.0151 | 7650 | 55648.6 | -0.220 | -0.000 | G25 | G25 | 1 | 1002 | GOUSSET | 2.05316 | 2.89668 | 0.000261549 | 0.00048 | 34.7037 | 0.0712522 | 0.0461254 | 209.661 | 220
GOUSSET | 5336.38 | 61050 | 44556.4 | +5.239 | +5.459 | G25 | G25 | 1 | 1002 | GOUSSET | 2.05316 | 2.89667 | 0.000261549 | 0.00048 | 34.7037 | 0.0712521 | 0.0461253 | 209.661 | 220
GOUSSET | -97.0151 | 61050 | 55648.6 | -0.220 | +0.000 | G25 | G25 | 1 | 1002 | GOUSSET | 2.05316 | 2.89668 | 0.000261549 | 0.00048 | 34.7037 | 0.0712522 | 0.0461254 | 209.661 | 220
ATTACHE | 3627.88 | 10022 | 9116.3 | +3.498 | +3.714 | 680 | L52 | 2 | 2003 | ATTACHE | 1.53581 | 2.07912 | 0.000195644 | 0 | 35.27 | 0.054168 | 0.033107 | 209.939 | 157.698

# IfcPlate: PL8*211, GOUSSET
In: Undefined
Description: PL8*211; Material: STEEL/E24-2
Tekla Common - Center of gravity Z: 5442.18 mm; Center of gravity Y: 63789.1 mm; Center of gravity X: 32855.3 mm; Bottom elevation: +5.427; Top elevation: +5.460; Part mark: G16; Assembly mark: G16; Phase: 3; Class: 3004; Finish: GRENAILLE-PEINT; Grade: E24-2; Profile: PL8*211; Name: GOUSSET; sets with these values: 2
Tekla Quantity - Net weight: 2.93801 kg; Gross weight: 3.68768 kg; Weight: 2.93801 kg; Net volume: 0.000374269 m3; Gross volume: 0.000374269 m3; Gross footprint area: 0 m2; Area per tons: 34.2195 m2; Net surface area: 0.100537 m2; Gross area: 0.058721 m2; Height: 211.158 mm; Width: 8 mm; Length: 278.09 mm; sets with these values: 2

# IfcPlate: PL8*212 (5)
In: Undefined
Description: PL8*212; Material: STEEL/E24-2
Tekla Common - Center of gravity Z: 5501.21 mm; Bottom elevation: +5.482; Top elevation: +5.519; Phase: 1; Class: 1001; Finish: GRENAILLE-PEINT; Grade: E24-2; Profile: PL8*212; Name: GOUSSET; sets with these values: 2
Tekla Quantity - Net weight: 3.00945 kg; Gross weight: 3.18532 kg; Weight: 3.00945 kg; Net volume: 0.00038337 m3; Gross volume: 0.00038337 m3; Gross footprint area: 0 m2; Area per tons: 34.1304 m2; Net surface area: 0.102714 m2; Gross area: 0.0507216 m2; Height: 211.603 mm; Width: 8 mm; Length: 239.701 mm; sets with these values: 2
Name | Center of gravity Y (mm) | Center of gravity X (mm) | Part mark | Assembly mark
GOUSSET | 69122.8 | 55994.1 | 770 | P27
GOUSSET | 27.1812 | 55994.1 | 768 | P25
GOUSSET | 69122.8 | 44319.1 | 770 | P26
GOUSSET | 27.1812 | 44319.1 | 768 | P22
GOUSSET | 69122.8 | 67669.1 | 770 | P23

# IfcPlate: PL8*216, GOUSSET
In: Undefined
Description: PL8*216; Material: STEEL/E24-2
Tekla Common - Center of gravity Z: 4816.62 mm; Center of gravity Y: 32554.6 mm; Center of gravity X: 73274 mm; Bottom elevation: +4.795; Top elevation: +4.839; Part mark: 846; Assembly mark: K99; Phase: 1; Class: 1010; Finish: GRENAILLE-PEINT; Grade: E24-2; Profile: PL8*216; Name: GOUSSET; sets with these values: 2
Tekla Quantity - Net weight: 3.75775 kg; Gross weight: 4.05343 kg; Weight: 3.75775 kg; Net volume: 0.000478695 m3; Gross volume: 0.000478695 m3; Gross footprint area: 0 m2; Area per tons: 33.942 m2; Net surface area: 0.127546 m2; Gross area: 0.064545 m2; Height: 216 mm; Width: 8 mm; Length: 298.819 mm; sets with these values: 2

# IfcPlate: PL8*217 (52)
In: Undefined
Description: PL8*217; Material: STEEL/E24-2
Tekla Common - Finish: GRENAILLE-PEINT; Grade: E24-2; Profile: PL8*217; sets with these values: 2
Tekla Quantity - Width: 8 mm; sets with these values: 2
Name | Center of gravity Z (mm) | Center of gravity Y (mm) | Center of gravity X (mm) | Bottom elevation | Top elevation | Part mark | Assembly mark | Phase | Class | Name | Net weight (kg) = Weight (kg) | Gross weight (kg) | Net volume (m3) = Gross volume (m3) | Gross footprint area (m2) | Area per tons (m2) | Net surface area (m2) | Gross area (m2) | Height (mm) | Length (mm)
GOUSSET | 5503.08 | 32450 | 67653.9 | +5.485 | +5.519 | 843 | N7 | 1 | 1006 | GOUSSET | 3.4267 | 3.74858 | 0.000436522 | 0 | 33.9128 | 0.116209 | 0.0596908 | 216.581 | 275.605
GOUSSET | 5503.07 | 27250 | 67653.9 | +5.485 | +5.519 | 842 | N11 | 1 | 1006 | GOUSSET | 3.4267 | 3.74858 | 0.000436522 | 0 | 33.9128 | 0.116209 | 0.0596908 | 216.581 | 275.605
GOUSSET | 5503.08 | 45450 | 32628.9 | +5.485 | +5.519 | 837 | N43 | 3 | 3003 | GOUSSET | 3.4267 | 3.74858 | 0.000436522 | 0 | 33.9128 | 0.116209 | 0.0596908 | 216.581 | 275.605
GOUSSET | 5503.08 | 35050 | 32628.9 | +5.485 | +5.519 | 837 | N40 | 3 | 3006 | GOUSSET | 3.4267 | 3.74858 | 0.000436522 | 0 | 33.9128 | 0.116209 | 0.0596908 | 216.581 | 275.605
GOUSSET | 5503.08 | 29850 | 32628.9 | +5.485 | +5.519 | 837 | N40 | 3 | 3006 | GOUSSET | 3.4267 | 3.74858 | 0.000436522 | 0 | 33.9128 | 0.116209 | 0.0596908 | 216.581 | 275.605
GOUSSET | 5503.07 | 24650 | 67653.9 | +5.485 | +5.519 | 840 | N11 | 1 | 1006 | GOUSSET | 3.4267 | 3.74858 | 0.000436522 | 0 | 33.9128 | 0.116209 | 0.0596908 | 216.581 | 275.605
GOUSSET | 4102.18 | 63754.4 | 67448.4 | +4.086 | +4.120 | 831 | N17 | 1 | 1006 | GOUSSET | 3.24094 | 3.72689 | 0.000412858 | 0 | 33.9917 | 0.110165 | 0.0593453 | 216.581 | 274.01
GOUSSET | 5503.08 | 55850 | 55978.9 | +5.485 | +5.519 | 837 | N13 | 1 | 1006 | GOUSSET | 3.4267 | 3.74858 | 0.000436522 | 0 | 33.9128 | 0.116209 | 0.0596908 | 216.581 | 275.605
GOUSSET | 5503.08 | 45450 | 55978.9 | +5.485 | +5.519 | 837 | N41 | 1 | 1006 | GOUSSET | 3.4267 | 3.74858 | 0.000436522 | 0 | 33.9128 | 0.116209 | 0.0596908 | 216.581 | 275.605
GOUSSET | 5503.08 | 50650 | 55978.9 | +5.485 | +5.519 | 837 | N41 | 1 | 1006 | GOUSSET | 3.4267 | 3.74858 | 0.000436522 | 0 | 33.9128 | 0.116209 | 0.0596908 | 216.581 | 275.605
GOUSSET | 5503.08 | 10010 | 55978.9 | +5.485 | +5.519 | 836 | N47 | 1 | 1006 | GOUSSET | 3.4267 | 3.74858 | 0.000436522 | 0 | 33.9128 | 0.116209 | 0.0596908 | 216.581 | 275.605
GOUSSET | 5503.08 | 10010 | 32628.9 | +5.485 | +5.519 | 836 | N48 | 3 | 3006 | GOUSSET | 3.4267 | 3.74858 | 0.000436522 | 0 | 33.9128 | 0.116209 | 0.0596908 | 216.581 | 275.605
GOUSSET | 4102.18 | 5095.64 | 32423.4 | +4.086 | +4.120 | 830 | N15 | 3 | 3006 | GOUSSET | 3.24094 | 3.72689 | 0.000412858 | 0 | 33.9917 | 0.110165 | 0.0593453 | 216.581 | 274.01
GOUSSET | 5503.08 | 29850 | 20953.9 | +5.485 | +5.519 | 837 | N44 | 2 | 2006 | GOUSSET | 3.4267 | 3.74858 | 0.000436522 | 0 | 33.9128 | 0.116209 | 0.0596908 | 216.581 | 275.605
GOUSSET | 5503.08 | 24650 | 20953.9 | +5.485 | +5.519 | 837 | N45 | 2 | 2006 | GOUSSET | 3.4267 | 3.74858 | 0.000436522 | 0 | 33.9128 | 0.116209 | 0.0596908 | 216.581 | 275.605
GOUSSET | 5503.08 | 10010 | 20953.9 | +5.485 | +5.519 | 836 | N49 | 2 | 2006 | GOUSSET | 3.4267 | 3.74858 | 0.000436522 | 0 | 33.9128 | 0.116209 | 0.0596908 | 216.581 | 275.605
GOUSSET | 5503.08 | 55850 | 67653.9 | +5.485 | +5.519 | 837 | N13 | 1 | 1006 | GOUSSET | 3.4267 | 3.74858 | 0.000436522 | 0 | 33.9128 | 0.116209 | 0.0596908 | 216.581 | 275.605
GOUSSET | 5503.08 | 50650 | 67653.9 | +5.485 | +5.519 | 837 | N6 | 1 | 1006 | GOUSSET | 3.4267 | 3.74858 | 0.000436522 | 0 | 33.9128 | 0.116209 | 0.0596908 | 216.581 | 275.605
GOUSSET | 5503.08 | 45450 | 67653.9 | +5.485 | +5.519 | 837 | N6 | 1 | 1006 | GOUSSET | 3.4267 | 3.74858 | 0.000436522 | 0 | 33.9128 | 0.116209 | 0.0596908 | 216.581 | 275.605
GOUSSET | 5503.08 | 35050 | 67653.9 | +5.485 | +5.519 | 841 | N7 | 1 | 1006 | GOUSSET | 3.4267 | 3.74858 | 0.000436522 | 0 | 33.9128 | 0.116209 | 0.0596908 | 216.581 | 275.605
GOUSSET | 4102.18 | 5095.64 | 55773.4 | +4.086 | +4.120 | 830 | N16 | 1 | 1006 | GOUSSET | 3.24094 | 3.72689 | 0.000412858 | 0 | 33.9917 | 0.110165 | 0.0593453 | 216.581 | 274.01
GOUSSET | 5503.08 | 24650 | 44303.9 | +5.485 | +5.519 | 837 | N10 | 1 | 1006 | GOUSSET | 3.4267 | 3.74858 | 0.000436522 | 0 | 33.9128 | 0.116209 | 0.0596908 | 216.581 | 275.605
GOUSSET | 4068.93 | 63754.4 | 44098.4 | +4.053 | +4.087 | 831 | N39 | 1 | 1006 | GOUSSET | 3.24094 | 3.72689 | 0.000412858 | 0 | 33.9917 | 0.110165 | 0.0593453 | 216.581 | 274.01
GOUSSET | 5503.08 | 29850 | 44303.9 | +5.485 | +5.519 | 837 | N8 | 1 | 1006 | GOUSSET | 3.4267 | 3.74858 | 0.000436522 | 0 | 33.9128 | 0.116209 | 0.0596908 | 216.581 | 275.605
GOUSSET | 5503.08 | 35050 | 44303.9 | +5.485 | +5.519 | 837 | N8 | 1 | 1006 | GOUSSET | 3.4267 | 3.74858 | 0.000436522 | 0 | 33.9128 | 0.116209 | 0.0596908 | 216.581 | 275.605
GOUSSET | 5503.18 | 5100 | 32628 | +5.485 | +5.519 | 835 | N15 | 3 | 3006 | GOUSSET | 3.38272 | 3.74855 | 0.00043092 | 0 | 33.9269 | 0.114765 | 0.0596903 | 216.58 | 275.603
GOUSSET | 5503.08 | 55850 | 44303.9 | +5.485 | +5.519 | 837 | N42 | 1 | 1006 | GOUSSET | 3.4267 | 3.74858 | 0.000436522 | 0 | 33.9128 | 0.116209 | 0.0596908 | 216.581 | 275.605
GOUSSET | 4102.18 | 63754.4 | 55773.4 | +4.086 | +4.120 | 831 | N38 | 1 | 1006 | GOUSSET | 3.24094 | 3.72689 | 0.000412858 | 0 | 33.9917 | 0.110165 | 0.0593453 | 216.581 | 274.01
GOUSSET | 5503.08 | 50650 | 44303.9 | +5.485 | +5.519 | 837 | N41 | 1 | 1006 | GOUSSET | 3.4267 | 3.74858 | 0.000436522 | 0 | 33.9128 | 0.116209 | 0.0596908 | 216.581 | 275.605
GOUSSET | 5503.08 | 45450 | 44303.9 | +5.485 | +5.519 | 837 | N41 | 1 | 1006 | GOUSSET | 3.4267 | 3.74858 | 0.000436522 | 0 | 33.9128 | 0.116209 | 0.0596908 | 216.581 | 275.605
GOUSSET | 5503.08 | 29850 | 67653.9 | +5.485 | +5.519 | 840 | N7 | 1 | 1006 | GOUSSET | 3.4267 | 3.74858 | 0.000436522 | 0 | 33.9128 | 0.116209 | 0.0596908 | 216.581 | 275.605
GOUSSET | 5503.08 | 14730 | 44303.9 | +5.485 | +5.519 | 836 | N47 | 1 | 1006 | GOUSSET | 3.4267 | 3.74858 | 0.000436522 | 0 | 33.9128 | 0.116209 | 0.0596908 | 216.581 | 275.605
GOUSSET | 5503.08 | 10010 | 44303.9 | +5.485 | +5.519 | 836 | N47 | 1 | 1006 | GOUSSET | 3.4267 | 3.74858 | 0.000436522 | 0 | 33.9128 | 0.116209 | 0.0596908 | 216.581 | 275.605
GOUSSET | 5503.18 | 5100 | 44303 | +5.485 | +5.519 | 835 | N16 | 1 | 1006 | GOUSSET | 3.38272 | 3.74855 | 0.00043092 | 0 | 33.9269 | 0.114765 | 0.0596903 | 216.58 | 275.603
GOUSSET | 5503.08 | 35050 | 55978.9 | +5.485 | +5.519 | 837 | N8 | 1 | 1006 | GOUSSET | 3.4267 | 3.74858 | 0.000436522 | 0 | 33.9128 | 0.116209 | 0.0596908 | 216.581 | 275.605
GOUSSET | 5503.08 | 14730 | 55978.9 | +5.485 | +5.519 | 836 | N47 | 1 | 1006 | GOUSSET | 3.4267 | 3.74858 | 0.000436522 | 0 | 33.9128 | 0.116209 | 0.0596908 | 216.581 | 275.605
GOUSSET | 4102.18 | 5095.64 | 44098.4 | +4.086 | +4.120 | 830 | N16 | 1 | 1006 | GOUSSET | 3.24094 | 3.72689 | 0.000412858 | 0 | 33.9917 | 0.110165 | 0.0593453 | 216.581 | 274.01
GOUSSET | 5503.08 | 24650 | 32628.9 | +5.485 | +5.519 | 837 | N9 | 3 | 3006 | GOUSSET | 3.4267 | 3.74858 | 0.000436522 | 0 | 33.9128 | 0.116209 | 0.0596908 | 216.581 | 275.605
GOUSSET | 5503.08 | 14730 | 20953.9 | +5.485 | +5.519 | 836 | N49 | 2 | 2006 | GOUSSET | 3.4267 | 3.74858 | 0.000436522 | 0 | 33.9128 | 0.116209 | 0.0596908 | 216.581 | 275.605
GOUSSET | 5503.18 | 5100 | 20953 | +5.485 | +5.519 | 835 | N18 | 2 | 2006 | GOUSSET | 3.38272 | 3.74855 | 0.00043092 | 0 | 33.9269 | 0.114765 | 0.0596903 | 216.58 | 275.603
GOUSSET | 5503.08 | 35050 | 20953.9 | +5.485 | +5.519 | 837 | N44 | 2 | 2006 | GOUSSET | 3.4267 | 3.74858 | 0.000436522 | 0 | 33.9128 | 0.116209 | 0.0596908 | 216.581 | 275.605
GOUSSET | 5503.08 | 14730 | 32628.9 | +5.485 | +5.519 | 836 | N48 | 3 | 3006 | GOUSSET | 3.4267 | 3.74858 | 0.000436522 | 0 | 33.9128 | 0.116209 | 0.0596908 | 216.581 | 275.605
GOUSSET | 5503.18 | 5100 | 55978 | +5.485 | +5.519 | 835 | N16 | 1 | 1006 | GOUSSET | 3.38272 | 3.74855 | 0.00043092 | 0 | 33.9269 | 0.114765 | 0.0596903 | 216.58 | 275.603
GOUSSET | 5503.08 | 24650 | 55978.9 | +5.485 | +5.519 | 837 | N10 | 1 | 1006 | GOUSSET | 3.4267 | 3.74858 | 0.000436522 | 0 | 33.9128 | 0.116209 | 0.0596908 | 216.581 | 275.605
GOUSSET | 5503.08 | 29850 | 55978.9 | +5.485 | +5.519 | 837 | N8 | 1 | 1006 | GOUSSET | 3.4267 | 3.74858 | 0.000436522 | 0 | 33.9128 | 0.116209 | 0.0596908 | 216.581 | 275.605
GOUSSET | 4102.18 | 5095.64 | 67448.4 | +4.086 | +4.120 | 830 | N14 | 1 | 1006 | GOUSSET | 3.24094 | 3.72689 | 0.000412858 | 0 | 33.9917 | 0.110165 | 0.0593453 | 216.581 | 274.01
ATTACHE | 3541.6 | 48437.7 | -2.74194e-16 | +3.428 | +3.628 | 854 | P127 | 2 | 2001 | ATTACHE | 1.78664 | 2.72357 | 0.000227598 | 0.000639676 | 34.9527 | 0.062448 | 0.043369 | 216.845 | 200
ATTACHE | -301.597 | 48437.7 | 5.88345e-16 | -0.388 | -0.188 | 854 | P127 | 2 | 2001 | ATTACHE | 1.78664 | 2.72357 | 0.000227598 | 0 | 34.9527 | 0.062448 | 0.043369 | 216.845 | 200
ATTACHE | 3541.6 | 40337.3 | 5.58454e-16 | +3.428 | +3.628 | 854 | P126 | 2 | 2001 | ATTACHE | 1.78664 | 2.72357 | 0.000227598 | 0.000639676 | 34.9527 | 0.062448 | 0.043369 | 216.845 | 200
ATTACHE | -301.597 | 40337.3 | -2.97314e-16 | -0.388 | -0.188 | 854 | P126 | 2 | 2001 | ATTACHE | 1.78664 | 2.72357 | 0.000227598 | 0 | 34.9527 | 0.062448 | 0.043369 | 216.845 | 200
GOUSSET | 5503.08 | 42850 | 20953.9 | +5.485 | +5.519 | 844 | N46 | 2 | 2006 | GOUSSET | 3.4267 | 3.74858 | 0.000436522 | 0 | 33.9128 | 0.116209 | 0.0596908 | 216.581 | 275.605
GOUSSET | 4102.18 | 48045.6 | 32423.4 | +4.086 | +4.120 | 832 | N43 | 3 | 3003 | GOUSSET | 3.24094 | 3.72689 | 0.000412858 | 0 | 33.9917 | 0.110165 | 0.0593453 | 216.581 | 274.01

# IfcPlate: PL8*219, GOUSSET
In: Undefined
Description: PL8*219; Material: STEEL/E24-2
Tekla Common - Center of gravity Z: 4783.03 mm; Center of gravity Y: 1785.73 mm; Center of gravity X: 79028.4 mm; Bottom elevation: +4.776; Top elevation: +4.791; Part mark: G61; Assembly mark: G61; Phase: 1; Class: 1009; Finish: GRENAILLE-PEINT; Grade: E24-2; Profile: PL8*219; Name: GOUSSET; sets with these values: 2
Tekla Quantity - Net weight: 2.359 kg; Gross weight: 3.30702 kg; Weight: 2.359 kg; Net volume: 0.00030051 m3; Gross volume: 0.00030051 m3; Gross footprint area: 0 m2; Area per tons: 34.4963 m2; Net surface area: 0.0813768 m2; Gross area: 0.0526596 m2; Height: 219.415 mm; Width: 8 mm; Length: 240 mm; sets with these values: 2

# IfcPlate: PL8*220 (2)
In: Undefined
Description: PL8*220; Material: STEEL/E24-2
Tekla Common - Part mark: G8; Assembly mark: G8; Phase: 3; Class: 3004; Finish: GRENAILLE-PEINT; Grade: E24-2; Profile: PL8*220; Name: GOUSSET; sets with these values: 2
Tekla Quantity - Net weight: 3.33836 kg; Gross weight: 4.15094 kg; Weight: 3.33836 kg; Gross footprint area: 0 m2; Area per tons: 34.0793 m2; Net surface area: 0.113769 m2; Height: 220 mm; Width: 8 mm; Length: 300.444 mm; sets with these values: 2
Name | Center of gravity Z (mm) | Center of gravity Y (mm) | Center of gravity X (mm) | Bottom elevation | Top elevation | Net volume (m3) = Gross volume (m3) | Gross area (m2)
GOUSSET | 5041.89 | 50.376 | 24729.7 | +5.023 | +5.058 | 0.000425268 | 0.0660977
GOUSSET | 4563.64 | 50.3761 | 28645.3 | +4.548 | +4.582 | 0.000425269 | 0.0660978

# IfcPlate: PL8*221 (2)
In: Undefined
Description: PL8*221; Material: STEEL/E24-2
Tekla Common - Phase: 1; Finish: GRENAILLE-PEINT; Grade: E24-2; Profile: PL8*221; Name: GOUSSET; sets with these values: 2
Tekla Quantity - Gross footprint area: 0 m2; Width: 8 mm; sets with these values: 2
Name | Center of gravity Z (mm) | Center of gravity Y (mm) | Center of gravity X (mm) | Bottom elevation | Top elevation | Part mark | Assembly mark | Class | Net weight (kg) = Weight (kg) | Gross weight (kg) | Net volume (m3) = Gross volume (m3) | Area per tons (m2) | Net surface area (m2) | Gross area (m2) | Height (mm) | Length (mm)
GOUSSET | 5130.98 | 2469.19 | 71757.2 | +5.122 | +5.144 | 735 | K38 | 1010 | 3.62723 | 6.56062 | 0.000462068 | 34.4374 | 0.124912 | 0.104468 | 220.767 | 473.206
GOUSSET | 3532.26 | 24631.4 | 79028.7 | +3.526 | +3.540 | G62 | G62 | 1009 | 2.63972 | 3.73898 | 0.00033627 | 34.3703 | 0.090728 | 0.0595379 | 220.511 | 270

# IfcPlate: PL8*222, GOUSSET
In: Undefined
Description: PL8*222; Material: STEEL/E24-2
Tekla Common - Center of gravity Z: 2263.72 mm; Center of gravity Y: 69150 mm; Center of gravity X: 50053.6 mm; Bottom elevation: +2.148; Top elevation: +2.385; Part mark: G33; Assembly mark: G33; Phase: 1; Class: 1002; Finish: GRENAILLE-PEINT; Grade: E24-2; Profile: PL8*222; Name: GOUSSET; sets with these values: 2
Tekla Quantity - Net weight: 5.6477 kg; Gross weight: 5.85571 kg; Weight: 5.6477 kg; Net volume: 0.000719452 m3; Gross volume: 0.000719452 m3; Gross footprint area: 0 m2; Area per tons: 33.6396 m2; Net surface area: 0.189987 m2; Gross area: 0.0932438 m2; Height: 221.821 mm; Width: 8 mm; Length: 420.355 mm; sets with these values: 2

# IfcPlate: PL8*226 (4)
In: Undefined
Description: PL8*226; Material: STEEL/E24-2
Tekla Common - Phase: 1; Finish: GRENAILLE-PEINT; Grade: E24-2; Profile: PL8*226; sets with these values: 2
Tekla Quantity - Gross footprint area: 0 m2; Width: 8 mm; sets with these values: 2
Name | Center of gravity Z (mm) | Center of gravity Y (mm) | Center of gravity X (mm) | Bottom elevation | Top elevation | Part mark | Assembly mark | Class | Name | Net weight (kg) = Weight (kg) | Gross weight (kg) | Net volume (m3) = Gross volume (m3) | Area per tons (m2) | Net surface area (m2) | Gross area (m2) | Height (mm) | Length (mm)
GOUSSET | 5497.25 | 63750.6 | 67701.5 | +5.471 | +5.519 | 833 | N17 | 1006 | GOUSSET | 3.75711 | 5.83029 | 0.000478613 | 34.0601 | 0.127967 | 0.0928391 | 225.513 | 411.679
GOUSSET | 5497.25 | 63750.6 | 44351.5 | +5.471 | +5.519 | 833 | N39 | 1006 | GOUSSET | 3.75711 | 5.83029 | 0.000478613 | 34.0601 | 0.127967 | 0.0928391 | 225.513 | 411.679
GOUSSET | 5497.25 | 63750.6 | 56026.5 | +5.471 | +5.519 | 833 | N38 | 1006 | GOUSSET | 3.75711 | 5.83029 | 0.000478613 | 34.0601 | 0.127967 | 0.0928391 | 225.513 | 411.679
 | -287.125 | 69150 | 55779.1 | -0.375 | -0.175 | 763 | P27 | 1001 |  | 1.96946 | 2.83767 | 0.000250887 | 34.7447 | 0.0684284 | 0.0451858 | 225.929 | 200

# IfcPlate: PL8*227 (2)
In: Undefined
Description: PL8*227; Material: STEEL/E24-2
Tekla Common - Center of gravity Z: 5501.83 mm; Center of gravity Y: 27.3748 mm; Bottom elevation: +5.485; Top elevation: +5.519; Part mark: 850; Finish: GRENAILLE-PEINT; Grade: E24-2; Profile: PL8*227; Name: GOUSSET; sets with these values: 2
Tekla Quantity - Net weight: 2.66677 kg; Gross weight: 3.06414 kg; Weight: 2.66677 kg; Net volume: 0.000339716 m3; Gross volume: 0.000339716 m3; Gross footprint area: 0 m2; Area per tons: 34.6674 m2; Net surface area: 0.09245 m2; Gross area: 0.0487921 m2; Height: 226.604 mm; Width: 8 mm; Length: 215.319 mm; sets with these values: 2
Name | Center of gravity X (mm) | Assembly mark | Phase | Class
GOUSSET | 32639.1 | P113 | 3 | 3001
GOUSSET | 20964.1 | P119 | 2 | 2001

# IfcPlate: PL8*229 (18)
In: Undefined
Description: PL8*229; Material: STEEL/E24-2
Tekla Common - Bottom elevation: +5.481; Top elevation: +5.517; Finish: GRENAILLE-PEINT; Grade: E24-2; Profile: PL8*229; Name: GOUSSET; sets with these values: 2
Tekla Quantity - Net weight: 2.02629 kg; Gross weight: 3.30058 kg; Weight: 2.02629 kg; Net volume: 0.000258126 m3; Gross volume: 0.000258126 m3; Gross footprint area: 0 m2; Area per tons: 34.8235 m2; Net surface area: 0.0705625 m2; Gross area: 0.0525571 m2; Height: 228.608 mm; Width: 8 mm; Length: 229.9 mm; sets with these values: 2
Name | Center of gravity Z (mm) | Center of gravity Y (mm) | Center of gravity X (mm) | Part mark = Assembly mark | Phase | Class
GOUSSET | 5500.19 | 40131.4 | 20977.5 | G34 | 3 | 3004
GOUSSET | 5500.19 | 19331.4 | 20977.5 | G35 | 3 | 3004
GOUSSET | 5500.19 | 19568.6 | 20977.5 | G34 | 3 | 3004
GOUSSET | 5500.19 | 40368.6 | 67677.5 | G34 | 1 | 1004
GOUSSET | 5500.19 | 40131.4 | 67677.5 | G34 | 1 | 1004
GOUSSET | 5500.19 | 40368.6 | 32652.5 | G34 | 3 | 3004
GOUSSET | 5500.19 | 19568.6 | 32652.5 | G34 | 3 | 3004
GOUSSET | 5500.19 | 40131.4 | 32652.5 | G34 | 3 | 3004
GOUSSET | 5500.18 | 19568.6 | 67677.5 | G36 | 1 | 1009
GOUSSET | 5500.19 | 40131.4 | 56002.5 | G34 | 1 | 1004
GOUSSET | 5500.19 | 19331.4 | 44327.5 | G35 | 1 | 1004
GOUSSET | 5500.19 | 40368.6 | 44327.5 | G34 | 1 | 1004
GOUSSET | 5500.19 | 40131.4 | 44327.5 | G34 | 1 | 1004
GOUSSET | 5500.19 | 19568.6 | 44327.5 | G34 | 1 | 1004
GOUSSET | 5500.19 | 19331.4 | 32652.5 | G35 | 3 | 3004
GOUSSET | 5500.19 | 40368.6 | 56002.5 | G34 | 1 | 1004
GOUSSET | 5500.19 | 19568.6 | 56002.5 | G34 | 1 | 1004
GOUSSET | 5500.19 | 19331.4 | 56002.5 | G35 | 1 | 1004

# IfcPlate: PL8*235
In: Undefined
Description: PL8*235; Material: STEEL/E24-2
Tekla Common - Center of gravity Z: -285.542 mm; Center of gravity Y: 69150 mm; Center of gravity X: 44299.7 mm; Bottom elevation: -0.375; Top elevation: -0.175; Part mark: 765; Assembly mark: P26; Phase: 1; Class: 1001; Finish: GRENAILLE-PEINT; Grade: E24-2; Profile: PL8*235; sets with these values: 2
Tekla Quantity - Net weight: 2.06098 kg; Gross weight: 2.95205 kg; Weight: 2.06098 kg; Net volume: 0.000262546 m3; Gross volume: 0.000262546 m3; Gross footprint area: 0 m2; Area per tons: 34.6825 m2; Net surface area: 0.07148 m2; Gross area: 0.0470072 m2; Height: 235.036 mm; Width: 8 mm; Length: 200 mm; sets with these values: 2

# IfcPlate: PL8*237, GOUSSET
In: Undefined
Description: PL8*237; Material: STEEL/E24-2
Tekla Common - Center of gravity Z: 5130.74 mm; Center of gravity Y: 97.2307 mm; Center of gravity X: 71765.1 mm; Bottom elevation: +5.120; Top elevation: +5.140; Part mark: 710; Assembly mark: K28; Phase: 1; Class: 1010; Finish: GRENAILLE-PEINT; Grade: E24-2; Profile: PL8*237; Name: GOUSSET; sets with these values: 2
Tekla Quantity - Net weight: 3.70479 kg; Gross weight: 5.70793 kg; Weight: 3.70479 kg; Net volume: 0.000471948 m3; Gross volume: 0.000471948 m3; Gross footprint area: 0 m2; Area per tons: 34.0956 m2; Net surface area: 0.126317 m2; Gross area: 0.0908905 m2; Height: 236.95 mm; Width: 8 mm; Length: 383.585 mm; sets with these values: 2

# IfcPlate: PL8*239
In: Undefined
Description: PL8*239; Material: STEEL/E24-2
Tekla Common - Center of gravity Z: 4032.03 mm; Center of gravity Y: 69150 mm; Center of gravity X: 55755.9 mm; Bottom elevation: +3.950; Top elevation: +4.116; Part mark: 766; Assembly mark: P27; Phase: 1; Class: 1001; Finish: GRENAILLE-PEINT; Grade: E24-2; Profile: PL8*239; sets with these values: 2
Tekla Quantity - Net weight: 2.00183 kg; Gross weight: 2.48367 kg; Weight: 2.00183 kg; Net volume: 0.00025501 m3; Gross volume: 0.00025501 m3; Gross footprint area: 0 m2; Area per tons: 34.7617 m2; Net surface area: 0.069587 m2; Gross area: 0.0395488 m2; Height: 238.877 mm; Width: 8 mm; Length: 165.561 mm; sets with these values: 2

# IfcPlate: PL8*242, GOUSSET
In: Undefined
Description: PL8*242; Material: STEEL/E24-2
Tekla Common - Center of gravity Z: 4105.13 mm; Center of gravity Y: -26.0909 mm; Center of gravity X: 32399.1 mm; Bottom elevation: +4.086; Top elevation: +4.123; Part mark: 773; Assembly mark: P113; Phase: 3; Class: 3001; Finish: GRENAILLE-PEINT; Grade: E24-2; Profile: PL8*242; Name: GOUSSET; sets with these values: 2
Tekla Quantity - Net weight: 4.01666 kg; Gross weight: 6.20595 kg; Weight: 4.01666 kg; Net volume: 0.000511676 m3; Gross volume: 0.000511676 m3; Gross footprint area: 0 m2; Area per tons: 34.0335 m2; Net surface area: 0.136701 m2; Gross area: 0.0988208 m2; Height: 241.829 mm; Width: 8 mm; Length: 408.639 mm; sets with these values: 2

# IfcPlate: PL8*243, GOUSSET
In: Undefined
Description: PL8*243; Material: STEEL/E24-2
Tekla Common - Center of gravity Z: 4775.93 mm; Center of gravity Y: 50614 mm; Center of gravity X: 38310 mm; Bottom elevation: +4.759; Top elevation: +4.800; Part mark: G13; Assembly mark: G13; Phase: 3; Class: 3004; Finish: GRENAILLE-PEINT; Grade: E24-2; Profile: PL8*243; Name: GOUSSET; sets with these values: 2
Tekla Quantity - Net weight: 4.77768 kg; Gross weight: 7.0768 kg; Weight: 4.77768 kg; Net volume: 0.000608622 m3; Gross volume: 0.000608622 m3; Gross footprint area: 0 m2; Area per tons: 33.7998 m2; Net surface area: 0.161485 m2; Gross area: 0.112688 m2; Height: 242.764 mm; Width: 8 mm; Length: 464.187 mm; sets with these values: 2

# IfcPlate: PL8*245 (2)
In: Undefined
Description: PL8*245; Material: STEEL/E24-2
Tekla Common - Center of gravity X: 78997 mm; Bottom elevation: +4.099; Top elevation: +4.151; Part mark: 803; Phase: 1; Class: 1010; Finish: GRENAILLE-PEINT; Grade: E24-2; Profile: PL8*245; Name: GOUSSET; sets with these values: 2
Tekla Quantity - Gross footprint area: 0 m2; Area per tons: 35.2599 m2; Width: 8 mm; sets with these values: 2
Name | Center of gravity Z (mm) | Center of gravity Y (mm) | Assembly mark | Net weight (kg) = Weight (kg) | Gross weight (kg) | Net volume (m3) = Gross volume (m3) | Net surface area (m2) | Gross area (m2) | Height (mm) | Length (mm)
GOUSSET | 4125.69 | 69015 | K54 | 2.04522 | 4.09043 | 0.000260537 | 0.0721141 | 0.0651343 | 244.557 | 266.336
GOUSSET | 4125.68 | 63885 | K8 | 2.04524 | 4.09048 | 0.00026054 | 0.0721149 | 0.0651351 | 244.559 | 266.337

# IfcPlate: PL8*248 (31)
In: Undefined
Description: PL8*248; Material: STEEL/E24-2
Tekla Common - Center of gravity Z: 4814.13 mm; Bottom elevation: +4.795; Top elevation: +4.833; Finish: GRENAILLE-PEINT; Grade: E24-2; Profile: PL8*248; Name: GOUSSET; sets with these values: 2
Tekla Quantity - Net weight: 6.37364 kg; Gross weight: 6.37367 kg; Weight: 6.37364 kg; Net volume: 0.000811928 m3; Gross volume: 0.000811928 m3; Gross footprint area: 0 m2; Area per tons: 33.4978 m2; Net surface area: 0.213503 m2; Gross area: 0.101492 m2; Height: 247.54 mm; Width: 8 mm; Length: 410 mm; sets with these values: 2
Name | Center of gravity Y (mm) | Center of gravity X (mm) | Part mark = Assembly mark | Phase | Class
GOUSSET | 35050 | 26594.4 | G48 | 3 | 3004
GOUSSET | 29850 | 26594.4 | G48 | 3 | 3004
GOUSSET | 24650 | 26594.4 | G48 | 3 | 3004
GOUSSET | 14730 | 26594.4 | G47 | 3 | 3004
GOUSSET | 10010 | 26594.4 | G47 | 3 | 3004
GOUSSET | 40250 | 73294.4 | G48 | 1 | 1004
GOUSSET | 45450 | 73294.4 | G48 | 1 | 1004
GOUSSET | 50650 | 73294.4 | G48 | 1 | 1004
GOUSSET | 45450 | 38269.4 | G48 | 3 | 3004
GOUSSET | 50650 | 49944.4 | G48 | 1 | 1004
GOUSSET | 29850 | 49944.4 | G48 | 1 | 1004
GOUSSET | 10010 | 38269.4 | G47 | 3 | 3004
GOUSSET | 35050 | 49944.4 | G48 | 1 | 1004
GOUSSET | 55850 | 49944.4 | G48 | 1 | 1004
GOUSSET | 45450 | 49944.4 | G48 | 1 | 1004
GOUSSET | 24650 | 49944.4 | G48 | 1 | 1004
GOUSSET | 14730 | 49944.4 | G47 | 1 | 1004
GOUSSET | 10010 | 49944.4 | G47 | 1 | 1004
GOUSSET | 29850 | 61619.4 | G48 | 1 | 1004
GOUSSET | 35050 | 61619.4 | G48 | 1 | 1004
GOUSSET | 50650 | 61619.4 | G48 | 1 | 1004
GOUSSET | 55850 | 61619.4 | G48 | 1 | 1004
GOUSSET | 45450 | 61619.4 | G48 | 1 | 1004
GOUSSET | 10010 | 61619.4 | G47 | 1 | 1004
GOUSSET | 14730 | 61619.4 | G47 | 1 | 1004
GOUSSET | 24650 | 61619.4 | G48 | 1 | 1004
GOUSSET | 35050 | 38269.4 | G48 | 3 | 3004
GOUSSET | 24650 | 38269.4 | G48 | 3 | 3004
GOUSSET | 29850 | 38269.4 | G48 | 3 | 3004
GOUSSET | 14730 | 38269.4 | G47 | 3 | 3004
GOUSSET | 55850 | 73294.4 | G48 | 1 | 1004

# IfcPlate: PL8*262, GOUSSET
In: Undefined
Description: PL8*262; Material: STEEL/E24-2
Tekla Common - Center of gravity Z: 3752.2 mm; Center of gravity Y: 13578.6 mm; Center of gravity X: 71933.9 mm; Bottom elevation: +3.744; Top elevation: +3.760; Part mark: 805; Assembly mark: P123; Phase: 1; Class: 1011; Finish: GRENAILLE-PEINT; Grade: E24-2; Profile: PL8*262; Name: GOUSSET; sets with these values: 2
Tekla Quantity - Net weight: 2.58497 kg; Gross weight: 4.3166 kg; Weight: 2.58497 kg; Net volume: 0.000329295 m3; Gross volume: 0.000329295 m3; Gross footprint area: 0 m2; Area per tons: 34.5059 m2; Net surface area: 0.0891965 m2; Gross area: 0.0687357 m2; Height: 261.668 mm; Width: 8 mm; Length: 262.683 mm; sets with these values: 2

# IfcPlate: PL8*275, GOUSSET
In: Undefined
Description: PL8*275; Material: STEEL/E24-2
Tekla Common - Center of gravity Z: 4814.79 mm; Center of gravity Y: 35051.6 mm; Center of gravity X: 73289.1 mm; Bottom elevation: +4.795; Top elevation: +4.836; Part mark: G31; Assembly mark: G31; Phase: 1; Class: 1009; Finish: GRENAILLE-PEINT; Grade: E24-2; Profile: PL8*275; Name: GOUSSET; sets with these values: 2
Tekla Quantity - Net weight: 6.57196 kg; Gross weight: 7.08976 kg; Weight: 6.57196 kg; Net volume: 0.000837192 m3; Gross volume: 0.000837192 m3; Gross footprint area: 0 m2; Area per tons: 33.4494 m2; Net surface area: 0.219828 m2; Gross area: 0.112894 m2; Height: 275.351 mm; Width: 8 mm; Length: 410.002 mm; sets with these values: 2

# IfcPlate: PL8*276, GOUSSET
In: Undefined
Description: PL8*276; Material: STEEL/E24-2
Tekla Common - Center of gravity Z: 5051.6 mm; Center of gravity Y: 70.208 mm; Center of gravity X: 74317.9 mm; Bottom elevation: +5.041; Top elevation: +5.062; Part mark: 734; Assembly mark: K28; Phase: 1; Class: 1010; Finish: GRENAILLE-PEINT; Grade: E24-2; Profile: PL8*276; Name: GOUSSET; sets with these values: 2
Tekla Quantity - Net weight: 2.55428 kg; Gross weight: 5.10861 kg; Weight: 2.55428 kg; Net volume: 0.000325386 m3; Gross volume: 0.000325386 m3; Gross footprint area: 0 m2; Area per tons: 34.8992 m2; Net surface area: 0.0891424 m2; Gross area: 0.0813473 m2; Height: 276.334 mm; Width: 8 mm; Length: 294.38 mm; sets with these values: 2

# IfcPlate: PL8*278 (8)
In: Undefined
Description: PL8*278; Material: STEEL/E24-2
Tekla Common - Center of gravity Z: 4802.76 mm; Bottom elevation: +4.774; Top elevation: +4.831; Finish: GRENAILLE-PEINT; Grade: E24-2; Profile: PL8*278; Name: GOUSSET; sets with these values: 2
Tekla Quantity - Net weight: 6.82104 kg; Gross weight: 7.07224 kg; Weight: 6.82104 kg; Net volume: 0.000868922 m3; Gross volume: 0.000868922 m3; Gross footprint area: 0 m2; Area per tons: 33.3954 m2; Net surface area: 0.227791 m2; Gross area: 0.112615 m2; Height: 278.009 mm; Width: 8 mm; Length: 405.078 mm; sets with these values: 2
Name | Center of gravity Y (mm) | Center of gravity X (mm) | Part mark = Assembly mark | Phase | Class
GOUSSET | 69088.8 | 61712.5 | G3 | 1 | 1004
GOUSSET | 61.1875 | 61712.5 | G2 | 1 | 1004
GOUSSET | 69088.8 | 50037.5 | G3 | 1 | 1004
GOUSSET | 61.1875 | 50037.5 | G2 | 1 | 1004
GOUSSET | 61.1875 | 38362.5 | G2 | 3 | 3004
GOUSSET | 61.1875 | 26687.5 | G2 | 3 | 3004
GOUSSET | 69088.8 | 73387.5 | G3 | 1 | 1004
GOUSSET | 69088.8 | 38362.5 | G7 | 3 | 3004

# IfcPlate: PL8*281
In: Undefined
Description: PL8*281; Material: STEEL/E24-2
Tekla Common - Center of gravity Z: -277.541 mm; Center of gravity Y: -1.45332e-16 mm; Center of gravity X: 55756.8 mm; Bottom elevation: -0.375; Top elevation: -0.175; Part mark: 858; Assembly mark: P25; Phase: 1; Class: 1001; Finish: GRENAILLE-PEINT; Grade: E24-2; Profile: PL8*281; sets with these values: 2
Tekla Quantity - Net weight: 2.51886 kg; Gross weight: 3.5242 kg; Weight: 2.51886 kg; Net volume: 0.000320874 m3; Gross volume: 0.000320874 m3; Gross footprint area: 0 m2; Area per tons: 34.4482 m2; Net surface area: 0.0867702 m2; Gross area: 0.0561178 m2; Height: 280.589 mm; Width: 8 mm; Length: 200 mm; sets with these values: 2

# IfcPlate: PL8*290
In: Undefined
Description: PL8*290; Material: STEEL/E24-2
Tekla Common - Center of gravity Z: 4028.34 mm; Center of gravity Y: -2.28847e-16 mm; Center of gravity X: 55732.4 mm; Bottom elevation: +3.950; Top elevation: +4.116; Part mark: 859; Assembly mark: P25; Phase: 1; Class: 1001; Finish: GRENAILLE-PEINT; Grade: E24-2; Profile: PL8*290; sets with these values: 2
Tekla Quantity - Net weight: 2.47153 kg; Gross weight: 3.01719 kg; Weight: 2.47153 kg; Net volume: 0.000314844 m3; Gross volume: 0.000314844 m3; Gross footprint area: 0 m2; Area per tons: 34.4378 m2; Net surface area: 0.0851141 m2; Gross area: 0.0480444 m2; Height: 290.193 mm; Width: 8 mm; Length: 165.56 mm; sets with these values: 2

# IfcPlate: PL8*307, GOUSSET
In: Undefined
Description: PL8*307; Material: STEEL/E24-2
Tekla Common - Center of gravity Z: 5262.33 mm; Center of gravity Y: 22050 mm; Center of gravity X: 69624.9 mm; Bottom elevation: +5.240; Top elevation: +5.285; Part mark: G46; Assembly mark: G46; Phase: 1; Class: 1009; Finish: GRENAILLE-PEINT; Grade: E24-2; Profile: PL8*307; Name: GOUSSET; sets with these values: 2
Tekla Quantity - Net weight: 7.12217 kg; Gross weight: 7.12218 kg; Weight: 7.12217 kg; Net volume: 0.000907283 m3; Gross volume: 0.000907283 m3; Gross footprint area: 0 m2; Area per tons: 33.3667 m2; Net surface area: 0.237644 m2; Gross area: 0.11341 m2; Height: 306.901 mm; Width: 8 mm; Length: 369.534 mm; sets with these values: 2

# IfcPlate: PL8*308 (4)
In: Undefined
Description: PL8*308; Material: STEEL/E24-2
Tekla Common - Phase: 1; Class: 1009; Finish: GRENAILLE-PEINT; Grade: E24-2; Profile: PL8*308; Name: GOUSSET; sets with these values: 2
Tekla Quantity - Gross footprint area: 0 m2; Width: 8 mm; sets with these values: 2
Name | Center of gravity Z (mm) | Center of gravity Y (mm) | Center of gravity X (mm) | Bottom elevation | Top elevation | Part mark = Assembly mark | Net weight (kg) = Weight (kg) | Gross weight (kg) | Net volume (m3) = Gross volume (m3) | Area per tons (m2) | Net surface area (m2) | Gross area (m2) | Height (mm) | Length (mm)
GOUSSET | 5245.8 | 24721.8 | 69760.3 | +5.223 | +5.270 | G12 | 4.40188 | 6.07621 | 0.000560749 | 33.7163 | 0.148415 | 0.0967549 | 307.839 | 314.303
GOUSSET | 3643.2 | 15633.3 | 75449.9 | +3.631 | +3.655 | G21 | 9.70969 | 9.70974 | 0.0012369 | 33.1814 | 0.322181 | 0.154614 | 308.482 | 501.208
GOUSSET | 3641.32 | 23975.8 | 75510.6 | +3.625 | +3.655 | G66 | 11.9341 | 13.6945 | 0.00152027 | 33.1072 | 0.395104 | 0.218066 | 308.482 | 706.901
GOUSSET | 3643.2 | 19800 | 75449.9 | +3.631 | +3.655 | G21 | 9.70969 | 9.70974 | 0.0012369 | 33.1814 | 0.322181 | 0.154614 | 308.482 | 501.208

# IfcPlate: PL8*310, GOUSSET
In: Undefined
Description: PL8*310; Material: STEEL/E24-2
Tekla Common - Center of gravity Z: 5074.37 mm; Center of gravity Y: 2574.34 mm; Center of gravity X: 69630 mm; Bottom elevation: +5.065; Top elevation: +5.083; Part mark: G24; Assembly mark: G24; Phase: 1; Class: 1009; Finish: GRENAILLE-PEINT; Grade: E24-2; Profile: PL8*310; Name: GOUSSET; sets with these values: 2
Tekla Quantity - Net weight: 6.10912 kg; Gross weight: 7.14533 kg; Weight: 6.10912 kg; Net volume: 0.000778232 m3; Gross volume: 0.000778232 m3; Gross footprint area: 0 m2; Area per tons: 33.4959 m2; Net surface area: 0.204631 m2; Gross area: 0.113779 m2; Height: 310.031 mm; Width: 8 mm; Length: 366.992 mm; sets with these values: 2

# IfcPlate: PL8*315, GOUSSET
In: Undefined
Description: PL8*315; Material: STEEL/E24-2
Tekla Common - Center of gravity Z: 5249.28 mm; Center of gravity Y: 27212.6 mm; Center of gravity X: 69731.8 mm; Bottom elevation: +5.223; Top elevation: +5.269; Part mark: G56; Assembly mark: G56; Phase: 1; Class: 1009; Finish: GRENAILLE-PEINT; Grade: E24-2; Profile: PL8*315; Name: GOUSSET; sets with these values: 2
Tekla Quantity - Net weight: 5.49955 kg; Gross weight: 7.85765 kg; Weight: 5.49955 kg; Net volume: 0.00070058 m3; Gross volume: 0.00070058 m3; Gross footprint area: 0 m2; Area per tons: 33.6054 m2; Net surface area: 0.184814 m2; Gross area: 0.125122 m2; Height: 314.886 mm; Width: 8 mm; Length: 397.356 mm; sets with these values: 2

# IfcPlate: PL8*332 (2)
In: Undefined
Description: PL8*332; Material: STEEL/E24-2
Tekla Common - Center of gravity Y: 32243.7 mm; Part mark: G58; Assembly mark: G58; Phase: 2; Class: 2004; Finish: GRENAILLE-PEINT; Grade: E24-2; Profile: PL8*332; Name: GOUSSET; sets with these values: 2
Tekla Quantity - Net weight: 7.81314 kg; Gross weight: 7.81315 kg; Weight: 7.81314 kg; Net volume: 0.000995304 m3; Gross volume: 0.000995304 m3; Gross footprint area: 0 m2; Area per tons: 33.2943 m2; Net surface area: 0.260133 m2; Gross area: 0.124413 m2; Height: 332.47 mm; Width: 8 mm; Length: 374.209 mm; sets with these values: 2
Name | Center of gravity Z (mm) | Center of gravity X (mm) | Bottom elevation | Top elevation
GOUSSET | 3494.82 | 6971.25 | +3.485 | +3.505
GOUSSET | 3657.48 | 2323.75 | +3.648 | +3.667

# IfcPlate: PL8*335 (2)
In: Undefined
Description: PL8*335; Material: STEEL/E24-2
Tekla Common - Center of gravity Z: 5073.96 mm; Center of gravity X: 69643.3 mm; Bottom elevation: +5.065; Top elevation: +5.083; Phase: 1; Class: 1009; Finish: GRENAILLE-PEINT; Grade: E24-2; Profile: PL8*335; Name: GOUSSET; sets with these values: 2
Tekla Quantity - Gross footprint area: 0 m2; Height: 335.412 mm; Width: 8 mm; sets with these values: 2
Name | Center of gravity Y (mm) | Part mark = Assembly mark | Net weight (kg) = Weight (kg) | Gross weight (kg) | Net volume (m3) = Gross volume (m3) | Area per tons (m2) | Net surface area (m2) | Gross area (m2) | Length (mm)
GOUSSET | 7647.5 | G45 | 7.9331 | 7.93311 | 0.00101059 | 33.2832 | 0.264039 | 0.126323 | 376.621
GOUSSET | 17090 | G44 | 7.82778 | 7.82779 | 0.00099717 | 33.2923 | 0.260605 | 0.124646 | 371.621

# IfcPlate: PL8*345, GOUSSET
In: Undefined
Description: PL8*345; Material: STEEL/E24-2
Tekla Common - Center of gravity Z: 5261.43 mm; Center of gravity Y: 34972.8 mm; Center of gravity X: 69632.3 mm; Bottom elevation: +5.231; Top elevation: +5.288; Part mark: G57; Assembly mark: G57; Phase: 1; Class: 1009; Finish: GRENAILLE-PEINT; Grade: E24-2; Profile: PL8*345; Name: GOUSSET; sets with these values: 2
Tekla Quantity - Net weight: 5.21228 kg; Gross weight: 8.56092 kg; Weight: 5.21228 kg; Net volume: 0.000663985 m3; Gross volume: 0.000663985 m3; Gross footprint area: 0 m2; Area per tons: 33.603 m2; Net surface area: 0.175148 m2; Gross area: 0.13632 m2; Height: 345.293 mm; Width: 8 mm; Length: 394.797 mm; sets with these values: 2

# IfcPlate: PL8*358 (18)
In: Undefined
Description: PL8*358; Material: STEEL/E24-2
Tekla Common - Finish: GRENAILLE-PEINT; Grade: E24-2; Profile: PL8*358; Name: GOUSSET; sets with these values: 2
Tekla Quantity - Gross footprint area: 0 m2; Height: 357.929 mm; Width: 8 mm; sets with these values: 2
Name | Center of gravity Z (mm) | Center of gravity Y (mm) | Center of gravity X (mm) | Bottom elevation | Top elevation | Part mark = Assembly mark | Phase | Class | Net weight (kg) = Weight (kg) | Gross weight (kg) | Net volume (m3) = Gross volume (m3) | Area per tons (m2) | Net surface area (m2) | Gross area (m2) | Length (mm)
GOUSSET | 5159.26 | 17090 | 23768.8 | +5.129 | +5.190 | G41 | 3 | 3004 | 9.76032 | 9.76033 | 0.00124335 | 33.1457 | 0.323513 | 0.155419 | 434.218
GOUSSET | 5159.26 | 12370 | 23768.8 | +5.129 | +5.190 | G41 | 3 | 3004 | 9.76032 | 9.76033 | 0.00124335 | 33.1457 | 0.323513 | 0.155419 | 434.218
GOUSSET | 5159.26 | 7652.07 | 23768.8 | +5.129 | +5.190 | G40 | 3 | 3004 | 9.43281 | 9.76031 | 0.00120163 | 33.1666 | 0.312854 | 0.155419 | 434.217
GOUSSET | 4446.26 | 2550 | 64631.2 | +4.418 | +4.475 | G39 | 1 | 1004 | 9.10531 | 9.10532 | 0.00115991 | 33.1879 | 0.302186 | 0.144989 | 405.078
GOUSSET | 5159.26 | 2550 | 58793.8 | +5.131 | +5.188 | G39 | 1 | 1004 | 9.10531 | 9.10532 | 0.00115991 | 33.1879 | 0.302186 | 0.144989 | 405.078
GOUSSET | 5159.26 | 17090 | 47118.8 | +5.129 | +5.190 | G41 | 1 | 1004 | 9.76032 | 9.76033 | 0.00124335 | 33.1457 | 0.323513 | 0.155419 | 434.218
GOUSSET | 4446.26 | 2550 | 52956.2 | +4.418 | +4.475 | G39 | 1 | 1004 | 9.10531 | 9.10532 | 0.00115991 | 33.1879 | 0.302186 | 0.144989 | 405.078
GOUSSET | 5159.26 | 12370 | 47118.8 | +5.129 | +5.190 | G41 | 1 | 1004 | 9.76032 | 9.76033 | 0.00124335 | 33.1457 | 0.323513 | 0.155419 | 434.218
GOUSSET | 5159.26 | 7652.07 | 47118.8 | +5.129 | +5.190 | G40 | 1 | 1004 | 9.43281 | 9.76031 | 0.00120163 | 33.1666 | 0.312854 | 0.155419 | 434.217
GOUSSET | 5159.26 | 2550 | 47118.8 | +5.131 | +5.188 | G39 | 1 | 1004 | 9.10531 | 9.10532 | 0.00115991 | 33.1879 | 0.302186 | 0.144989 | 405.078
GOUSSET | 5159.26 | 2550 | 35443.8 | +5.131 | +5.188 | G39 | 3 | 3004 | 9.10531 | 9.10532 | 0.00115991 | 33.1879 | 0.302186 | 0.144989 | 405.078
GOUSSET | 5159.26 | 7652.07 | 35443.8 | +5.129 | +5.190 | G40 | 3 | 3004 | 9.43281 | 9.76031 | 0.00120163 | 33.1666 | 0.312854 | 0.155419 | 434.217
GOUSSET | 5159.26 | 12370 | 35443.8 | +5.129 | +5.190 | G41 | 3 | 3004 | 9.76032 | 9.76033 | 0.00124335 | 33.1457 | 0.323513 | 0.155419 | 434.218
GOUSSET | 5159.26 | 17090 | 35443.8 | +5.129 | +5.190 | G41 | 3 | 3004 | 9.76032 | 9.76033 | 0.00124335 | 33.1457 | 0.323513 | 0.155419 | 434.218
GOUSSET | 4446.26 | 2550 | 41281.2 | +4.418 | +4.475 | G39 | 3 | 3004 | 9.10531 | 9.10532 | 0.00115991 | 33.1879 | 0.302186 | 0.144989 | 405.078
GOUSSET | 5159.26 | 7652.07 | 58793.8 | +5.129 | +5.190 | G40 | 1 | 1004 | 9.43281 | 9.76031 | 0.00120163 | 33.1666 | 0.312854 | 0.155419 | 434.217
GOUSSET | 5159.26 | 12370 | 58793.8 | +5.129 | +5.190 | G41 | 1 | 1004 | 9.76032 | 9.76033 | 0.00124335 | 33.1457 | 0.323513 | 0.155419 | 434.218
GOUSSET | 5159.26 | 17090 | 58793.8 | +5.129 | +5.190 | G41 | 1 | 1004 | 9.76032 | 9.76033 | 0.00124335 | 33.1457 | 0.323513 | 0.155419 | 434.218

# IfcPlate: PL8*360, GOUSSET
In: Undefined
Description: PL8*360; Material: STEEL/E24-2
Tekla Common - Center of gravity Z: 4889.49 mm; Center of gravity Y: 2568.62 mm; Center of gravity X: 75594.1 mm; Bottom elevation: +4.876; Top elevation: +4.905; Part mark: G38; Assembly mark: G38; Phase: 1; Class: 1009; Finish: GRENAILLE-PEINT; Grade: E24-2; Profile: PL8*360; Name: GOUSSET; sets with these values: 2
Tekla Quantity - Net weight: 9.733 kg; Gross weight: 15.6742 kg; Weight: 9.733 kg; Net volume: 0.00123987 m3; Gross volume: 0.00123987 m3; Gross footprint area: 0 m2; Area per tons: 33.2671 m2; Net surface area: 0.323789 m2; Gross area: 0.24959 m2; Height: 359.705 mm; Width: 8 mm; Length: 693.873 mm; sets with these values: 2

# IfcPlate: PL8*361 (30)
In: Undefined
Description: PL8*361; Material: STEEL/E24-2
Tekla Common - Center of gravity Z: 5159.26 mm; Bottom elevation: +5.131; Top elevation: +5.188; Part mark: G42; Assembly mark: G42; Finish: GRENAILLE-PEINT; Grade: E24-2; Profile: PL8*361; Name: GOUSSET; sets with these values: 2
Tekla Quantity - Net weight: 9.12418 kg; Gross weight: 9.12419 kg; Weight: 9.12418 kg; Net volume: 0.00116232 m3; Gross volume: 0.00116232 m3; Gross footprint area: 0 m2; Area per tons: 33.1859 m2; Net surface area: 0.302794 m2; Gross area: 0.14529 m2; Height: 361.329 mm; Width: 8 mm; Length: 402.098 mm; sets with these values: 2
Name | Center of gravity Y (mm) | Center of gravity X (mm) | Phase | Class
GOUSSET | 37650 | 23768.8 | 3 | 3004
GOUSSET | 32450 | 23768.8 | 3 | 3004
GOUSSET | 27250 | 23768.8 | 3 | 3004
GOUSSET | 22050 | 23768.8 | 3 | 3004
GOUSSET | 37650 | 70468.8 | 1 | 1004
GOUSSET | 42850 | 70468.8 | 1 | 1004
GOUSSET | 48050 | 70468.8 | 1 | 1004
GOUSSET | 53250 | 70468.8 | 1 | 1004
GOUSSET | 42850 | 35443.8 | 3 | 3004
GOUSSET | 37650 | 35443.8 | 3 | 3004
GOUSSET | 42850 | 58793.8 | 1 | 1004
GOUSSET | 53250 | 47118.8 | 1 | 1004
GOUSSET | 58450 | 47118.8 | 1 | 1004
GOUSSET | 37650 | 47118.8 | 1 | 1004
GOUSSET | 32450 | 47118.8 | 1 | 1004
GOUSSET | 22050 | 47118.8 | 1 | 1004
GOUSSET | 27250 | 47118.8 | 1 | 1004
GOUSSET | 32450 | 35443.8 | 3 | 3004
GOUSSET | 42850 | 47118.8 | 1 | 1004
GOUSSET | 48050 | 47118.8 | 1 | 1004
GOUSSET | 32450 | 58793.8 | 1 | 1004
GOUSSET | 37650 | 58793.8 | 1 | 1004
GOUSSET | 58450 | 58793.8 | 1 | 1004
GOUSSET | 48050 | 58793.8 | 1 | 1004
GOUSSET | 53250 | 58793.8 | 1 | 1004
GOUSSET | 22050 | 35443.8 | 3 | 3004
GOUSSET | 27250 | 35443.8 | 3 | 3004
GOUSSET | 22050 | 58793.8 | 1 | 1004
GOUSSET | 27250 | 58793.8 | 1 | 1004
GOUSSET | 58450 | 70468.8 | 1 | 1004

# IfcPlate: PL8*368 (9)
In: Undefined
Description: PL8*368; Material: STEEL/E24-2
Tekla Common - Phase: 1; Class: 1004; Finish: GRENAILLE-PEINT; Grade: E24-2; Profile: PL8*368; Name: GOUSSET; sets with these values: 2
Tekla Quantity - Gross footprint area: 0 m2; Width: 8 mm; sets with these values: 2
Name | Center of gravity Z (mm) | Center of gravity Y (mm) | Center of gravity X (mm) | Bottom elevation | Top elevation | Part mark = Assembly mark | Net weight (kg) = Weight (kg) | Gross weight (kg) | Net volume (m3) = Gross volume (m3) | Area per tons (m2) | Net surface area (m2) | Gross area (m2) | Height (mm) | Length (mm)
GOUSSET | 4817.48 | 61060.9 | 61592 | +4.795 | +4.848 | G1 | 7.51422 | 9.46486 | 0.000957226 | 33.3263 | 0.250421 | 0.150714 | 367.596 | 410
GOUSSET | 4817.48 | 61060.9 | 49917 | +4.795 | +4.848 | G1 | 7.51422 | 9.46486 | 0.000957226 | 33.3263 | 0.250421 | 0.150714 | 367.596 | 410
GOUSSET | 5159.26 | 66450 | 47118.8 | +5.131 | +5.187 | G43 | 9.15352 | 9.15353 | 0.00116605 | 33.1827 | 0.303739 | 0.145757 | 367.889 | 396.198
GOUSSET | 4446.26 | 66450 | 52956.2 | +4.418 | +4.474 | G43 | 9.15352 | 9.15353 | 0.00116605 | 33.1827 | 0.303739 | 0.145757 | 367.889 | 396.198
GOUSSET | 4817.48 | 61060.9 | 73267 | +4.795 | +4.848 | G1 | 7.51422 | 9.46486 | 0.000957226 | 33.3263 | 0.250421 | 0.150714 | 367.596 | 410
GOUSSET | 4446.26 | 66450 | 64631.2 | +4.418 | +4.474 | G43 | 9.15352 | 9.15353 | 0.00116605 | 33.1827 | 0.303739 | 0.145757 | 367.889 | 396.198
GOUSSET | 5159.26 | 66450 | 58793.8 | +5.131 | +5.187 | G43 | 9.15352 | 9.15353 | 0.00116605 | 33.1827 | 0.303739 | 0.145757 | 367.889 | 396.198
GOUSSET | 5159.26 | 66450 | 70468.8 | +5.131 | +5.187 | G43 | 9.15352 | 9.15353 | 0.00116605 | 33.1827 | 0.303739 | 0.145757 | 367.889 | 396.198
GOUSSET | 4446.26 | 66450 | 76306.2 | +4.418 | +4.474 | G43 | 9.15352 | 9.15353 | 0.00116605 | 33.1827 | 0.303739 | 0.145757 | 367.889 | 396.198

# IfcPlate: PL8*375 (2)
In: Undefined
Description: PL8*375; Material: STEEL/E24-2
Tekla Common - Finish: GRENAILLE-PEINT; Grade: E24-2; Profile: PL8*375; Name: GOUSSET; sets with these values: 2
Tekla Quantity - Gross footprint area: 0 m2; Width: 8 mm; sets with these values: 2
Name | Center of gravity Z (mm) | Center of gravity Y (mm) | Center of gravity X (mm) | Bottom elevation | Top elevation | Part mark = Assembly mark | Phase | Class | Net weight (kg) = Weight (kg) | Gross weight (kg) | Net volume (m3) = Gross volume (m3) | Area per tons (m2) | Net surface area (m2) | Gross area (m2) | Height (mm) | Length (mm)
GOUSSET | 5072.11 | 12379.3 | 69703.2 | +5.060 | +5.083 | G65 | 1 | 1009 | 10.6169 | 11.1821 | 0.00135247 | 33.0693 | 0.351092 | 0.178058 | 374.621 | 475.302
GOUSSET | 4413.51 | 66450 | 41277.2 | +4.385 | +4.442 | G23 | 3 | 3004 | 9.49466 | 9.49751 | 0.00120951 | 33.1585 | 0.314829 | 0.151234 | 374.648 | 403.67

# IfcPlate: PL8*376 (2)
In: Undefined
Description: PL8*376; Material: STEEL/E24-2
Tekla Common - Phase: 3; Class: 3004; Finish: GRENAILLE-PEINT; Grade: E24-2; Profile: PL8*376; Name: GOUSSET; sets with these values: 2
Tekla Quantity - Gross footprint area: 0 m2; Width: 8 mm; sets with these values: 2
Name | Center of gravity Z (mm) | Center of gravity Y (mm) | Center of gravity X (mm) | Bottom elevation | Top elevation | Part mark = Assembly mark | Net weight (kg) = Weight (kg) | Gross weight (kg) | Net volume (m3) = Gross volume (m3) | Area per tons (m2) | Net surface area (m2) | Gross area (m2) | Height (mm) | Length (mm)
GOUSSET | 5159.41 | 48053.6 | 35442.5 | +5.131 | +5.188 | G68 | 9.30651 | 9.48884 | 0.00118554 | 33.1649 | 0.308649 | 0.151096 | 375.77 | 402.098
GOUSSET | 4769.8 | 63800.9 | 38360.2 | +4.740 | +4.799 | G6 | 6.72677 | 11.1184 | 0.000856913 | 33.4625 | 0.225094 | 0.177045 | 375.962 | 470.912

# IfcPlate: PL8*378, GOUSSET
In: Undefined
Description: PL8*378; Material: STEEL/E24-2
Tekla Common - Center of gravity Z: 2140.06 mm; Center of gravity Y: 10648.8 mm; Center of gravity X: 79225 mm; Bottom elevation: +1.947; Top elevation: +2.325; Part mark: 799; Assembly mark: B4; Phase: 1; Class: 1002; Finish: GRENAILLE-PEINT; Grade: E24-2; Profile: PL8*378; Name: GOUSSET; sets with these values: 2
Tekla Quantity - Net weight: 11.5386 kg; Gross weight: 13.2547 kg; Weight: 11.5386 kg; Net volume: 0.00146989 m3; Gross volume: 0.00146989 m3; Gross footprint area: 0 m2; Area per tons: 33.0304 m2; Net surface area: 0.381126 m2; Gross area: 0.211062 m2; Height: 377.635 mm; Width: 8 mm; Length: 558.906 mm; sets with these values: 2

# IfcPlate: PL8*382, GOUSSET
In: Undefined
Description: PL8*382; Material: STEEL/E24-2
Tekla Common - Center of gravity Z: 5112.86 mm; Center of gravity Y: 66450 mm; Center of gravity X: 35551.5 mm; Bottom elevation: +5.085; Top elevation: +5.141; Part mark: G22; Assembly mark: G22; Phase: 3; Class: 3004; Finish: GRENAILLE-PEINT; Grade: E24-2; Profile: PL8*382; Name: GOUSSET; sets with these values: 2
Tekla Quantity - Net weight: 9.51463 kg; Gross weight: 9.52407 kg; Weight: 9.51463 kg; Net volume: 0.00121206 m3; Gross volume: 0.00121206 m3; Gross footprint area: 0 m2; Area per tons: 33.1565 m2; Net surface area: 0.315472 m2; Gross area: 0.151657 m2; Height: 381.602 mm; Width: 8 mm; Length: 397.423 mm; sets with these values: 2

# IfcPlate: PL8*388 (3)
In: Undefined
Description: PL8*388; Material: STEEL/E24-2
Tekla Common - Center of gravity Z: 4811.81 mm; Center of gravity Y: 63761.5 mm; Bottom elevation: +4.773; Top elevation: +4.848; Part mark: G32; Assembly mark: G32; Phase: 1; Class: 1004; Finish: GRENAILLE-PEINT; Grade: E24-2; Profile: PL8*388; Name: GOUSSET; sets with these values: 2
Tekla Quantity - Net weight: 10.1004 kg; Gross weight: 13.9168 kg; Weight: 10.1004 kg; Net volume: 0.00128668 m3; Gross volume: 0.00128668 m3; Gross footprint area: 0 m2; Area per tons: 33.1175 m2; Net surface area: 0.3345 m2; Gross area: 0.221605 m2; Height: 388.115 mm; Width: 8 mm; Length: 570.977 mm; sets with these values: 2
Name | Center of gravity X (mm)
GOUSSET | 61638.5
GOUSSET | 49963.5
GOUSSET | 73313.5

# IfcPlate: PL8*404 (2)
In: Undefined
Description: PL8*404; Material: STEEL/E24-2
Tekla Common - Center of gravity Y: 2538.14 mm; Part mark: G11; Assembly mark: G11; Phase: 3; Class: 3004; Finish: GRENAILLE-PEINT; Grade: E24-2; Profile: PL8*404; Name: GOUSSET; sets with these values: 2
Tekla Quantity - Gross weight: 10.2877 kg; Net volume: 0.00123522 m3; Gross volume: 0.00123522 m3; Gross footprint area: 0 m2; Area per tons: 33.1155 m2; Gross area: 0.163817 m2; Height: 404.409 mm; Width: 8 mm; Length: 405.078 mm; sets with these values: 2
Name | Center of gravity Z (mm) | Center of gravity X (mm) | Bottom elevation | Top elevation | Net weight (kg) = Weight (kg) | Net surface area (m2)
GOUSSET | 4446.4 | 29605.1 | +4.418 | +4.475 | 9.69651 | 0.321105
GOUSSET | 5159.13 | 23769.9 | +5.131 | +5.188 | 9.6965 | 0.321104

# IfcPlate: PL8*410 (8)
In: Undefined
Description: PL8*410; Material: STEEL/E24-2
Tekla Common - Finish: GRENAILLE-PEINT; Grade: E24-2; Profile: PL8*410; Name: GOUSSET; sets with these values: 2
Tekla Quantity - Gross footprint area: 0 m2; Height: 410 mm; Width: 8 mm; sets with these values: 2
Name | Center of gravity Z (mm) | Center of gravity Y (mm) | Center of gravity X (mm) | Bottom elevation | Top elevation | Part mark = Assembly mark | Phase | Class | Net weight (kg) = Weight (kg) | Gross weight (kg) | Net volume (m3) = Gross volume (m3) | Area per tons (m2) | Net surface area (m2) | Gross area (m2) | Length (mm)
GOUSSET | 4805.95 | 45471.8 | 26661.4 | +4.767 | +4.835 | G37 | 3 | 3004 | 10.0751 | 12.7148 | 0.00128345 | 33.0959 | 0.333443 | 0.202464 | 493.816
GOUSSET | 4807.39 | 5078.49 | 26649.6 | +4.773 | +4.832 | G9 | 3 | 3004 | 8.43791 | 10.7442 | 0.00107489 | 33.2578 | 0.280626 | 0.171086 | 417.284
GOUSSET | 4807.39 | 5078.49 | 61674.6 | +4.773 | +4.832 | G9 | 1 | 1004 | 8.43791 | 10.7442 | 0.00107489 | 33.2578 | 0.280626 | 0.171086 | 417.284
GOUSSET | 4807.39 | 5078.49 | 38324.6 | +4.773 | +4.832 | G9 | 3 | 3004 | 8.43791 | 10.7442 | 0.00107489 | 33.2578 | 0.280626 | 0.171086 | 417.284
GOUSSET | 4807.39 | 5078.49 | 49999.6 | +4.773 | +4.832 | G9 | 1 | 1004 | 8.43791 | 10.7442 | 0.00107489 | 33.2578 | 0.280626 | 0.171086 | 417.284
GOUSSET | 5009.4 | 5067.75 | 71726 | +4.997 | +5.019 | G10 | 1 | 1009 | 7.94385 | 11.0448 | 0.00101196 | 33.334 | 0.264801 | 0.175873 | 428.958
GOUSSET | 3576.15 | 34888.2 | 4647.5 | +3.566 | +3.586 | G59 | 2 | 2004 | 7.66486 | 8.81791 | 0.000976416 | 33.2524 | 0.254875 | 0.140413 | 342.47
GOUSSET | 3576.15 | 29599.3 | 4647.5 | +3.566 | +3.586 | G59 | 2 | 2004 | 7.66486 | 8.81791 | 0.000976416 | 33.2524 | 0.254875 | 0.140413 | 342.47

# IfcPlate: PL8*45 (2)
In: Undefined
Description: PL8*45; Material: STEEL/S235JR
Tekla Common - Center of gravity Y: 9978 mm; Part mark: 682; Assembly mark: L52; Phase: 2; Class: 2003; Finish: GRENAILLE-PEINT; Grade: S235JR; Profile: PL8*45; Name: TOLE; sets with these values: 2
Tekla Quantity - Net weight: 0.209124 kg; Gross weight: 0.223254 kg; Weight: 0.209124 kg; Net volume: 0.00002664 m3; Gross volume: 0.00002664 m3; Gross footprint area: 0.00333 m2; Area per tons: 40.6621 m2; Net surface area: 0.00850341 m2; Gross area: 0.003555 m2; Height: 45 mm; Width: 8 mm; Length: 79 mm; sets with these values: 2
Name | Center of gravity Z (mm) | Center of gravity X (mm) | Bottom elevation | Top elevation
TOLE | 3609.67 | 9260.78 | +3.606 | +3.614
TOLE | 3920 | -26.1824 | +3.916 | +3.924

# IfcPlate: PL8*49 (9)
In: Undefined
Description: PL8*49; Material: STEEL/E24-2
Tekla Common - Center of gravity Z: 3840 mm; Center of gravity X: -134.5 mm; Bottom elevation: +3.650; Top elevation: +4.030; Part mark: 852; Assembly mark: L118; Phase: 2; Class: 2003; Finish: GRENAILLE-PEINT; Grade: E24-2; Profile: PL8*49; Name: PLAT; sets with these values: 2
Tekla Quantity - Net weight: 1.16934 kg; Gross weight: 1.16934 kg; Weight: 1.16934 kg; Net volume: 0.00014896 m3; Gross volume: 0.00014896 m3; Gross footprint area: 0.000392 m2; Area per tons: 37.7171 m2; Net surface area: 0.044104 m2; Gross area: 0.01862 m2; Height: 49 mm; Width: 8 mm; Length: 380 mm; sets with these values: 2
Name | Center of gravity Y (mm)
PLAT | 10930
PLAT | 13060
PLAT | 15190
PLAT | 17320
PLAT | 19450
PLAT | 21981.2
PLAT | 29375
PLAT | 24512.5
PLAT | 27043.8

# IfcPlate: PL8*69 (10)
In: Undefined
Description: PL8*69
Tekla Common - Finish: GRENAILLE-PEINT; Profile: PL8*69; Name: ATTACHE; sets with these values: 2
