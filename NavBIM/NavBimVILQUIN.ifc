Properties of the parts of a building model (IFC2X3), part 2 of 32

# IfcBeam: IPE270 (7)
Name | Material | Center of gravity Z (mm) | Center of gravity Y (mm) | Center of gravity X (mm) | Bottom elevation | Top elevation | Part mark | Assembly mark | Phase | Class | Grade | Name | Net weight (kg) = NetWeight (kg) | Gross weight (kg) = Weight (kg) | Net volume (m3) = NetVolume (m3) | Gross volume (m3) | Gross footprint area (m2) | Net surface area (m2) | Gross area (m2) = OuterSurfaceArea (m2) | Tekla Quantity, Length (mm) = BaseQuantities, Length (mm)
EMPANNON | STEEL/E24-2 | 5340.47 | 27745 | 74583.2 | +5.110 | +5.570 | K97 | K97 | 1 | 1010 | E24-2 | EMPANNON | 328.22 | 344.045 | 0.0418115 | 0.0438273 | 0 | 10.1497 | 9.93992 | 9548.44
SUPPORT | STEEL/S235JR | 3872.32 | 32243.8 | -86.65 | +3.737 | +4.007 | 1014 | L32 | 5 | 5001 | S235JR | SUPPORT | 4.99948 | 5.21376 | 0.000636877 | 0.000664173 | 0.0195345 | 0.163169 | 0.150633 | 144.7

# IfcBeam: IPE330 (13)
In: Undefined
Description: IPE330
Tekla Common - Profile: IPE330; sets with these values: 2
Tekla Quantity - Area per tons: 25.5184 m2; Height: 330 mm; Width: 160 mm; sets with these values: 2
Name | Material | Center of gravity Z (mm) | Center of gravity Y (mm) | Center of gravity X (mm) | Bottom elevation | Top elevation | Part mark | Assembly mark | Phase | Class | Finish | Grade | Name | Net weight (kg) = NetWeight (kg) | Gross weight (kg) = Weight (kg) | Net volume (m3) = NetVolume (m3) | Gross volume (m3) | Gross footprint area (m2) | Net surface area (m2) | Gross area (m2) = OuterSurfaceArea (m2) | Tekla Quantity, Length (mm) = BaseQuantities, Length (mm)
SUPPORT | STEEL/S235JR | 3475 | 40250 | -301.25 | +3.310 | +3.640 | 170 | E3 | 4 | 4000 | GALVANISE | S235JR | SUPPORT | 19.1373 | 20.025 | 0.00243787 | 0.00255095 | 0.0652 | 0.535602 | 0.511005 | 407.5
SUPPORT | STEEL/S235JR | 3475 | 48525 | -301.25 | +3.310 | +3.640 | 170 | E3 | 4 | 4000 | GALVANISE | S235JR | SUPPORT | 19.1373 | 20.025 | 0.00243787 | 0.00255095 | 0.0652 | 0.535602 | 0.511005 | 407.5
EMPANNON | STEEL/E24-2 | 4931.53 | 66450 | 38430 | +4.071 | +5.792 | K32 | K32 | 3 | 3005 | GRENAILLE-PEINT | E24-2 | EMPANNON | 537.933 | 564.866 | 0.0685265 | 0.0719575 | 0 | 14.7311 | 14.4145 | 11494.8
EMPANNON | STEEL/E24-2 | 4933.33 | 63750 | 38418 | +4.080 | +5.792 | K31 | K31 | 3 | 3005 | GRENAILLE-PEINT | E24-2 | EMPANNON | 536.797 | 564.686 | 0.0683817 | 0.0719345 | 0 | 14.7044 | 14.4099 | 11491.1
EMPANNON | STEEL/E24-2 | 4931.53 | 58450 | 38430 | +4.071 | +5.792 | K30 | K30 | 3 | 3005 | GRENAILLE-PEINT | E24-2 | EMPANNON | 537.933 | 564.866 | 0.0685265 | 0.0719575 | 0 | 14.7311 | 14.4145 | 11494.8
EMPANNON | STEEL/E24-2 | 4931.53 | 55850 | 38430 | +4.071 | +5.792 | K30 | K30 | 3 | 3005 | GRENAILLE-PEINT | E24-2 | EMPANNON | 537.933 | 564.866 | 0.0685265 | 0.0719575 | 0 | 14.7311 | 14.4145 | 11494.8
EMPANNON | STEEL/E24-2 | 4931.53 | 53250 | 38430 | +4.071 | +5.792 | K30 | K30 | 3 | 3005 | GRENAILLE-PEINT | E24-2 | EMPANNON | 537.933 | 564.866 | 0.0685265 | 0.0719575 | 0 | 14.7311 | 14.4145 | 11494.8
EMPANNON | STEEL/E24-2 | 4931.53 | 50650 | 38430 | +4.071 | +5.792 | K29 | K29 | 3 | 3005 | GRENAILLE-PEINT | E24-2 | EMPANNON | 537.933 | 564.866 | 0.0685265 | 0.0719575 | 0 | 14.7311 | 14.4145 | 11494.8
EMPANNON | STEEL/S235JR | 10219.7 | 60985 | 26267.5 | +9.855 | +10.584 | 168 | K33 | 2 | 2005 | GRENAILLE-PEINT | S235JR | EMPANNON | 604.934 | 633.497 | 0.0770617 | 0.0807003 | 0 | 16.5643 | 16.1658 | 12891.4
EMPANNON | STEEL/S235JR | 10219.7 | 58220 | 26267.5 | +9.855 | +10.584 | 168 | K34 | 2 | 2005 | GRENAILLE-PEINT | S235JR | EMPANNON | 604.934 | 633.497 | 0.0770617 | 0.0807003 | 0 | 16.5643 | 16.1658 | 12891.4
EMPANNON | STEEL/S235JR | 10219.7 | 55455 | 26267.5 | +9.855 | +10.584 | 168 | K33 | 2 | 2005 | GRENAILLE-PEINT | S235JR | EMPANNON | 604.934 | 633.497 | 0.0770617 | 0.0807003 | 0 | 16.5643 | 16.1658 | 12891.4
EMPANNON | STEEL/S235JR | 10219.7 | 52690 | 26267.5 | +9.855 | +10.584 | 169 | K35 | 2 | 2005 | GRENAILLE-PEINT | S235JR | EMPANNON | 604.934 | 633.497 | 0.0770617 | 0.0807003 | 0 | 16.5643 | 16.1658 | 12891.4
EMPANNON | STEEL/S235JR | 10219.7 | 63750 | 26267.5 | +9.855 | +10.584 | 169 | K36 | 2 | 2005 | GRENAILLE-PEINT | S235JR | EMPANNON | 604.934 | 633.497 | 0.0770617 | 0.0807003 | 0 | 16.5643 | 16.1658 | 12891.4

# IfcBeam: IPE360, EMPANNON
In: Undefined
Description: IPE360; Material: STEEL/E24-2
Tekla Common - Center of gravity Z: 4919.63 mm; Center of gravity Y: 32450 mm; Center of gravity X: 73450.2 mm; Bottom elevation: +4.056; Top elevation: +5.809; Part mark: 578; Assembly mark: K99; Phase: 1; Class: 1010; Finish: GRENAILLE-PEINT; Grade: E24-2; Profile: IPE360; Name: EMPANNON; sets with these values: 2
Tekla Quantity - Net weight: 636.895 kg; Gross weight: 672.629 kg; Weight: 672.629 kg; Net volume: 0.0811331 m3; Gross volume: 0.0856852 m3; Gross footprint area: 0 m2; Area per tons: 23.7079 m2; Net surface area: 16.0889 m2; Gross area: 15.9466 m2; Height: 360 mm; Width: 170 mm; Length: 11786.1 mm; sets with these values: 2
BaseQuantities - Length: 11786.1 mm; OuterSurfaceArea: 15.9466 m2; NetVolume: 0.0811331 m3; NetWeight: 636.895 kg

# IfcBeam: IPE400 (5)
In: Undefined
Description: IPE400; Material: STEEL/E24-2
Tekla Common - Finish: GRENAILLE-PEINT; Grade: E24-2; Profile: IPE400; sets with these values: 2
Tekla Quantity - Area per tons: 22.1159 m2; Height: 400 mm; Width: 180 mm; sets with these values: 2
Name | Center of gravity Z (mm) | Center of gravity Y (mm) | Center of gravity X (mm) | Bottom elevation | Top elevation | Part mark | Assembly mark | Phase | Class | Name | Net weight (kg) = NetWeight (kg) | Gross weight (kg) = Weight (kg) | Net volume (m3) = NetVolume (m3) | Gross volume (m3) | Gross footprint area (m2) | Net surface area (m2) | Gross area (m2) = OuterSurfaceArea (m2) | Tekla Quantity, Length (mm) = BaseQuantities, Length (mm)
POUTRES | 3840 | 33175 | -1.53887e-15 | +3.640 | +4.040 | 5 | N21 | 2 | 2006 | POUTRES | 895.518 | 937.942 | 0.114079 | 0.119483 | 2.5452 | 21.2657 | 20.7434 | 14140
POUTRES | 3840 | 22330 | -1.45887e-15 | +3.640 | +4.040 | 4 | N19 | 2 | 2006 | POUTRES | 476.892 | 499.484 | 0.0607505 | 0.0636285 | 1.3554 | 11.3322 | 11.0465 | 7530
POUTRES | 3840 | 14295.5 | -3.02635e-15 | +3.640 | +4.040 | 3 | N20 | 2 | 2006 | POUTRES | 539.527 | 565.087 | 0.0687296 | 0.0719855 | 1.53342 | 12.8185 | 12.4974 | 8519
POUTRES | 3840 | 44847.5 | 4.25859e-16 | +3.640 | +4.040 | 6 | N22 | 2 | 2006 | POUTRES | 581.707 | 609.264 | 0.0741027 | 0.0776132 | 1.6533 | 13.8194 | 13.4744 | 9185
EMPANNON | 4899.32 | 61050 | 38405 | +4.009 | +5.790 | 2 | K1 | 3 | 3005 | EMPANNON | 719.697 | 757.032 | 0.0916811 | 0.0964372 | 0 | 17.0938 | 16.7424 | 11412.7

# IfcBeam: IPE450 (8)
In: Undefined
Description: IPE450; Material: STEEL/E24-2
Tekla Common - Center of gravity Z: 4865.28 mm; Bottom elevation: +3.959; Top elevation: +5.771; Part mark: 868; Finish: GRENAILLE-PEINT; Grade: E24-2; Profile: IPE450; Name: EMPANNON; sets with these values: 2
Tekla Quantity - Net weight: 836.122 kg; Gross weight: 873.508 kg; Weight: 873.508 kg; Net volume: 0.106512 m3; Gross volume: 0.111275 m3; Gross footprint area: 0 m2; Area per tons: 20.6942 m2; Net surface area: 18.4132 m2; Gross area: 18.0765 m2; Height: 450 mm; Width: 190 mm; Length: 11262.6 mm; sets with these values: 2
BaseQuantities - Length: 11262.6 mm; OuterSurfaceArea: 18.0765 m2; NetVolume: 0.106512 m3; NetWeight: 836.122 kg
Name | Center of gravity Y (mm) | Center of gravity X (mm) | Assembly mark | Phase | Class
EMPANNON | 19450 | 50152.5 | K21 | 1 | 1005
EMPANNON | 40250 | 50152.5 | K22 | 1 | 1005
EMPANNON | 19450 | 26802.5 | K21 | 3 | 3005
EMPANNON | 19450 | 38477.5 | K21 | 3 | 3005
EMPANNON | 19450 | 61827.5 | K21 | 1 | 1005
EMPANNON | 40250 | 61827.5 | K24 | 1 | 1005
EMPANNON | 40250 | 26802.5 | K23 | 3 | 3005
EMPANNON | 40250 | 38477.5 | K22 | 3 | 3005

# IfcBeam: IPE500 (5)
In: Undefined
Description: IPE500; Material: STEEL/E24-2
Tekla Common - Finish: GRENAILLE-PEINT; Grade: E24-2; Profile: IPE500; Name: POUTRES; sets with these values: 2
Tekla Quantity - Area per tons: 19.1522 m2; Height: 500 mm; Width: 200 mm; sets with these values: 2
Name | Center of gravity Z (mm) | Center of gravity Y (mm) | Center of gravity X (mm) | Bottom elevation | Top elevation | Part mark | Assembly mark | Phase | Class | Net weight (kg) = NetWeight (kg) | Gross weight (kg) = Weight (kg) | Net volume (m3) = NetVolume (m3) | Gross volume (m3) | Gross footprint area (m2) | Net surface area (m2) | Gross area (m2) = OuterSurfaceArea (m2) | Tekla Quantity, Length (mm) = BaseQuantities, Length (mm)
POUTRES | 3464.67 | 14821.4 | 9293.82 | +3.215 | +3.715 | 124 | N4 | 2 | 2006 | 810.057 | 856.784 | 0.103192 | 0.109144 | 1.82116 | 16.5241 | 16.4093 | 9409
POUTRES | 3464.67 | 24512.5 | 9295 | +3.215 | +3.715 | 123 | N3 | 2 | 2006 | 887.215 | 921.072 | 0.113021 | 0.117334 | 2.023 | 18.023 | 17.6406 | 10115
POUTRES | 3464.67 | 34912.5 | 9295 | +3.215 | +3.715 | 122 | N2 | 2 | 2006 | 935.457 | 971.155 | 0.119166 | 0.123714 | 2.133 | 19.0018 | 18.5998 | 10665
POUTRES | 3464.67 | 44764.9 | 9293.76 | +3.215 | +3.715 | 121 | N1 | 2 | 2006 | 790.014 | 836.386 | 0.100639 | 0.106546 | 1.77479 | 16.1191 | 16.0186 | 9185
POUTRES | 3750 | 20405 | 71815 | +3.500 | +4.000 | 125 | N5 | 1 | 1011 | 1182.37 | 1227.49 | 0.15062 | 0.156368 | 2.696 | 24.0114 | 23.5091 | 13480

# IfcBeam: IPEA300 (314)
In: Undefined
Description: IPEA300; Material: STEEL/E36-3
Tekla Common - Finish: GRENAILLE-PEINT; Grade: E36-3; Profile: IPEA300; sets with these values: 2
Tekla Quantity - Area per tons: 31.7786 m2; Height: 297 mm; Width: 150 mm; sets with these values: 2
Name | Center of gravity Z (mm) | Center of gravity Y (mm) | Center of gravity X (mm) | Bottom elevation | Top elevation | Part mark | Assembly mark | Phase | Class | Name | Net weight (kg) = NetWeight (kg) | Gross weight (kg) = Weight (kg) | Net volume (m3) = NetVolume (m3) | Gross volume (m3) | Gross footprint area (m2) | Net surface area (m2) | Gross area (m2) = OuterSurfaceArea (m2) | Tekla Quantity, Length (mm) = BaseQuantities, Length (mm)
EMPANNON | 3191.25 | -1244.84 | 20850 | +3.023 | +3.360 | 95 | K94 | 3 | 3003 | EMPANNON | 70.016 | 73.2295 | 0.00891924 | 0.0093286 | 0 | 2.37261 | 2.32714 | 2006.15
EMPANNON | 3727.79 | 43008.3 | 4645.28 | +3.418 | +4.036 | 93 | K83 | 2 | 2005 | EMPANNON | 322.217 | 338.753 | 0.0410468 | 0.0431532 | 0 | 10.8958 | 10.7651 | 9280.27
EMPANNON | 3383.58 | 43008.3 | 15064.6 | +3.059 | +3.708 | 91 | K67 | 2 | 2005 | EMPANNON | 399.217 | 418.419 | 0.0508556 | 0.0533017 | 0 | 13.4852 | 13.2968 | 11462.7
EMPANNON | 3727.79 | 40250 | 4645.28 | +3.418 | +4.036 | 93 | K83 | 2 | 2005 | EMPANNON | 322.217 | 338.753 | 0.0410468 | 0.0431532 | 0 | 10.8958 | 10.7651 | 9280.27
EMPANNON | 3382.67 | 40250 | 15035.1 | +3.059 | +3.707 | 89 | K64 | 2 | 2005 | EMPANNON | 397.15 | 416.264 | 0.0505924 | 0.0530272 | 0 | 13.4155 | 13.2283 | 11403.7
EMPANNON | 3383.58 | 15190 | 15064.6 | +3.059 | +3.708 | 88 | K63 | 2 | 2005 | EMPANNON | 399.217 | 418.419 | 0.0508556 | 0.0533017 | 0 | 13.4852 | 13.2968 | 11462.7
EMPANNON | 3727.79 | 15190 | 4645.28 | +3.418 | +4.036 | 86 | K81 | 2 | 2005 | EMPANNON | 322.217 | 338.753 | 0.0410468 | 0.0431532 | 0 | 10.8958 | 10.7651 | 9280.27
EMPANNON | 3383.58 | 17320 | 15064.6 | +3.059 | +3.708 | 91 | K68 | 2 | 2005 | EMPANNON | 399.217 | 418.419 | 0.0508556 | 0.0533017 | 0 | 13.4852 | 13.2968 | 11462.7
EMPANNON | 3727.79 | 17320 | 4645.28 | +3.418 | +4.036 | 85 | K80 | 2 | 2005 | EMPANNON | 322.217 | 338.753 | 0.0410468 | 0.0431532 | 0 | 10.8958 | 10.7651 | 9280.27
EMPANNON | 3382.67 | 19450 | 15035.1 | +3.059 | +3.707 | 89 | K66 | 2 | 2005 | EMPANNON | 397.15 | 416.264 | 0.0505924 | 0.0530272 | 0 | 13.4155 | 13.2283 | 11403.7
EMPANNON | 3727.79 | 19450 | 4645.28 | +3.418 | +4.036 | 84 | K79 | 2 | 2005 | EMPANNON | 322.217 | 338.753 | 0.0410468 | 0.0431532 | 0 | 10.8958 | 10.7651 | 9280.27
EMPANNON | 3383.58 | 32243.8 | 15064.6 | +3.059 | +3.708 | 91 | K69 | 2 | 2005 | EMPANNON | 399.217 | 418.419 | 0.0508556 | 0.0533017 | 0 | 13.4852 | 13.2968 | 11462.7
EMPANNON | 3383.58 | 21981.2 | 15064.6 | +3.059 | +3.708 | 91 | K71 | 2 | 2005 | EMPANNON | 399.217 | 418.419 | 0.0508556 | 0.0533017 | 0 | 13.4852 | 13.2968 | 11462.7
EMPANNON | 3175.37 | -450.863 | 44199.6 | +3.023 | +3.328 | 99 | K20 | 3 | 3003 | EMPANNON | 14.4143 | 15.6156 | 0.00183622 | 0.00198925 | 0 | 0.495576 | 0.496244 | 427.796
EMPANNON | 4956.4 | 48050 | 38362.5 | +4.104 | +5.809 | K16 | K16 | 3 | 3005 | EMPANNON | 405.746 | 424.406 | 0.0516874 | 0.0540645 | 0 | 13.7066 | 13.4871 | 11626.8
EMPANNON | 4955.2 | 45450 | 38374.9 | +4.104 | +5.809 | K14 | K14 | 3 | 3005 | EMPANNON | 404.869 | 424.406 | 0.0515757 | 0.0540645 | 0 | 13.6811 | 13.4871 | 11626.8
EMPANNON | 4956.4 | 42850 | 38362.5 | +4.104 | +5.809 | K16 | K16 | 3 | 3005 | EMPANNON | 405.746 | 424.406 | 0.0516874 | 0.0540645 | 0 | 13.7066 | 13.4871 | 11626.8
EMPANNON | 4956.97 | -5.58517e-15 | 50037.9 | +4.116 | +5.806 | K18 | K18 | 1 | 1005 | EMPANNON | 402.256 | 422.456 | 0.0512427 | 0.0538161 | 0 | 13.5968 | 13.4251 | 11573.4
EMPANNON | 4956.4 | 2550 | 50037.5 | +4.104 | +5.809 | K11 | K11 | 1 | 1005 | EMPANNON | 405.746 | 424.406 | 0.0516874 | 0.0540645 | 0 | 13.7066 | 13.4871 | 11626.8
EMPANNON | 4956.97 | 5100 | 50037.9 | +4.113 | +5.809 | K12 | K12 | 1 | 1005 | EMPANNON | 404.019 | 424.295 | 0.0514674 | 0.0540503 | 0 | 13.6563 | 13.4835 | 11623.7
EMPANNON | 4955.2 | 10010 | 50049.9 | +4.104 | +5.809 | K14 | K14 | 1 | 1005 | EMPANNON | 404.869 | 424.406 | 0.0515757 | 0.0540645 | 0 | 13.6811 | 13.4871 | 11626.8
EMPANNON | 4956.4 | 12370 | 50037.5 | +4.104 | +5.809 | K16 | K16 | 1 | 1005 | EMPANNON | 405.746 | 424.406 | 0.0516874 | 0.0540645 | 0 | 13.7066 | 13.4871 | 11626.8
EMPANNON | 4955.2 | 14730 | 50049.9 | +4.104 | +5.809 | K14 | K14 | 1 | 1005 | EMPANNON | 404.869 | 424.406 | 0.0515757 | 0.0540645 | 0 | 13.6811 | 13.4871 | 11626.8
EMPANNON | 4956.4 | 17090 | 50037.5 | +4.104 | +5.809 | K16 | K16 | 1 | 1005 | EMPANNON | 405.746 | 424.406 | 0.0516874 | 0.0540645 | 0 | 13.7066 | 13.4871 | 11626.8
EMPANNON | 4956.4 | 22050 | 50037.5 | +4.104 | +5.809 | K16 | K16 | 1 | 1005 | EMPANNON | 405.746 | 424.406 | 0.0516874 | 0.0540645 | 0 | 13.7066 | 13.4871 | 11626.8
EMPANNON | 4955.2 | 24650 | 50049.9 | +4.104 | +5.809 | K14 | K14 | 1 | 1005 | EMPANNON | 404.869 | 424.406 | 0.0515757 | 0.0540645 | 0 | 13.6811 | 13.4871 | 11626.8
EMPANNON | 4956.4 | 27250 | 50037.5 | +4.104 | +5.809 | K16 | K16 | 1 | 1005 | EMPANNON | 405.746 | 424.406 | 0.0516874 | 0.0540645 | 0 | 13.7066 | 13.4871 | 11626.8
EMPANNON | 4965.2 | 29850 | 50049.9 | +4.114 | +5.819 | K15 | K15 | 1 | 1005 | EMPANNON | 404.869 | 424.406 | 0.0515757 | 0.0540645 | 0 | 13.6811 | 13.4871 | 11626.8
EMPANNON | 4956.4 | 32450 | 50037.5 | +4.104 | +5.809 | K16 | K16 | 1 | 1005 | EMPANNON | 405.746 | 424.406 | 0.0516874 | 0.0540645 | 0 | 13.7066 | 13.4871 | 11626.8
EMPANNON | 4955.2 | 35050 | 50049.9 | +4.104 | +5.809 | K14 | K14 | 1 | 1005 | EMPANNON | 404.869 | 424.406 | 0.0515757 | 0.0540645 | 0 | 13.6811 | 13.4871 | 11626.8
EMPANNON | 4956.4 | 37650 | 50037.5 | +4.104 | +5.809 | K16 | K16 | 1 | 1005 | EMPANNON | 405.746 | 424.406 | 0.0516874 | 0.0540645 | 0 | 13.7066 | 13.4871 | 11626.8
EMPANNON | 3727.79 | 10930 | 4645.28 | +3.418 | +4.036 | 80 | K75 | 2 | 2005 | EMPANNON | 322.217 | 338.753 | 0.0410468 | 0.0431532 | 0 | 10.8958 | 10.7651 | 9280.27
EMPANNON | 3383.58 | 10930 | 15064.6 | +3.059 | +3.708 | 90 | K102 | 2 | 2005 | EMPANNON | 399.217 | 418.419 | 0.0508556 | 0.0533017 | 0 | 13.4852 | 13.2968 | 11462.7
EMPANNON | 3727.79 | 13060 | 4645.28 | +3.418 | +4.036 | 79 | K74 | 2 | 2005 | EMPANNON | 322.217 | 338.753 | 0.0410468 | 0.0431532 | 0 | 10.8958 | 10.7651 | 9280.27
EMPANNON | 3383.58 | 13060 | 15064.6 | +3.059 | +3.708 | 87 | K72 | 2 | 2005 | EMPANNON | 399.217 | 418.419 | 0.0508556 | 0.0533017 | 0 | 13.4852 | 13.2968 | 11462.7
EMPANNON | 3383.58 | 24512.5 | 15064.6 | +3.059 | +3.708 | 88 | K65 | 2 | 2005 | EMPANNON | 399.217 | 418.419 | 0.0508556 | 0.0533017 | 0 | 13.4852 | 13.2968 | 11462.7
EMPANNON | 3383.58 | 45766.7 | 15064.6 | +3.059 | +3.708 | 46 | K60 | 2 | 2005 | EMPANNON | 399.217 | 418.419 | 0.0508556 | 0.0533017 | 0 | 13.4852 | 13.2968 | 11462.7
EMPANNON | 3727.79 | 45766.7 | 4645.28 | +3.418 | +4.036 | 93 | K83 | 2 | 2005 | EMPANNON | 322.217 | 338.753 | 0.0410468 | 0.0431532 | 0 | 10.8958 | 10.7651 | 9280.27
EMPANNON | 3379.81 | 48525 | 14942.6 | +3.059 | +3.701 | 59 | K101 | 2 | 2005 | EMPANNON | 390.667 | 409.504 | 0.0497665 | 0.0521661 | 0 | 13.1966 | 13.0135 | 11218.5
EMPANNON | 3727.79 | 48525 | 4645.28 | +3.418 | +4.036 | 92 | K82 | 2 | 2005 | EMPANNON | 322.217 | 338.753 | 0.0410468 | 0.0431532 | 0 | 10.8958 | 10.7651 | 9280.27
EMPANNON | 3727.79 | 34912.5 | 4645.28 | +3.418 | +4.036 | 77 | K85 | 2 | 2005 | EMPANNON | 322.217 | 338.753 | 0.0410468 | 0.0431532 | 0 | 10.8958 | 10.7651 | 9280.27
EMPANNON | 3727.79 | 29575 | 4645.28 | +3.418 | +4.036 | 76 | K84 | 2 | 2005 | EMPANNON | 322.217 | 338.753 | 0.0410468 | 0.0431532 | 0 | 10.8958 | 10.7651 | 9280.27
EMPANNON | 3383.58 | 29575 | 15064.6 | +3.059 | +3.708 | 75 | K62 | 2 | 2005 | EMPANNON | 399.217 | 418.419 | 0.0508556 | 0.0533017 | 0 | 13.4852 | 13.2968 | 11462.7
POUTRES | 4088.5 | 43120.8 | 20850 | +3.940 | +4.237 | 37 | N46 | 2 | 2006 | POUTRES | 199.235 | 207.748 | 0.0253803 | 0.0264647 | 0.853701 | 6.73494 | 6.60195 | 5691.34
EMPANNON | 3727.79 | 27043.8 | 4645.28 | +3.418 | +4.036 | 81 | K76 | 2 | 2005 | EMPANNON | 322.217 | 338.753 | 0.0410468 | 0.0431532 | 0 | 10.8958 | 10.7651 | 9280.27
POUTRES | 4915 | 45450 | 20850 | +4.237 | +5.593 | 34 | N46 | 2 | 2006 | POUTRES | 47.4692 | 49.4974 | 0.00604703 | 0.0063054 | 0.00445946 | 1.61144 | 1.57296 | 1356
POUTRES | 4915 | 42850 | 20850 | +4.237 | +5.593 | 34 | N46 | 2 | 2006 | POUTRES | 47.4692 | 49.4974 | 0.00604703 | 0.0063054 | 0.00445946 | 1.61144 | 1.57296 | 1356
POUTRES | 5741.5 | 44192.5 | 20850 | +5.593 | +5.890 | 36 | N46 | 2 | 2006 | POUTRES | 273.924 | 285.628 | 0.0348948 | 0.0363858 | 1.17374 | 9.25639 | 9.07688 | 7824.9
POUTRES | 4088.5 | 45030.1 | 32525 | +3.940 | +4.237 | 29 | N43 | 3 | 3003 | POUTRES | 332.911 | 347.135 | 0.042409 | 0.044221 | 1.42649 | 11.2477 | 11.0315 | 9509.9
POUTRES | 5741.5 | 44990 | 32525 | +5.593 | +5.890 | 28 | N43 | 3 | 3003 | POUTRES | 329.76 | 343.85 | 0.0420077 | 0.0438025 | 1.41299 | 11.1414 | 10.9271 | 9419.9
POUTRES | 4915 | 48050 | 32525 | +4.237 | +5.593 | 34 | N43 | 3 | 3003 | POUTRES | 47.4692 | 49.4974 | 0.00604703 | 0.0063054 | 0.00445946 | 1.61144 | 1.57296 | 1356
POUTRES | 4915 | 45450 | 32525 | +4.237 | +5.593 | 34 | N43 | 3 | 3003 | POUTRES | 47.4692 | 49.4974 | 0.00604703 | 0.0063054 | 0.00445946 | 1.61144 | 1.57296 | 1356
POUTRES | 4915 | 42850 | 32525 | +4.237 | +5.593 | 34 | N43 | 3 | 3003 | POUTRES | 47.4692 | 49.4974 | 0.00604703 | 0.0063054 | 0.00445946 | 1.61144 | 1.57296 | 1356
EMPANNON | 3383.58 | 27043.8 | 15064.6 | +3.059 | +3.708 | 91 | K71 | 2 | 2005 | EMPANNON | 399.217 | 418.419 | 0.0508556 | 0.0533017 | 0 | 13.4852 | 13.2968 | 11462.7
EMPANNON | 4956.4 | 17090 | 38362.5 | +4.104 | +5.809 | K16 | K16 | 3 | 3005 | EMPANNON | 405.746 | 424.406 | 0.0516874 | 0.0540645 | 0 | 13.7066 | 13.4871 | 11626.8
EMPANNON | 4955.99 | 48029.9 | 26690.2 | +4.113 | +5.809 | K19 | K19 | 3 | 3003 | EMPANNON | 403.844 | 424.295 | 0.051445 | 0.0540503 | 0 | 13.6527 | 13.4835 | 11623.7
EMPANNON | 4948.46 | 61050 | 61777.5 | +4.112 | +5.785 | 62 | K41 | 1 | 1005 | EMPANNON | 396.929 | 415.213 | 0.0505642 | 0.0528934 | 0 | 13.409 | 13.1949 | 11374.9
EMPANNON | 4948.46 | 7650 | 61777.5 | +4.112 | +5.785 | 67 | K42 | 1 | 1005 | EMPANNON | 396.929 | 415.213 | 0.0505642 | 0.0528934 | 0 | 13.409 | 13.1949 | 11374.9
EMPANNON | 4948.46 | 7650 | 26752.5 | +4.112 | +5.785 | 67 | K42 | 3 | 3005 | EMPANNON | 396.929 | 415.213 | 0.0505642 | 0.0528934 | 0 | 13.409 | 13.1949 | 11374.9
POUTRES | 4088.5 | 13549.6 | 20850 | +3.940 | +4.237 | 31 | N49 | 2 | 2006 | POUTRES | 411.35 | 428.926 | 0.0524013 | 0.0546403 | 1.76259 | 13.8958 | 13.6307 | 11750.6
POUTRES | 5741.5 | 13547.1 | 20850 | +5.593 | +5.890 | 32 | N49 | 2 | 2006 | POUTRES | 411.175 | 428.744 | 0.052379 | 0.054617 | 1.76184 | 13.8899 | 13.6249 | 11745.6
POUTRES | 4088.5 | 23897.5 | 20850 | +3.940 | +4.237 | 24 | N45 | 2 | 2006 | POUTRES | 309.628 | 322.857 | 0.039443 | 0.0411283 | 1.32672 | 10.4617 | 10.26 | 8844.8
POUTRES | 4088.5 | 34277.4 | 20850 | +3.940 | +4.237 | 25 | N44 | 2 | 2006 | POUTRES | 416.405 | 434.197 | 0.0530453 | 0.0553117 | 1.78425 | 14.0664 | 13.7982 | 11895
POUTRES | 5741.5 | 34274.9 | 20850 | +5.593 | +5.890 | 26 | N44 | 2 | 2006 | POUTRES | 416.23 | 434.015 | 0.053023 | 0.0552885 | 1.7835 | 14.0605 | 13.7924 | 11890
POUTRES | 5741.5 | 23900 | 20850 | +5.593 | +5.890 | 27 | N45 | 2 | 2006 | POUTRES | 309.453 | 322.675 | 0.0394207 | 0.0411051 | 1.32597 | 10.4558 | 10.2542 | 8839.8
POUTRES | 4915 | 37650 | 20850 | +4.237 | +5.593 | 34 | N44 | 2 | 2006 | POUTRES | 47.4692 | 49.4974 | 0.00604703 | 0.0063054 | 0.00445946 | 1.61144 | 1.57296 | 1356
POUTRES | 4915 | 35050 | 20850 | +4.237 | +5.593 | 34 | N44 | 2 | 2006 | POUTRES | 47.4692 | 49.4974 | 0.00604703 | 0.0063054 | 0.00445946 | 1.61144 | 1.57296 | 1356
POUTRES | 4915 | 32450 | 20850 | +4.237 | +5.593 | 34 | N44 | 2 | 2006 | POUTRES | 47.4692 | 49.4974 | 0.00604703 | 0.0063054 | 0.00445946 | 1.61144 | 1.57296 | 1356
POUTRES | 4915 | 29850 | 20850 | +4.237 | +5.593 | 34 | N44 | 2 | 2006 | POUTRES | 47.4692 | 49.4974 | 0.00604703 | 0.0063054 | 0.00445946 | 1.61144 | 1.57296 | 1356
POUTRES | 4915 | 27250 | 20850 | +4.237 | +5.593 | 34 | N45 | 2 | 2006 | POUTRES | 47.4692 | 49.4974 | 0.00604703 | 0.0063054 | 0.00445946 | 1.61144 | 1.57296 | 1356
POUTRES | 4915 | 24650 | 20850 | +4.237 | +5.593 | 34 | N45 | 2 | 2006 | POUTRES | 47.4692 | 49.4974 | 0.00604703 | 0.0063054 | 0.00445946 | 1.61144 | 1.57296 | 1356
POUTRES | 4915 | 22050 | 20850 | +4.237 | +5.593 | 34 | N45 | 2 | 2006 | POUTRES | 47.4692 | 49.4974 | 0.00604703 | 0.0063054 | 0.00445946 | 1.61144 | 1.57296 | 1356
POUTRES | 4915 | 17090 | 20850 | +4.237 | +5.593 | 34 | N49 | 2 | 2006 | POUTRES | 47.4692 | 49.4974 | 0.00604703 | 0.0063054 | 0.00445946 | 1.61144 | 1.57296 | 1356
POUTRES | 4915 | 14730 | 20850 | +4.237 | +5.593 | 34 | N49 | 2 | 2006 | POUTRES | 47.4692 | 49.4974 | 0.00604703 | 0.0063054 | 0.00445946 | 1.61144 | 1.57296 | 1356
POUTRES | 4915 | 12370 | 20850 | +4.237 | +5.593 | 34 | N49 | 2 | 2006 | POUTRES | 47.4692 | 49.4974 | 0.00604703 | 0.0063054 | 0.00445946 | 1.61144 | 1.57296 | 1356
POUTRES | 4915 | 10010 | 20850 | +4.237 | +5.593 | 34 | N49 | 2 | 2006 | POUTRES | 47.4692 | 49.4974 | 0.00604703 | 0.0063054 | 0.00445946 | 1.61144 | 1.57296 | 1356
POUTRES | 5741.5 | 3960.35 | 67550 | +5.593 | +5.890 | 30 | N14 | 1 | 1006 | POUTRES | 256.624 | 267.589 | 0.032691 | 0.0340878 | 1.0996 | 8.67234 | 8.50361 | 7330.7
POUTRES | 4088.5 | 3960.35 | 67550 | +3.940 | +4.237 | 30 | N14 | 1 | 1006 | POUTRES | 256.624 | 267.589 | 0.032691 | 0.0340878 | 1.0996 | 8.67234 | 8.50361 | 7330.7
POUTRES | 4088.5 | 13549.6 | 67550 | +3.940 | +4.237 | 31 | N12 | 1 | 1006 | POUTRES | 411.35 | 428.926 | 0.0524013 | 0.0546403 | 1.76259 | 13.8958 | 13.6307 | 11750.6
POUTRES | 5741.5 | 13547.1 | 67550 | +5.593 | +5.890 | 32 | N12 | 1 | 1006 | POUTRES | 411.175 | 428.744 | 0.052379 | 0.054617 | 1.76184 | 13.8899 | 13.6249 | 11745.6
POUTRES | 4088.5 | 23897.5 | 67550 | +3.940 | +4.237 | 24 | N11 | 1 | 1006 | POUTRES | 309.628 | 322.857 | 0.039443 | 0.0411283 | 1.32672 | 10.4617 | 10.26 | 8844.8
POUTRES | 4088.5 | 46222.6 | 67550 | +3.940 | +4.237 | 25 | N6 | 1 | 1006 | POUTRES | 416.405 | 434.197 | 0.0530453 | 0.0553117 | 1.78425 | 14.0664 | 13.7982 | 11895
POUTRES | 4088.5 | 34277.4 | 67550 | +3.940 | +4.237 | 25 | N7 | 1 | 1006 | POUTRES | 416.405 | 434.197 | 0.0530453 | 0.0553117 | 1.78425 | 14.0664 | 13.7982 | 11895
POUTRES | 5741.5 | 34274.9 | 67550 | +5.593 | +5.890 | 26 | N7 | 1 | 1006 | POUTRES | 416.23 | 434.015 | 0.053023 | 0.0552885 | 1.7835 | 14.0605 | 13.7924 | 11890
POUTRES | 5741.5 | 23900 | 67550 | +5.593 | +5.890 | 27 | N11 | 1 | 1006 | POUTRES | 309.453 | 322.675 | 0.0394207 | 0.0411051 | 1.32597 | 10.4558 | 10.2542 | 8839.8
POUTRES | 5741.5 | 46225.1 | 67550 | +5.593 | +5.890 | 26 | N6 | 1 | 1006 | POUTRES | 416.23 | 434.015 | 0.053023 | 0.0552885 | 1.7835 | 14.0605 | 13.7924 | 11890
POUTRES | 5741.5 | 64964.7 | 67550 | +5.593 | +5.890 | 33 | N17 | 1 | 1006 | POUTRES | 272.377 | 284.015 | 0.0346977 | 0.0361803 | 1.16711 | 9.20415 | 9.02561 | 7780.7
POUTRES | 4088.5 | 64964.7 | 67550 | +3.940 | +4.237 | 33 | N17 | 1 | 1006 | POUTRES | 272.377 | 284.015 | 0.0346977 | 0.0361803 | 1.16711 | 9.20415 | 9.02561 | 7780.7
POUTRES | 4088.5 | 56602.9 | 67550 | +3.940 | +4.237 | 24 | N13 | 1 | 1006 | POUTRES | 309.656 | 322.887 | 0.0394466 | 0.041132 | 1.32684 | 10.4626 | 10.2609 | 8845.6
POUTRES | 5741.5 | 56602.9 | 67550 | +5.593 | +5.890 | 24 | N13 | 1 | 1006 | POUTRES | 309.656 | 322.887 | 0.0394466 | 0.041132 | 1.32684 | 10.4626 | 10.2609 | 8845.6
POUTRES | 4915 | 66450 | 67550 | +4.237 | +5.593 | 34 | N17 | 1 | 1006 | POUTRES | 47.4692 | 49.4974 | 0.00604703 | 0.0063054 | 0.00445946 | 1.61144 | 1.57296 | 1356
POUTRES | 4915 | 63750 | 67550 | +4.237 | +5.593 | 34 | N17 | 1 | 1006 | POUTRES | 47.4692 | 49.4974 | 0.00604703 | 0.0063054 | 0.00445946 | 1.61144 | 1.57296 | 1356
POUTRES | 4915 | 58450 | 67550 | +4.237 | +5.593 | 34 | N13 | 1 | 1006 | POUTRES | 47.4692 | 49.4974 | 0.00604703 | 0.0063054 | 0.00445946 | 1.61144 | 1.57296 | 1356
POUTRES | 4915 | 55850 | 67550 | +4.237 | +5.593 | 34 | N13 | 1 | 1006 | POUTRES | 47.4692 | 49.4974 | 0.00604703 | 0.0063054 | 0.00445946 | 1.61144 | 1.57296 | 1356
POUTRES | 4915 | 53250 | 67550 | +4.237 | +5.593 | 34 | N13 | 1 | 1006 | POUTRES | 47.4692 | 49.4974 | 0.00604703 | 0.0063054 | 0.00445946 | 1.61144 | 1.57296 | 1356
POUTRES | 4915 | 50650 | 67550 | +4.237 | +5.593 | 34 | N6 | 1 | 1006 | POUTRES | 47.4692 | 49.4974 | 0.00604703 | 0.0063054 | 0.00445946 | 1.61144 | 1.57296 | 1356
POUTRES | 4915 | 48050 | 67550 | +4.237 | +5.593 | 34 | N6 | 1 | 1006 | POUTRES | 47.4692 | 49.4974 | 0.00604703 | 0.0063054 | 0.00445946 | 1.61144 | 1.57296 | 1356
POUTRES | 4915 | 45450 | 67550 | +4.237 | +5.593 | 34 | N6 | 1 | 1006 | POUTRES | 47.4692 | 49.4974 | 0.00604703 | 0.0063054 | 0.00445946 | 1.61144 | 1.57296 | 1356
POUTRES | 4915 | 42850 | 67550 | +4.237 | +5.593 | 34 | N6 | 1 | 1006 | POUTRES | 47.4692 | 49.4974 | 0.00604703 | 0.0063054 | 0.00445946 | 1.61144 | 1.57296 | 1356
POUTRES | 4915 | 37650 | 67550 | +4.237 | +5.593 | 34 | N7 | 1 | 1006 | POUTRES | 47.4692 | 49.4974 | 0.00604703 | 0.0063054 | 0.00445946 | 1.61144 | 1.57296 | 1356
POUTRES | 4915 | 35050 | 67550 | +4.237 | +5.593 | 34 | N7 | 1 | 1006 | POUTRES | 47.4692 | 49.4974 | 0.00604703 | 0.0063054 | 0.00445946 | 1.61144 | 1.57296 | 1356
POUTRES | 4915 | 32450 | 67550 | +4.237 | +5.593 | 34 | N7 | 1 | 1006 | POUTRES | 47.4692 | 49.4974 | 0.00604703 | 0.0063054 | 0.00445946 | 1.61144 | 1.57296 | 1356
POUTRES | 4915 | 29850 | 67550 | +4.237 | +5.593 | 34 | N7 | 1 | 1006 | POUTRES | 47.4692 | 49.4974 | 0.00604703 | 0.0063054 | 0.00445946 | 1.61144 | 1.57296 | 1356
POUTRES | 4915 | 27250 | 67550 | +4.237 | +5.593 | 34 | N11 | 1 | 1006 | POUTRES | 47.4692 | 49.4974 | 0.00604703 | 0.0063054 | 0.00445946 | 1.61144 | 1.57296 | 1356
POUTRES | 4915 | 24650 | 67550 | +4.237 | +5.593 | 34 | N11 | 1 | 1006 | POUTRES | 47.4692 | 49.4974 | 0.00604703 | 0.0063054 | 0.00445946 | 1.61144 | 1.57296 | 1356
POUTRES | 4915 | 22050 | 67550 | +4.237 | +5.593 | 34 | N11 | 1 | 1006 | POUTRES | 47.4692 | 49.4974 | 0.00604703 | 0.0063054 | 0.00445946 | 1.61144 | 1.57296 | 1356
POUTRES | 4915 | 17090 | 67550 | +4.237 | +5.593 | 23 | N12 | 1 | 1006 | POUTRES | 47.4692 | 49.4974 | 0.00604703 | 0.0063054 | 0.00445946 | 1.61144 | 1.57296 | 1356
POUTRES | 4915 | 14730 | 67550 | +4.237 | +5.593 | 34 | N12 | 1 | 1006 | POUTRES | 47.4692 | 49.4974 | 0.00604703 | 0.0063054 | 0.00445946 | 1.61144 | 1.57296 | 1356
POUTRES | 4915 | 12370 | 67550 | +4.237 | +5.593 | 23 | N12 | 1 | 1006 | POUTRES | 47.4692 | 49.4974 | 0.00604703 | 0.0063054 | 0.00445946 | 1.61144 | 1.57296 | 1356
POUTRES | 4915 | 10010 | 67550 | +4.237 | +5.593 | 34 | N12 | 1 | 1006 | POUTRES | 47.4692 | 49.4974 | 0.00604703 | 0.0063054 | 0.00445946 | 1.61144 | 1.57296 | 1356
POUTRES | 4915 | 5100 | 67550 | +4.237 | +5.593 | 34 | N14 | 1 | 1006 | POUTRES | 47.4692 | 49.4974 | 0.00604703 | 0.0063054 | 0.00445946 | 1.61144 | 1.57296 | 1356
POUTRES | 4915 | 2550 | 67550 | +4.237 | +5.593 | 23 | N14 | 1 | 1006 | POUTRES | 47.4692 | 49.4974 | 0.00604703 | 0.0063054 | 0.00445946 | 1.61144 | 1.57296 | 1356
EMPANNON | 5403.93 | 27250 | 69730.5 | +5.001 | +5.809 | 60 | K49 | 1 | 1010 | EMPANNON | 146.063 | 154.542 | 0.0186067 | 0.0196869 | 0 | 4.94398 | 4.91114 | 4233.74
EMPANNON | 5407.83 | 22050 | 69691.5 | +5.007 | +5.809 | 57 | K47 | 1 | 1010 | EMPANNON | 145.053 | 152.575 | 0.0184781 | 0.0194363 | 0 | 4.90585 | 4.84862 | 4179.84
POUTRES | 5741.5 | 3960.35 | 55875 | +5.593 | +5.890 | 30 | N16 | 1 | 1006 | POUTRES | 256.624 | 267.589 | 0.032691 | 0.0340878 | 1.0996 | 8.67234 | 8.50361 | 7330.7
POUTRES | 4088.5 | 3960.35 | 55875 | +3.940 | +4.237 | 30 | N16 | 1 | 1006 | POUTRES | 256.624 | 267.589 | 0.032691 | 0.0340878 | 1.0996 | 8.67234 | 8.50361 | 7330.7
POUTRES | 4088.5 | 13549.6 | 55875 | +3.940 | +4.237 | 31 | N47 | 1 | 1006 | POUTRES | 411.35 | 428.926 | 0.0524013 | 0.0546403 | 1.76259 | 13.8958 | 13.6307 | 11750.6
POUTRES | 5741.5 | 13547.1 | 55875 | +5.593 | +5.890 | 32 | N47 | 1 | 1006 | POUTRES | 411.175 | 428.744 | 0.052379 | 0.054617 | 1.76184 | 13.8899 | 13.6249 | 11745.6
POUTRES | 4088.5 | 23897.5 | 55875 | +3.940 | +4.237 | 24 | N10 | 1 | 1006 | POUTRES | 309.628 | 322.857 | 0.039443 | 0.0411283 | 1.32672 | 10.4617 | 10.26 | 8844.8
POUTRES | 4088.5 | 46222.6 | 55875 | +3.940 | +4.237 | 25 | N41 | 1 | 1006 | POUTRES | 416.405 | 434.197 | 0.0530453 | 0.0553117 | 1.78425 | 14.0664 | 13.7982 | 11895
POUTRES | 4088.5 | 34277.4 | 55875 | +3.940 | +4.237 | 25 | N8 | 1 | 1006 | POUTRES | 416.405 | 434.197 | 0.0530453 | 0.0553117 | 1.78425 | 14.0664 | 13.7982 | 11895
POUTRES | 5741.5 | 34274.9 | 55875 | +5.593 | +5.890 | 26 | N8 | 1 | 1006 | POUTRES | 416.23 | 434.015 | 0.053023 | 0.0552885 | 1.7835 | 14.0605 | 13.7924 | 11890
POUTRES | 5741.5 | 23900 | 55875 | +5.593 | +5.890 | 27 | N10 | 1 | 1006 | POUTRES | 309.453 | 322.675 | 0.0394207 | 0.0411051 | 1.32597 | 10.4558 | 10.2542 | 8839.8
POUTRES | 5741.5 | 46225.1 | 55875 | +5.593 | +5.890 | 26 | N41 | 1 | 1006 | POUTRES | 416.23 | 434.015 | 0.053023 | 0.0552885 | 1.7835 | 14.0605 | 13.7924 | 11890
POUTRES | 5741.5 | 64964.7 | 55875 | +5.593 | +5.890 | 33 | N38 | 1 | 1006 | POUTRES | 272.377 | 284.015 | 0.0346977 | 0.0361803 | 1.16711 | 9.20415 | 9.02561 | 7780.7
POUTRES | 4088.5 | 64964.7 | 55875 | +3.940 | +4.237 | 33 | N38 | 1 | 1006 | POUTRES | 272.377 | 284.015 | 0.0346977 | 0.0361803 | 1.16711 | 9.20415 | 9.02561 | 7780.7
POUTRES | 4088.5 | 56602.9 | 55875 | +3.940 | +4.237 | 24 | N13 | 1 | 1006 | POUTRES | 309.656 | 322.887 | 0.0394466 | 0.041132 | 1.32684 | 10.4626 | 10.2609 | 8845.6
POUTRES | 5741.5 | 56602.9 | 55875 | +5.593 | +5.890 | 24 | N13 | 1 | 1006 | POUTRES | 309.656 | 322.887 | 0.0394466 | 0.041132 | 1.32684 | 10.4626 | 10.2609 | 8845.6
POUTRES | 4915 | 66450 | 55875 | +4.237 | +5.593 | 34 | N38 | 1 | 1006 | POUTRES | 47.4692 | 49.4974 | 0.00604703 | 0.0063054 | 0.00445946 | 1.61144 | 1.57296 | 1356
POUTRES | 4915 | 63750 | 55875 | +4.237 | +5.593 | 34 | N38 | 1 | 1006 | POUTRES | 47.4692 | 49.4974 | 0.00604703 | 0.0063054 | 0.00445946 | 1.61144 | 1.57296 | 1356
POUTRES | 4915 | 58450 | 55875 | +4.237 | +5.593 | 34 | N13 | 1 | 1006 | POUTRES | 47.4692 | 49.4974 | 0.00604703 | 0.0063054 | 0.00445946 | 1.61144 | 1.57296 | 1356
POUTRES | 4915 | 55850 | 55875 | +4.237 | +5.593 | 34 | N13 | 1 | 1006 | POUTRES | 47.4692 | 49.4974 | 0.00604703 | 0.0063054 | 0.00445946 | 1.61144 | 1.57296 | 1356
POUTRES | 4915 | 53250 | 55875 | +4.237 | +5.593 | 34 | N13 | 1 | 1006 | POUTRES | 47.4692 | 49.4974 | 0.00604703 | 0.0063054 | 0.00445946 | 1.61144 | 1.57296 | 1356
POUTRES | 4915 | 50650 | 55875 | +4.237 | +5.593 | 34 | N41 | 1 | 1006 | POUTRES | 47.4692 | 49.4974 | 0.00604703 | 0.0063054 | 0.00445946 | 1.61144 | 1.57296 | 1356
POUTRES | 4915 | 48050 | 55875 | +4.237 | +5.593 | 34 | N41 | 1 | 1006 | POUTRES | 47.4692 | 49.4974 | 0.00604703 | 0.0063054 | 0.00445946 | 1.61144 | 1.57296 | 1356
POUTRES | 4915 | 45450 | 55875 | +4.237 | +5.593 | 34 | N41 | 1 | 1006 | POUTRES | 47.4692 | 49.4974 | 0.00604703 | 0.0063054 | 0.00445946 | 1.61144 | 1.57296 | 1356
POUTRES | 4915 | 42850 | 55875 | +4.237 | +5.593 | 34 | N41 | 1 | 1006 | POUTRES | 47.4692 | 49.4974 | 0.00604703 | 0.0063054 | 0.00445946 | 1.61144 | 1.57296 | 1356
POUTRES | 4915 | 37650 | 55875 | +4.237 | +5.593 | 34 | N8 | 1 | 1006 | POUTRES | 47.4692 | 49.4974 | 0.00604703 | 0.0063054 | 0.00445946 | 1.61144 | 1.57296 | 1356
POUTRES | 4915 | 35050 | 55875 | +4.237 | +5.593 | 34 | N8 | 1 | 1006 | POUTRES | 47.4692 | 49.4974 | 0.00604703 | 0.0063054 | 0.00445946 | 1.61144 | 1.57296 | 1356
POUTRES | 4915 | 32450 | 55875 | +4.237 | +5.593 | 34 | N8 | 1 | 1006 | POUTRES | 47.4692 | 49.4974 | 0.00604703 | 0.0063054 | 0.00445946 | 1.61144 | 1.57296 | 1356
POUTRES | 4915 | 29850 | 55875 | +4.237 | +5.593 | 34 | N8 | 1 | 1006 | POUTRES | 47.4692 | 49.4974 | 0.00604703 | 0.0063054 | 0.00445946 | 1.61144 | 1.57296 | 1356
POUTRES | 4915 | 27250 | 55875 | +4.237 | +5.593 | 34 | N10 | 1 | 1006 | POUTRES | 47.4692 | 49.4974 | 0.00604703 | 0.0063054 | 0.00445946 | 1.61144 | 1.57296 | 1356
POUTRES | 4915 | 24650 | 55875 | +4.237 | +5.593 | 34 | N10 | 1 | 1006 | POUTRES | 47.4692 | 49.4974 | 0.00604703 | 0.0063054 | 0.00445946 | 1.61144 | 1.57296 | 1356
POUTRES | 4915 | 22050 | 55875 | +4.237 | +5.593 | 34 | N10 | 1 | 1006 | POUTRES | 47.4692 | 49.4974 | 0.00604703 | 0.0063054 | 0.00445946 | 1.61144 | 1.57296 | 1356
POUTRES | 4915 | 17090 | 55875 | +4.237 | +5.593 | 34 | N47 | 1 | 1006 | POUTRES | 47.4692 | 49.4974 | 0.00604703 | 0.0063054 | 0.00445946 | 1.61144 | 1.57296 | 1356
POUTRES | 4915 | 14730 | 55875 | +4.237 | +5.593 | 34 | N47 | 1 | 1006 | POUTRES | 47.4692 | 49.4974 | 0.00604703 | 0.0063054 | 0.00445946 | 1.61144 | 1.57296 | 1356
POUTRES | 4915 | 12370 | 55875 | +4.237 | +5.593 | 34 | N47 | 1 | 1006 | POUTRES | 47.4692 | 49.4974 | 0.00604703 | 0.0063054 | 0.00445946 | 1.61144 | 1.57296 | 1356
POUTRES | 4915 | 10010 | 55875 | +4.237 | +5.593 | 34 | N47 | 1 | 1006 | POUTRES | 47.4692 | 49.4974 | 0.00604703 | 0.0063054 | 0.00445946 | 1.61144 | 1.57296 | 1356
POUTRES | 4915 | 5100 | 55875 | +4.237 | +5.593 | 34 | N16 | 1 | 1006 | POUTRES | 47.4692 | 49.4974 | 0.00604703 | 0.0063054 | 0.00445946 | 1.61144 | 1.57296 | 1356
POUTRES | 4915 | 2550 | 55875 | +4.237 | +5.593 | 34 | N16 | 1 | 1006 | POUTRES | 47.4692 | 49.4974 | 0.00604703 | 0.0063054 | 0.00445946 | 1.61144 | 1.57296 | 1356
POUTRES | 4088.5 | 13549.6 | 32525 | +3.940 | +4.237 | 31 | N48 | 3 | 3006 | POUTRES | 411.35 | 428.926 | 0.0524013 | 0.0546403 | 1.76259 | 13.8958 | 13.6307 | 11750.6
POUTRES | 5741.5 | 13547.1 | 32525 | +5.593 | +5.890 | 32 | N48 | 3 | 3006 | POUTRES | 411.175 | 428.744 | 0.052379 | 0.054617 | 1.76184 | 13.8899 | 13.6249 | 11745.6
POUTRES | 4088.5 | 23897.5 | 32525 | +3.940 | +4.237 | 24 | N9 | 3 | 3006 | POUTRES | 309.628 | 322.857 | 0.039443 | 0.0411283 | 1.32672 | 10.4617 | 10.26 | 8844.8
POUTRES | 4088.5 | 34277.4 | 32525 | +3.940 | +4.237 | 25 | N40 | 3 | 3006 | POUTRES | 416.405 | 434.197 | 0.0530453 | 0.0553117 | 1.78425 | 14.0664 | 13.7982 | 11895
POUTRES | 5741.5 | 34274.9 | 32525 | +5.593 | +5.890 | 26 | N40 | 3 | 3006 | POUTRES | 416.23 | 434.015 | 0.053023 | 0.0552885 | 1.7835 | 14.0605 | 13.7924 | 11890
POUTRES | 5741.5 | 23900 | 32525 | +5.593 | +5.890 | 27 | N9 | 3 | 3006 | POUTRES | 309.453 | 322.675 | 0.0394207 | 0.0411051 | 1.32597 | 10.4558 | 10.2542 | 8839.8
POUTRES | 4915 | 37650 | 32525 | +4.237 | +5.593 | 34 | N40 | 3 | 3006 | POUTRES | 47.4692 | 49.4974 | 0.00604703 | 0.0063054 | 0.00445946 | 1.61144 | 1.57296 | 1356
POUTRES | 4915 | 35050 | 32525 | +4.237 | +5.593 | 34 | N40 | 3 | 3006 | POUTRES | 47.4692 | 49.4974 | 0.00604703 | 0.0063054 | 0.00445946 | 1.61144 | 1.57296 | 1356
POUTRES | 4915 | 32450 | 32525 | +4.237 | +5.593 | 34 | N40 | 3 | 3006 | POUTRES | 47.4692 | 49.4974 | 0.00604703 | 0.0063054 | 0.00445946 | 1.61144 | 1.57296 | 1356
POUTRES | 4915 | 29850 | 32525 | +4.237 | +5.593 | 34 | N40 | 3 | 3006 | POUTRES | 47.4692 | 49.4974 | 0.00604703 | 0.0063054 | 0.00445946 | 1.61144 | 1.57296 | 1356
POUTRES | 4915 | 27250 | 32525 | +4.237 | +5.593 | 34 | N9 | 3 | 3006 | POUTRES | 47.4692 | 49.4974 | 0.00604703 | 0.0063054 | 0.00445946 | 1.61144 | 1.57296 | 1356
POUTRES | 4915 | 24650 | 32525 | +4.237 | +5.593 | 34 | N9 | 3 | 3006 | POUTRES | 47.4692 | 49.4974 | 0.00604703 | 0.0063054 | 0.00445946 | 1.61144 | 1.57296 | 1356
POUTRES | 4915 | 22050 | 32525 | +4.237 | +5.593 | 34 | N9 | 3 | 3006 | POUTRES | 47.4692 | 49.4974 | 0.00604703 | 0.0063054 | 0.00445946 | 1.61144 | 1.57296 | 1356
POUTRES | 4915 | 17090 | 32525 | +4.237 | +5.593 | 34 | N48 | 3 | 3006 | POUTRES | 47.4692 | 49.4974 | 0.00604703 | 0.0063054 | 0.00445946 | 1.61144 | 1.57296 | 1356
POUTRES | 4915 | 14730 | 32525 | +4.237 | +5.593 | 34 | N48 | 3 | 3006 | POUTRES | 47.4692 | 49.4974 | 0.00604703 | 0.0063054 | 0.00445946 | 1.61144 | 1.57296 | 1356
POUTRES | 4915 | 12370 | 32525 | +4.237 | +5.593 | 34 | N48 | 3 | 3006 | POUTRES | 47.4692 | 49.4974 | 0.00604703 | 0.0063054 | 0.00445946 | 1.61144 | 1.57296 | 1356
POUTRES | 4915 | 10010 | 32525 | +4.237 | +5.593 | 34 | N48 | 3 | 3006 | POUTRES | 47.4692 | 49.4974 | 0.00604703 | 0.0063054 | 0.00445946 | 1.61144 | 1.57296 | 1356
EMPANNON | 4948.46 | 7650 | 38427.5 | +4.112 | +5.785 | 67 | K42 | 3 | 3005 | EMPANNON | 396.929 | 415.213 | 0.0505642 | 0.0528934 | 0 | 13.409 | 13.1949 | 11374.9
POUTRES | 4915 | 5100 | 32525 | +4.237 | +5.593 | 34 | N15 | 3 | 3006 | POUTRES | 47.4692 | 49.4974 | 0.00604703 | 0.0063054 | 0.00445946 | 1.61144 | 1.57296 | 1356
POUTRES | 4915 | 2550 | 32525 | +4.237 | +5.593 | 34 | N15 | 3 | 3006 | POUTRES | 47.4692 | 49.4974 | 0.00604703 | 0.0063054 | 0.00445946 | 1.61144 | 1.57296 | 1356
POUTRES | 5741.5 | 3858.85 | 32525 | +5.593 | +5.890 | 35 | N15 | 3 | 3006 | POUTRES | 263.73 | 274.999 | 0.0335962 | 0.0350317 | 1.13006 | 8.91225 | 8.73909 | 7533.7
POUTRES | 4088.5 | 3858.85 | 32525 | +3.940 | +4.237 | 35 | N15 | 3 | 3006 | POUTRES | 263.73 | 274.999 | 0.0335962 | 0.0350317 | 1.13006 | 8.91225 | 8.73909 | 7533.7
EMPANNON | 4956.4 | 66450 | 61712.5 | +4.104 | +5.809 | K11 | K11 | 1 | 1005 | EMPANNON | 405.746 | 424.406 | 0.0516874 | 0.0540645 | 0 | 13.7066 | 13.4871 | 11626.8
EMPANNON | 4956.97 | 63750 | 61712.9 | +4.113 | +5.809 | K13 | K13 | 1 | 1005 | EMPANNON | 404.019 | 424.295 | 0.0514674 | 0.0540503 | 0 | 13.6563 | 13.4835 | 11623.7
EMPANNON | 4956.4 | 58450 | 61712.5 | +4.104 | +5.809 | K16 | K16 | 1 | 1005 | EMPANNON | 405.746 | 424.406 | 0.0516874 | 0.0540645 | 0 | 13.7066 | 13.4871 | 11626.8
EMPANNON | 4955.2 | 55850 | 61724.9 | +4.104 | +5.809 | K14 | K14 | 1 | 1005 | EMPANNON | 404.869 | 424.406 | 0.0515757 | 0.0540645 | 0 | 13.6811 | 13.4871 | 11626.8
EMPANNON | 4956.4 | 53250 | 61712.5 | +4.104 | +5.809 | K16 | K16 | 1 | 1005 | EMPANNON | 405.746 | 424.406 | 0.0516874 | 0.0540645 | 0 | 13.7066 | 13.4871 | 11626.8
EMPANNON | 4955.2 | 50650 | 61724.9 | +4.104 | +5.809 | K14 | K14 | 1 | 1005 | EMPANNON | 404.869 | 424.406 | 0.0515757 | 0.0540645 | 0 | 13.6811 | 13.4871 | 11626.8
EMPANNON | 4955.2 | 14730 | 38374.9 | +4.104 | +5.809 | K14 | K14 | 3 | 3005 | EMPANNON | 404.869 | 424.406 | 0.0515757 | 0.0540645 | 0 | 13.6811 | 13.4871 | 11626.8
EMPANNON | 4956.4 | 48050 | 61712.5 | +4.104 | +5.809 | K16 | K16 | 1 | 1005 | EMPANNON | 405.746 | 424.406 | 0.0516874 | 0.0540645 | 0 | 13.7066 | 13.4871 | 11626.8
EMPANNON | 4956.4 | 12370 | 38362.5 | +4.104 | +5.809 | K16 | K16 | 3 | 3005 | EMPANNON | 405.746 | 424.406 | 0.0516874 | 0.0540645 | 0 | 13.7066 | 13.4871 | 11626.8
EMPANNON | 4955.2 | 45450 | 61724.9 | +4.104 | +5.809 | K14 | K14 | 1 | 1005 | EMPANNON | 404.869 | 424.406 | 0.0515757 | 0.0540645 | 0 | 13.6811 | 13.4871 | 11626.8
EMPANNON | 4955.2 | 42850 | 26699.9 | +4.104 | +5.809 | K2 | K2 | 3 | 3005 | EMPANNON | 404.869 | 424.406 | 0.0515757 | 0.0540645 | 0 | 13.6811 | 13.4871 | 11626.8
EMPANNON | 4956.4 | 42850 | 61712.5 | +4.104 | +5.809 | K16 | K16 | 1 | 1005 | EMPANNON | 405.746 | 424.406 | 0.0516874 | 0.0540645 | 0 | 13.7066 | 13.4871 | 11626.8
EMPANNON | 4956.4 | 37650 | 26687.5 | +4.104 | +5.809 | K16 | K16 | 3 | 3005 | EMPANNON | 405.746 | 424.406 | 0.0516874 | 0.0540645 | 0 | 13.7066 | 13.4871 | 11626.8
EMPANNON | 4955.2 | 10010 | 38374.9 | +4.104 | +5.809 | K14 | K14 | 3 | 3005 | EMPANNON | 404.869 | 424.406 | 0.0515757 | 0.0540645 | 0 | 13.6811 | 13.4871 | 11626.8
EMPANNON | 4956.4 | 37650 | 61712.5 | +4.104 | +5.809 | K16 | K16 | 1 | 1005 | EMPANNON | 405.746 | 424.406 | 0.0516874 | 0.0540645 | 0 | 13.7066 | 13.4871 | 11626.8
EMPANNON | 4955.2 | 35050 | 26699.9 | +4.104 | +5.809 | K14 | K14 | 3 | 3005 | EMPANNON | 404.869 | 424.406 | 0.0515757 | 0.0540645 | 0 | 13.6811 | 13.4871 | 11626.8
EMPANNON | 4955.2 | 35050 | 61724.9 | +4.104 | +5.809 | K14 | K14 | 1 | 1005 | EMPANNON | 404.869 | 424.406 | 0.0515757 | 0.0540645 | 0 | 13.6811 | 13.4871 | 11626.8
EMPANNON | 4956.4 | 32450 | 26687.5 | +4.104 | +5.809 | K16 | K16 | 3 | 3005 | EMPANNON | 405.746 | 424.406 | 0.0516874 | 0.0540645 | 0 | 13.7066 | 13.4871 | 11626.8
EMPANNON | 4956.4 | 32450 | 61712.5 | +4.104 | +5.809 | K16 | K16 | 1 | 1005 | EMPANNON | 405.746 | 424.406 | 0.0516874 | 0.0540645 | 0 | 13.7066 | 13.4871 | 11626.8
EMPANNON | 4955.2 | 29850 | 26699.9 | +4.104 | +5.809 | K14 | K14 | 3 | 3005 | EMPANNON | 404.869 | 424.406 | 0.0515757 | 0.0540645 | 0 | 13.6811 | 13.4871 | 11626.8
EMPANNON | 4956.97 | 5100 | 38362.9 | +4.113 | +5.809 | K12 | K12 | 3 | 3005 | EMPANNON | 404.019 | 424.295 | 0.0514674 | 0.0540503 | 0 | 13.6563 | 13.4835 | 11623.7
EMPANNON | 4955.2 | 29850 | 61724.9 | +4.104 | +5.809 | K14 | K14 | 1 | 1005 | EMPANNON | 404.869 | 424.406 | 0.0515757 | 0.0540645 | 0 | 13.6811 | 13.4871 | 11626.8
EMPANNON | 4956.4 | 27250 | 26687.5 | +4.104 | +5.809 | K16 | K16 | 3 | 3005 | EMPANNON | 405.746 | 424.406 | 0.0516874 | 0.0540645 | 0 | 13.7066 | 13.4871 | 11626.8
EMPANNON | 4956.4 | 2550 | 38362.5 | +4.104 | +5.809 | K11 | K11 | 3 | 3005 | EMPANNON | 405.746 | 424.406 | 0.0516874 | 0.0540645 | 0 | 13.7066 | 13.4871 | 11626.8
EMPANNON | 4956.4 | 27250 | 61712.5 | +4.104 | +5.809 | K16 | K16 | 1 | 1005 | EMPANNON | 405.746 | 424.406 | 0.0516874 | 0.0540645 | 0 | 13.7066 | 13.4871 | 11626.8
EMPANNON | 4955.2 | 24650 | 26699.9 | +4.104 | +5.809 | K14 | K14 | 3 | 3005 | EMPANNON | 404.869 | 424.406 | 0.0515757 | 0.0540645 | 0 | 13.6811 | 13.4871 | 11626.8
EMPANNON | 4955.2 | 24650 | 61724.9 | +4.104 | +5.809 | K14 | K14 | 1 | 1005 | EMPANNON | 404.869 | 424.406 | 0.0515757 | 0.0540645 | 0 | 13.6811 | 13.4871 | 11626.8
EMPANNON | 4956.4 | 22050 | 26687.5 | +4.104 | +5.809 | K16 | K16 | 3 | 3005 | EMPANNON | 405.746 | 424.406 | 0.0516874 | 0.0540645 | 0 | 13.7066 | 13.4871 | 11626.8
EMPANNON | 4956.4 | 22050 | 61712.5 | +4.104 | +5.809 | K16 | K16 | 1 | 1005 | EMPANNON | 405.746 | 424.406 | 0.0516874 | 0.0540645 | 0 | 13.7066 | 13.4871 | 11626.8
EMPANNON | 4956.4 | 17090 | 26687.5 | +4.104 | +5.809 | K16 | K16 | 3 | 3005 | EMPANNON | 405.746 | 424.406 | 0.0516874 | 0.0540645 | 0 | 13.7066 | 13.4871 | 11626.8
EMPANNON | 4956.4 | 17090 | 61712.5 | +4.104 | +5.809 | K16 | K16 | 1 | 1005 | EMPANNON | 405.746 | 424.406 | 0.0516874 | 0.0540645 | 0 | 13.7066 | 13.4871 | 11626.8
EMPANNON | 4955.2 | 14730 | 26699.9 | +4.104 | +5.809 | K14 | K14 | 3 | 3005 | EMPANNON | 404.869 | 424.406 | 0.0515757 | 0.0540645 | 0 | 13.6811 | 13.4871 | 11626.8
EMPANNON | 4955.2 | 14730 | 61724.9 | +4.104 | +5.809 | K14 | K14 | 1 | 1005 | EMPANNON | 404.869 | 424.406 | 0.0515757 | 0.0540645 | 0 | 13.6811 | 13.4871 | 11626.8
EMPANNON | 4956.4 | 12370 | 26687.5 | +4.104 | +5.809 | K16 | K16 | 3 | 3005 | EMPANNON | 405.746 | 424.406 | 0.0516874 | 0.0540645 | 0 | 13.7066 | 13.4871 | 11626.8
EMPANNON | 4956.4 | 12370 | 61712.5 | +4.104 | +5.809 | K16 | K16 | 1 | 1005 | EMPANNON | 405.746 | 424.406 | 0.0516874 | 0.0540645 | 0 | 13.7066 | 13.4871 | 11626.8
EMPANNON | 4955.2 | 10010 | 26699.9 | +4.104 | +5.809 | K14 | K14 | 3 | 3005 | EMPANNON | 404.869 | 424.406 | 0.0515757 | 0.0540645 | 0 | 13.6811 | 13.4871 | 11626.8
EMPANNON | 4955.2 | 10010 | 61724.9 | +4.104 | +5.809 | K14 | K14 | 1 | 1005 | EMPANNON | 404.869 | 424.406 | 0.0515757 | 0.0540645 | 0 | 13.6811 | 13.4871 | 11626.8
EMPANNON | 4956.97 | 5100 | 26687.9 | +4.113 | +5.809 | K12 | K12 | 3 | 3005 | EMPANNON | 404.019 | 424.295 | 0.0514674 | 0.0540503 | 0 | 13.6563 | 13.4835 | 11623.7
EMPANNON | 4956.97 | 5100 | 61712.9 | +4.113 | +5.809 | K12 | K12 | 1 | 1005 | EMPANNON | 404.019 | 424.295 | 0.0514674 | 0.0540503 | 0 | 13.6563 | 13.4835 | 11623.7
EMPANNON | 4956.4 | 2550 | 61712.5 | +4.104 | +5.809 | K11 | K11 | 1 | 1005 | EMPANNON | 405.746 | 424.406 | 0.0516874 | 0.0540645 | 0 | 13.7066 | 13.4871 | 11626.8
EMPANNON | 4956.4 | 2550 | 26687.5 | +4.104 | +5.809 | K11 | K11 | 3 | 3005 | EMPANNON | 405.746 | 424.406 | 0.0516874 | 0.0540645 | 0 | 13.7066 | 13.4871 | 11626.8
POUTRES | 4088.5 | 3858.85 | 20850 | +3.940 | +4.237 | 35 | N18 | 2 | 2006 | POUTRES | 263.73 | 274.999 | 0.0335962 | 0.0350317 | 1.13006 | 8.91225 | 8.73909 | 7533.7
POUTRES | 5741.5 | 3858.85 | 20850 | +5.593 | +5.890 | 35 | N18 | 2 | 2006 | POUTRES | 263.73 | 274.999 | 0.0335962 | 0.0350317 | 1.13006 | 8.91225 | 8.73909 | 7533.7
POUTRES | 4915 | 2550 | 20850 | +4.237 | +5.593 | 34 | N18 | 2 | 2006 | POUTRES | 47.4692 | 49.4974 | 0.00604703 | 0.0063054 | 0.00445946 | 1.61144 | 1.57296 | 1356
POUTRES | 4915 | 5100 | 20850 | +4.237 | +5.593 | 34 | N18 | 2 | 2006 | POUTRES | 47.4692 | 49.4974 | 0.00604703 | 0.0063054 | 0.00445946 | 1.61144 | 1.57296 | 1356
POUTRES | 4088.5 | 3960.35 | 44200 | +3.940 | +4.237 | 30 | N16 | 1 | 1006 | POUTRES | 256.624 | 267.589 | 0.032691 | 0.0340878 | 1.0996 | 8.67234 | 8.50361 | 7330.7
POUTRES | 5741.5 | 3960.35 | 44200 | +5.593 | +5.890 | 30 | N16 | 1 | 1006 | POUTRES | 256.624 | 267.589 | 0.032691 | 0.0340878 | 1.0996 | 8.67234 | 8.50361 | 7330.7
EMPANNON | 4958.44 | 7.31515e-15 | 26675.8 | +4.116 | +5.809 | 21 | K25 | 3 | 3005 | EMPANNON | 403.108 | 423.346 | 0.0513514 | 0.0539294 | 0 | 13.6255 | 13.4534 | 11597.7
EMPANNON | 4956.97 | -1.34315e-14 | 61712.9 | +4.116 | +5.806 | 72 | K26 | 1 | 1005 | EMPANNON | 402.256 | 422.456 | 0.0512427 | 0.0538161 | 0 | 13.5968 | 13.4251 | 11573.4
POUTRES | 4088.5 | 13549.6 | 44200 | +3.940 | +4.237 | 31 | N47 | 1 | 1006 | POUTRES | 411.35 | 428.926 | 0.0524013 | 0.0546403 | 1.76259 | 13.8958 | 13.6307 | 11750.6
POUTRES | 5741.5 | 13547.1 | 44200 | +5.593 | +5.890 | 32 | N47 | 1 | 1006 | POUTRES | 411.175 | 428.744 | 0.052379 | 0.054617 | 1.76184 | 13.8899 | 13.6249 | 11745.6
POUTRES | 4088.5 | 23897.5 | 44200 | +3.940 | +4.237 | 24 | N10 | 1 | 1006 | POUTRES | 309.628 | 322.857 | 0.039443 | 0.0411283 | 1.32672 | 10.4617 | 10.26 | 8844.8
POUTRES | 4088.5 | 46222.6 | 44200 | +3.940 | +4.237 | 25 | N41 | 1 | 1006 | POUTRES | 416.405 | 434.197 | 0.0530453 | 0.0553117 | 1.78425 | 14.0664 | 13.7982 | 11895
POUTRES | 4088.5 | 34277.4 | 44200 | +3.940 | +4.237 | 25 | N8 | 1 | 1006 | POUTRES | 416.405 | 434.197 | 0.0530453 | 0.0553117 | 1.78425 | 14.0664 | 13.7982 | 11895
POUTRES | 5741.5 | 46225.1 | 44200 | +5.593 | +5.890 | 26 | N41 | 1 | 1006 | POUTRES | 416.23 | 434.015 | 0.053023 | 0.0552885 | 1.7835 | 14.0605 | 13.7924 | 11890
POUTRES | 5741.5 | 64964.7 | 44200 | +5.593 | +5.890 | 33 | N39 | 1 | 1006 | POUTRES | 272.377 | 284.015 | 0.0346977 | 0.0361803 | 1.16711 | 9.20415 | 9.02561 | 7780.7 | Tekla Common - Preliminary mark: 38
POUTRES | 5741.5 | 23900 | 44200 | +5.593 | +5.890 | 27 | N10 | 1 | 1006 | POUTRES | 309.453 | 322.675 | 0.0394207 | 0.0411051 | 1.32597 | 10.4558 | 10.2542 | 8839.8
POUTRES | 5741.5 | 34274.9 | 44200 | +5.593 | +5.890 | 26 | N8 | 1 | 1006 | POUTRES | 416.23 | 434.015 | 0.053023 | 0.0552885 | 1.7835 | 14.0605 | 13.7924 | 11890
POUTRES | 4088.5 | 64964.7 | 44200 | +3.940 | +4.237 | 33 | N39 | 1 | 1006 | POUTRES | 272.377 | 284.015 | 0.0346977 | 0.0361803 | 1.16711 | 9.20415 | 9.02561 | 7780.7
POUTRES | 4088.5 | 56602.9 | 44200 | +3.940 | +4.237 | 24 | N42 | 1 | 1006 | POUTRES | 309.656 | 322.887 | 0.0394466 | 0.041132 | 1.32684 | 10.4626 | 10.2609 | 8845.6
POUTRES | 5741.5 | 56602.9 | 44200 | +5.593 | +5.890 | 24 | N42 | 1 | 1006 | POUTRES | 309.656 | 322.887 | 0.0394466 | 0.041132 | 1.32684 | 10.4626 | 10.2609 | 8845.6
POUTRES | 4915 | 66450 | 44200 | +4.237 | +5.593 | 34 | N39 | 1 | 1006 | POUTRES | 47.4692 | 49.4974 | 0.00604703 | 0.0063054 | 0.00445946 | 1.61144 | 1.57296 | 1356
POUTRES | 4915 | 63750 | 44200 | +4.237 | +5.593 | 34 | N39 | 1 | 1006 | POUTRES | 47.4692 | 49.4974 | 0.00604703 | 0.0063054 | 0.00445946 | 1.61144 | 1.57296 | 1356
POUTRES | 4915 | 58450 | 44200 | +4.237 | +5.593 | 34 | N42 | 1 | 1006 | POUTRES | 47.4692 | 49.4974 | 0.00604703 | 0.0063054 | 0.00445946 | 1.61144 | 1.57296 | 1356
POUTRES | 4915 | 55850 | 44200 | +4.237 | +5.593 | 34 | N42 | 1 | 1006 | POUTRES | 47.4692 | 49.4974 | 0.00604703 | 0.0063054 | 0.00445946 | 1.61144 | 1.57296 | 1356
POUTRES | 4915 | 53250 | 44200 | +4.237 | +5.593 | 34 | N42 | 1 | 1006 | POUTRES | 47.4692 | 49.4974 | 0.00604703 | 0.0063054 | 0.00445946 | 1.61144 | 1.57296 | 1356
POUTRES | 4915 | 50650 | 44200 | +4.237 | +5.593 | 34 | N41 | 1 | 1006 | POUTRES | 47.4692 | 49.4974 | 0.00604703 | 0.0063054 | 0.00445946 | 1.61144 | 1.57296 | 1356
POUTRES | 4915 | 48050 | 44200 | +4.237 | +5.593 | 34 | N41 | 1 | 1006 | POUTRES | 47.4692 | 49.4974 | 0.00604703 | 0.0063054 | 0.00445946 | 1.61144 | 1.57296 | 1356
POUTRES | 4915 | 45450 | 44200 | +4.237 | +5.593 | 34 | N41 | 1 | 1006 | POUTRES | 47.4692 | 49.4974 | 0.00604703 | 0.0063054 | 0.00445946 | 1.61144 | 1.57296 | 1356
POUTRES | 4915 | 42850 | 44200 | +4.237 | +5.593 | 34 | N41 | 1 | 1006 | POUTRES | 47.4692 | 49.4974 | 0.00604703 | 0.0063054 | 0.00445946 | 1.61144 | 1.57296 | 1356
POUTRES | 4915 | 37650 | 44200 | +4.237 | +5.593 | 34 | N8 | 1 | 1006 | POUTRES | 47.4692 | 49.4974 | 0.00604703 | 0.0063054 | 0.00445946 | 1.61144 | 1.57296 | 1356
POUTRES | 4915 | 35050 | 44200 | +4.237 | +5.593 | 34 | N8 | 1 | 1006 | POUTRES | 47.4692 | 49.4974 | 0.00604703 | 0.0063054 | 0.00445946 | 1.61144 | 1.57296 | 1356
POUTRES | 4915 | 32450 | 44200 | +4.237 | +5.593 | 34 | N8 | 1 | 1006 | POUTRES | 47.4692 | 49.4974 | 0.00604703 | 0.0063054 | 0.00445946 | 1.61144 | 1.57296 | 1356
POUTRES | 4915 | 29850 | 44200 | +4.237 | +5.593 | 34 | N8 | 1 | 1006 | POUTRES | 47.4692 | 49.4974 | 0.00604703 | 0.0063054 | 0.00445946 | 1.61144 | 1.57296 | 1356
POUTRES | 4915 | 27250 | 44200 | +4.237 | +5.593 | 34 | N10 | 1 | 1006 | POUTRES | 47.4692 | 49.4974 | 0.00604703 | 0.0063054 | 0.00445946 | 1.61144 | 1.57296 | 1356
POUTRES | 4915 | 24650 | 44200 | +4.237 | +5.593 | 34 | N10 | 1 | 1006 | POUTRES | 47.4692 | 49.4974 | 0.00604703 | 0.0063054 | 0.00445946 | 1.61144 | 1.57296 | 1356
POUTRES | 4915 | 22050 | 44200 | +4.237 | +5.593 | 34 | N10 | 1 | 1006 | POUTRES | 47.4692 | 49.4974 | 0.00604703 | 0.0063054 | 0.00445946 | 1.61144 | 1.57296 | 1356
POUTRES | 4915 | 17090 | 44200 | +4.237 | +5.593 | 34 | N47 | 1 | 1006 | POUTRES | 47.4692 | 49.4974 | 0.00604703 | 0.0063054 | 0.00445946 | 1.61144 | 1.57296 | 1356
POUTRES | 4915 | 14730 | 44200 | +4.237 | +5.593 | 34 | N47 | 1 | 1006 | POUTRES | 47.4692 | 49.4974 | 0.00604703 | 0.0063054 | 0.00445946 | 1.61144 | 1.57296 | 1356
POUTRES | 4915 | 12370 | 44200 | +4.237 | +5.593 | 34 | N47 | 1 | 1006 | POUTRES | 47.4692 | 49.4974 | 0.00604703 | 0.0063054 | 0.00445946 | 1.61144 | 1.57296 | 1356
POUTRES | 4915 | 10010 | 44200 | +4.237 | +5.593 | 34 | N47 | 1 | 1006 | POUTRES | 47.4692 | 49.4974 | 0.00604703 | 0.0063054 | 0.00445946 | 1.61144 | 1.57296 | 1356
POUTRES | 4915 | 5100 | 44200 | +4.237 | +5.593 | 34 | N16 | 1 | 1006 | POUTRES | 47.4692 | 49.4974 | 0.00604703 | 0.0063054 | 0.00445946 | 1.61144 | 1.57296 | 1356
POUTRES | 4915 | 2550 | 44200 | +4.237 | +5.593 | 34 | N16 | 1 | 1006 | POUTRES | 47.4692 | 49.4974 | 0.00604703 | 0.0063054 | 0.00445946 | 1.61144 | 1.57296 | 1356
EMPANNON | 5107.75 | 7650 | 73475 | +4.784 | +5.431 | 38 | K37 | 1 | 1010 | EMPANNON | 395.766 | 413.012 | 0.0504161 | 0.0526131 | 0 | 13.3697 | 13.125 | 11314.6
EMPANNON | 5108.49 | 5100 | 73464.9 | +4.778 | +5.439 | 39 | K3 | 1 | 1010 | EMPANNON | 410.855 | 429.728 | 0.0523382 | 0.0547424 | 0 | 13.8841 | 13.6562 | 11772.6
EMPANNON | 5108.67 | 2550 | 73446.7 | +4.778 | +5.440 | 40 | K38 | 1 | 1010 | EMPANNON | 412.133 | 429.91 | 0.052501 | 0.0547656 | 0 | 13.9222 | 13.662 | 11777.6
EMPANNON | 5111.38 | -4.70783e-15 | 73370.7 | +4.784 | +5.439 | 41 | K28 | 1 | 1010 | EMPANNON | 404.116 | 422.869 | 0.0514798 | 0.0538687 | 0 | 13.6567 | 13.4382 | 11584.7
EMPANNON | 5108.49 | 10010 | 73464.9 | +4.778 | +5.439 | 42 | K59 | 1 | 1010 | EMPANNON | 410.855 | 429.728 | 0.0523382 | 0.0547424 | 0 | 13.8841 | 13.6562 | 11772.6
EMPANNON | 5108.67 | 12370 | 73446.7 | +4.778 | +5.440 | 43 | K45 | 1 | 1010 | EMPANNON | 412.133 | 429.91 | 0.052501 | 0.0547656 | 0 | 13.9222 | 13.662 | 11777.6
EMPANNON | 5533.57 | 29850 | 68678.4 | +5.261 | +5.809 | K10 | K10 | 1 | 1010 | EMPANNON | 71.8395 | 78.8326 | 0.00915153 | 0.0100424 | 0 | 2.44578 | 2.50519 | 2159.65
EMPANNON | 5226.16 | 17090 | 69655.5 | +5.013 | +5.440 | 64 | K44 | 1 | 1010 | EMPANNON | 146.572 | 153.171 | 0.0186716 | 0.0195122 | 0 | 4.95707 | 4.86755 | 4196.17
EMPANNON | 5226.69 | 14730 | 69673.5 | +5.013 | +5.439 | 48 | K46 | 1 | 1010 | EMPANNON | 145.294 | 152.988 | 0.0185088 | 0.0194889 | 0 | 4.91902 | 4.86175 | 4191.17
EMPANNON | 4945.8 | 66450 | 73475.6 | +4.085 | +5.809 | K9 | K9 | 1 | 1010 | EMPANNON | 411.959 | 430.223 | 0.0524789 | 0.0548055 | 0 | 13.9164 | 13.6719 | 11786.1
EMPANNON | 4944.59 | 63750 | 73488 | +4.085 | +5.809 | 54 | K8 | 1 | 1010 | EMPANNON | 411.082 | 430.223 | 0.0523672 | 0.0548055 | 0 | 13.8908 | 13.6719 | 11786.1
EMPANNON | 4945.71 | 61050 | 73475 | +4.106 | +5.785 | 53 | K40 | 1 | 1010 | EMPANNON | 398.516 | 416.868 | 0.0507664 | 0.0531042 | 0 | 13.4626 | 13.2475 | 11420.3
EMPANNON | 4945.8 | 58450 | 73475.6 | +4.085 | +5.809 | K7 | K7 | 1 | 1010 | EMPANNON | 411.959 | 430.223 | 0.0524789 | 0.0548055 | 0 | 13.9164 | 13.6719 | 11786.1
EMPANNON | 5407.21 | 24650 | 69703.8 | +5.007 | +5.809 | 58 | K48 | 1 | 1010 | EMPANNON | 144.176 | 152.575 | 0.0183664 | 0.0194363 | 0 | 4.88028 | 4.84862 | 4179.84
EMPANNON | 4956.11 | 55850 | 73392.4 | +4.106 | +5.809 | K6 | K6 | 1 | 1010 | EMPANNON | 404.34 | 423.855 | 0.0515083 | 0.0539942 | 0 | 13.6632 | 13.4695 | 11611.7
EMPANNON | 4945.8 | 53250 | 73475.6 | +4.085 | +5.809 | K7 | K7 | 1 | 1010 | EMPANNON | 411.959 | 430.223 | 0.0524789 | 0.0548055 | 0 | 13.9164 | 13.6719 | 11786.1
EMPANNON | 4956.11 | 50650 | 73392.4 | +4.106 | +5.809 | K6 | K6 | 1 | 1010 | EMPANNON | 404.34 | 423.855 | 0.0515083 | 0.0539942 | 0 | 13.6632 | 13.4695 | 11611.7
EMPANNON | 4945.8 | 48050 | 73475.6 | +4.085 | +5.809 | K7 | K7 | 1 | 1010 | EMPANNON | 411.959 | 430.223 | 0.0524789 | 0.0548055 | 0 | 13.9164 | 13.6719 | 11786.1
EMPANNON | 4956.11 | 45450 | 73392.4 | +4.106 | +5.809 | K6 | K6 | 1 | 1010 | EMPANNON | 404.34 | 423.855 | 0.0515083 | 0.0539942 | 0 | 13.6632 | 13.4695 | 11611.7
EMPANNON | 4945.8 | 42850 | 73475.6 | +4.085 | +5.809 | K7 | K7 | 1 | 1010 | EMPANNON | 411.959 | 430.223 | 0.0524789 | 0.0548055 | 0 | 13.9164 | 13.6719 | 11786.1
EMPANNON | 4939.6 | 40250 | 73525 | +4.106 | +5.773 | 52 | K39 | 1 | 1010 | EMPANNON | 394.989 | 413.19 | 0.0503171 | 0.0526357 | 0 | 13.3435 | 13.1306 | 11319.5
EMPANNON | 4945.8 | 37650 | 73475.6 | +4.085 | +5.809 | K7 | K7 | 1 | 1010 | EMPANNON | 411.959 | 430.223 | 0.0524789 | 0.0548055 | 0 | 13.9164 | 13.6719 | 11786.1
EMPANNON | 4956.11 | 35050 | 73392.4 | +4.106 | +5.809 | K5 | K5 | 1 | 1010 | EMPANNON | 404.34 | 423.855 | 0.0515083 | 0.0539942 | 0 | 13.6632 | 13.4695 | 11611.7
EMPANNON | 4951.45 | 69150 | 38405.5 | +4.116 | +5.792 | K4 | K4 | 3 | 3003 | EMPANNON | 399.253 | 418.411 | 0.0508603 | 0.0533008 | 0 | 13.4914 | 13.2965 | 11462.5
EMPANNON | 4956.4 | 42850 | 50037.5 | +4.104 | +5.809 | K16 | K16 | 1 | 1005 | EMPANNON | 405.746 | 424.406 | 0.0516874 | 0.0540645 | 0 | 13.7066 | 13.4871 | 11626.8
EMPANNON | 4956.97 | 69150 | 61712.9 | +4.116 | +5.806 | 72 | K55 | 1 | 1005 | EMPANNON | 402.256 | 422.456 | 0.0512427 | 0.0538161 | 0 | 13.5968 | 13.4251 | 11573.4
EMPANNON | 4945.91 | 69149.8 | 73476.8 | +4.085 | +5.806 | 45 | K54 | 1 | 1010 | EMPANNON | 408.51 | 429.304 | 0.0520395 | 0.0546884 | 0 | 13.8142 | 13.6427 | 11760.9
POUTRES | 5391.49 | 29861.1 | 69765 | +5.242 | +5.539 | 47 | N36 | 1 | 1011 | POUTRES | 176.047 | 188.095 | 0.0224264 | 0.0239612 | 0.750441 | 5.97148 | 5.97741 | 5152.94
EMPANNON | 4958.44 | 8.24099e-15 | 38350.8 | +4.116 | +5.809 | 73 | K27 | 3 | 3005 | EMPANNON | 403.108 | 423.346 | 0.0513514 | 0.0539294 | 0 | 13.6255 | 13.4534 | 11597.7
EMPANNON | 4948.46 | 61050 | 50102.5 | +4.112 | +5.785 | 62 | K41 | 1 | 1005 | EMPANNON | 396.929 | 415.213 | 0.0505642 | 0.0528934 | 0 | 13.409 | 13.1949 | 11374.9
EMPANNON | 4955.2 | 45450 | 50049.9 | +4.104 | +5.809 | K14 | K14 | 1 | 1005 | EMPANNON | 404.869 | 424.406 | 0.0515757 | 0.0540645 | 0 | 13.6811 | 13.4871 | 11626.8
EMPANNON | 4956.4 | 53250 | 50037.5 | +4.104 | +5.809 | K16 | K16 | 1 | 1005 | EMPANNON | 405.746 | 424.406 | 0.0516874 | 0.0540645 | 0 | 13.7066 | 13.4871 | 11626.8
EMPANNON | 4955.2 | 55850 | 50049.9 | +4.104 | +5.809 | K14 | K14 | 1 | 1005 | EMPANNON | 404.869 | 424.406 | 0.0515757 | 0.0540645 | 0 | 13.6811 | 13.4871 | 11626.8
EMPANNON | 4956.97 | 63750 | 50037.9 | +4.113 | +5.809 | K13 | K13 | 1 | 1005 | EMPANNON | 404.019 | 424.295 | 0.0514674 | 0.0540503 | 0 | 13.6563 | 13.4835 | 11623.7
EMPANNON | 4948.46 | 7650 | 50102.5 | +4.112 | +5.785 | 67 | K42 | 1 | 1005 | EMPANNON | 396.929 | 415.213 | 0.0505642 | 0.0528934 | 0 | 13.409 | 13.1949 | 11374.9
EMPANNON | 4956.97 | 69150 | 50037.9 | +4.116 | +5.806 | K18 | K18 | 1 | 1005 | EMPANNON | 402.256 | 422.456 | 0.0512427 | 0.0538161 | 0 | 13.5968 | 13.4251 | 11573.4
EMPANNON | 4956.4 | 66450 | 50037.5 | +4.104 | +5.809 | K11 | K11 | 1 | 1005 | EMPANNON | 405.746 | 424.406 | 0.0516874 | 0.0540645 | 0 | 13.7066 | 13.4871 | 11626.8
EMPANNON | 4956.4 | 58450 | 50037.5 | +4.104 | +5.809 | K16 | K16 | 1 | 1005 | EMPANNON | 405.746 | 424.406 | 0.0516874 | 0.0540645 | 0 | 13.7066 | 13.4871 | 11626.8
EMPANNON | 4955.2 | 50650 | 50049.9 | +4.104 | +5.809 | K14 | K14 | 1 | 1005 | EMPANNON | 404.869 | 424.406 | 0.0515757 | 0.0540645 | 0 | 13.6811 | 13.4871 | 11626.8
EMPANNON | 4956.4 | 48050 | 50037.5 | +4.104 | +5.809 | K16 | K16 | 1 | 1005 | EMPANNON | 405.746 | 424.406 | 0.0516874 | 0.0540645 | 0 | 13.7066 | 13.4871 | 11626.8
EMPANNON | 4956.4 | 22050 | 38362.5 | +4.104 | +5.809 | K16 | K16 | 3 | 3005 | EMPANNON | 405.746 | 424.406 | 0.0516874 | 0.0540645 | 0 | 13.7066 | 13.4871 | 11626.8
EMPANNON | 4955.2 | 24650 | 38374.9 | +4.104 | +5.809 | K14 | K14 | 3 | 3005 | EMPANNON | 404.869 | 424.406 | 0.0515757 | 0.0540645 | 0 | 13.6811 | 13.4871 | 11626.8
EMPANNON | 4956.4 | 27250 | 38362.5 | +4.104 | +5.809 | K16 | K16 | 3 | 3005 | EMPANNON | 405.746 | 424.406 | 0.0516874 | 0.0540645 | 0 | 13.7066 | 13.4871 | 11626.8
EMPANNON | 4955.2 | 29850 | 38374.9 | +4.104 | +5.809 | K14 | K14 | 3 | 3005 | EMPANNON | 404.869 | 424.406 | 0.0515757 | 0.0540645 | 0 | 13.6811 | 13.4871 | 11626.8
EMPANNON | 4956.4 | 32450 | 38362.5 | +4.104 | +5.809 | K16 | K16 | 3 | 3005 | EMPANNON | 405.746 | 424.406 | 0.0516874 | 0.0540645 | 0 | 13.7066 | 13.4871 | 11626.8
