Properties of the parts of a building model (IFC2X3), part 16 of 32

# IfcBeam: PL70*6 (174)
Name | Material | Center of gravity Z (mm) | Center of gravity Y (mm) | Center of gravity X (mm) | Bottom elevation | Top elevation | Part mark | Assembly mark | Phase | Class | Finish | Grade | Name | Net weight (kg) = Weight (kg) = NetWeight (kg) | Gross weight (kg) | Net volume (m3) = NetVolume (m3) | Gross volume (m3) | Gross footprint area (m2) | Area per tons (m2) | Net surface area (m2) = OuterSurfaceArea (m2) | Gross area (m2) | Tekla Quantity, Length (mm) = BaseQuantities, Length (mm)
ATTACHE | STEEL/S235JR | 4311.91 | 43093.4 | 8343 | +4.265 | +4.359 | 331 | P67 | 2 | 2007 | GALVANISE | S235JR | ATTACHE | 0.309329 | 0.309918 | 0.000039405 | 0.00003948 | 0.00039 | 48.7682 | 0.0150854 | 0.015128 | 94
ATTACHE | STEEL/S235JR | 4311.91 | 43093.4 | 5694.67 | +4.265 | +4.359 | 331 | P66 | 2 | 2007 | GALVANISE | S235JR | ATTACHE | 0.309329 | 0.309918 | 0.000039405 | 0.00003948 | 0.00039 | 48.7682 | 0.0150854 | 0.015128 | 94
ATTACHE | STEEL/S235JR | 4311.91 | 42923.3 | 5694.67 | +4.265 | +4.359 | 331 | P66 | 2 | 2007 | GALVANISE | S235JR | ATTACHE | 0.309329 | 0.309918 | 0.000039405 | 0.00003948 | 0.00039 | 48.7682 | 0.0150854 | 0.015128 | 94
ATTACHE | STEEL/S235JR | 4311.91 | 45681.6 | 8343 | +4.265 | +4.359 | 331 | P67 | 2 | 2007 | GALVANISE | S235JR | ATTACHE | 0.309329 | 0.309918 | 0.000039405 | 0.00003948 | 0.00039 | 48.7682 | 0.0150854 | 0.015128 | 94
ATTACHE | STEEL/S235JR | 4311.91 | 45851.7 | 8343 | +4.265 | +4.359 | 331 | P67 | 2 | 2007 | GALVANISE | S235JR | ATTACHE | 0.309329 | 0.309918 | 0.000039405 | 0.00003948 | 0.00039 | 48.7682 | 0.0150854 | 0.015128 | 94
ATTACHE | STEEL/S235JR | 4311.91 | 45851.7 | 5694.67 | +4.265 | +4.359 | 331 | P66 | 2 | 2007 | GALVANISE | S235JR | ATTACHE | 0.309329 | 0.309918 | 0.000039405 | 0.00003948 | 0.00039 | 48.7682 | 0.0150854 | 0.015128 | 94
ATTACHE | STEEL/S235JR | 4311.91 | 45681.6 | 5694.67 | +4.265 | +4.359 | 331 | P66 | 2 | 2007 | GALVANISE | S235JR | ATTACHE | 0.309329 | 0.309918 | 0.000039405 | 0.00003948 | 0.00039 | 48.7682 | 0.0150854 | 0.015128 | 94
ATTACHE | STEEL/S235JR | 10811.9 | 63664.9 | 28850 | +10.765 | +10.859 | 331 | P65 | 2 | 2007 | GALVANISE | S235JR | ATTACHE | 0.309329 | 0.309918 | 0.000039405 | 0.00003948 | 0.00039 | 48.7682 | 0.0150854 | 0.015128 | 94
ATTACHE | STEEL/S235JR | 10811.9 | 63664.9 | 31678 | +10.765 | +10.859 | 331 | P63 | 2 | 2007 | GALVANISE | S235JR | ATTACHE | 0.309329 | 0.309918 | 0.000039405 | 0.00003948 | 0.00039 | 48.7682 | 0.0150854 | 0.015128 | 94
ATTACHE | STEEL/S235JR | 10811.9 | 63835.1 | 31678 | +10.765 | +10.859 | 331 | P63 | 2 | 2007 | GALVANISE | S235JR | ATTACHE | 0.309329 | 0.309918 | 0.000039405 | 0.00003948 | 0.00039 | 48.7682 | 0.0150854 | 0.015128 | 94
ATTACHE | STEEL/S235JR | 10811.9 | 63835.1 | 26022 | +10.765 | +10.859 | 331 | P64 | 2 | 2007 | GALVANISE | S235JR | ATTACHE | 0.309329 | 0.309918 | 0.000039405 | 0.00003948 | 0.00039 | 48.7682 | 0.0150854 | 0.015128 | 94
ATTACHE | STEEL/S235JR | 10811.9 | 63664.9 | 26022 | +10.765 | +10.859 | 331 | P64 | 2 | 2007 | GALVANISE | S235JR | ATTACHE | 0.309329 | 0.309918 | 0.000039405 | 0.00003948 | 0.00039 | 48.7682 | 0.0150854 | 0.015128 | 94
ATTACHE | STEEL/S235JR | 10811.9 | 63835.1 | 28850 | +10.765 | +10.859 | 331 | P65 | 2 | 2007 | GALVANISE | S235JR | ATTACHE | 0.309329 | 0.309918 | 0.000039405 | 0.00003948 | 0.00039 | 48.7682 | 0.0150854 | 0.015128 | 94
ATTACHE | STEEL/S235JR | 10811.9 | 61070.1 | 28850 | +10.765 | +10.859 | 331 | P65 | 2 | 2007 | GALVANISE | S235JR | ATTACHE | 0.309329 | 0.309918 | 0.000039405 | 0.00003948 | 0.00039 | 48.7682 | 0.0150854 | 0.015128 | 94
ATTACHE | STEEL/S235JR | 10811.9 | 60899.9 | 28850 | +10.765 | +10.859 | 331 | P65 | 2 | 2007 | GALVANISE | S235JR | ATTACHE | 0.309329 | 0.309918 | 0.000039405 | 0.00003948 | 0.00039 | 48.7682 | 0.0150854 | 0.015128 | 94
ATTACHE | STEEL/S235JR | 10811.9 | 60899.9 | 26022 | +10.765 | +10.859 | 331 | P64 | 2 | 2007 | GALVANISE | S235JR | ATTACHE | 0.309329 | 0.309918 | 0.000039405 | 0.00003948 | 0.00039 | 48.7682 | 0.0150854 | 0.015128 | 94
ATTACHE | STEEL/S235JR | 10811.9 | 61070.1 | 26022 | +10.765 | +10.859 | 331 | P64 | 2 | 2007 | GALVANISE | S235JR | ATTACHE | 0.309329 | 0.309918 | 0.000039405 | 0.00003948 | 0.00039 | 48.7682 | 0.0150854 | 0.015128 | 94
ATTACHE | STEEL/S235JR | 10811.9 | 61070.1 | 31678 | +10.765 | +10.859 | 331 | P63 | 2 | 2007 | GALVANISE | S235JR | ATTACHE | 0.309329 | 0.309918 | 0.000039405 | 0.00003948 | 0.00039 | 48.7682 | 0.0150854 | 0.015128 | 94
ATTACHE | STEEL/S235JR | 10811.9 | 60899.9 | 31678 | +10.765 | +10.859 | 331 | P63 | 2 | 2007 | GALVANISE | S235JR | ATTACHE | 0.309329 | 0.309918 | 0.000039405 | 0.00003948 | 0.00039 | 48.7682 | 0.0150854 | 0.015128 | 94
ATTACHE | STEEL/S235JR | 10811.9 | 58305.1 | 28850 | +10.765 | +10.859 | 331 | P65 | 2 | 2007 | GALVANISE | S235JR | ATTACHE | 0.309329 | 0.309918 | 0.000039405 | 0.00003948 | 0.00039 | 48.7682 | 0.0150854 | 0.015128 | 94
ATTACHE | STEEL/S235JR | 10811.9 | 58134.9 | 28850 | +10.765 | +10.859 | 331 | P65 | 2 | 2007 | GALVANISE | S235JR | ATTACHE | 0.309329 | 0.309918 | 0.000039405 | 0.00003948 | 0.00039 | 48.7682 | 0.0150854 | 0.015128 | 94
ATTACHE | STEEL/S235JR | 10811.9 | 58134.9 | 26022 | +10.765 | +10.859 | 331 | P64 | 2 | 2007 | GALVANISE | S235JR | ATTACHE | 0.309329 | 0.309918 | 0.000039405 | 0.00003948 | 0.00039 | 48.7682 | 0.0150854 | 0.015128 | 94
ATTACHE | STEEL/S235JR | 10811.9 | 58305.1 | 26022 | +10.765 | +10.859 | 331 | P64 | 2 | 2007 | GALVANISE | S235JR | ATTACHE | 0.309329 | 0.309918 | 0.000039405 | 0.00003948 | 0.00039 | 48.7682 | 0.0150854 | 0.015128 | 94
ATTACHE | STEEL/S235JR | 10811.9 | 58305.1 | 31678 | +10.765 | +10.859 | 331 | P63 | 2 | 2007 | GALVANISE | S235JR | ATTACHE | 0.309329 | 0.309918 | 0.000039405 | 0.00003948 | 0.00039 | 48.7682 | 0.0150854 | 0.015128 | 94
ATTACHE | STEEL/S235JR | 10811.9 | 58134.9 | 31678 | +10.765 | +10.859 | 331 | P63 | 2 | 2007 | GALVANISE | S235JR | ATTACHE | 0.309329 | 0.309918 | 0.000039405 | 0.00003948 | 0.00039 | 48.7682 | 0.0150854 | 0.015128 | 94
ATTACHE | STEEL/S235JR | 10811.9 | 55540.1 | 28850 | +10.765 | +10.859 | 331 | P65 | 2 | 2007 | GALVANISE | S235JR | ATTACHE | 0.309329 | 0.309918 | 0.000039405 | 0.00003948 | 0.00039 | 48.7682 | 0.0150854 | 0.015128 | 94
ATTACHE | STEEL/S235JR | 10811.9 | 55369.9 | 28850 | +10.765 | +10.859 | 331 | P65 | 2 | 2007 | GALVANISE | S235JR | ATTACHE | 0.309329 | 0.309918 | 0.000039405 | 0.00003948 | 0.00039 | 48.7682 | 0.0150854 | 0.015128 | 94
ATTACHE | STEEL/S235JR | 10811.9 | 55369.9 | 26022 | +10.765 | +10.859 | 331 | P64 | 2 | 2007 | GALVANISE | S235JR | ATTACHE | 0.309329 | 0.309918 | 0.000039405 | 0.00003948 | 0.00039 | 48.7682 | 0.0150854 | 0.015128 | 94
ATTACHE | STEEL/S235JR | 10811.9 | 55540.1 | 26022 | +10.765 | +10.859 | 331 | P64 | 2 | 2007 | GALVANISE | S235JR | ATTACHE | 0.309329 | 0.309918 | 0.000039405 | 0.00003948 | 0.00039 | 48.7682 | 0.0150854 | 0.015128 | 94
ATTACHE | STEEL/S235JR | 10811.9 | 55540.1 | 31678 | +10.765 | +10.859 | 331 | P63 | 2 | 2007 | GALVANISE | S235JR | ATTACHE | 0.309329 | 0.309918 | 0.000039405 | 0.00003948 | 0.00039 | 48.7682 | 0.0150854 | 0.015128 | 94
ATTACHE | STEEL/S235JR | 10811.9 | 55369.9 | 31678 | +10.765 | +10.859 | 331 | P63 | 2 | 2007 | GALVANISE | S235JR | ATTACHE | 0.309329 | 0.309918 | 0.000039405 | 0.00003948 | 0.00039 | 48.7682 | 0.0150854 | 0.015128 | 94
ATTACHE | STEEL/S235JR | 10811.9 | 52775.1 | 28850 | +10.765 | +10.859 | 331 | P65 | 2 | 2007 | GALVANISE | S235JR | ATTACHE | 0.309329 | 0.309918 | 0.000039405 | 0.00003948 | 0.00039 | 48.7682 | 0.0150854 | 0.015128 | 94
ATTACHE | STEEL/S235JR | 10811.9 | 52775.1 | 26022 | +10.765 | +10.859 | 331 | P64 | 2 | 2007 | GALVANISE | S235JR | ATTACHE | 0.309329 | 0.309918 | 0.000039405 | 0.00003948 | 0.00039 | 48.7682 | 0.0150854 | 0.015128 | 94
ATTACHE | STEEL/S235JR | 10811.9 | 52775.1 | 31678 | +10.765 | +10.859 | 331 | P63 | 2 | 2007 | GALVANISE | S235JR | ATTACHE | 0.309329 | 0.309918 | 0.000039405 | 0.00003948 | 0.00039 | 48.7682 | 0.0150854 | 0.015128 | 94
ATTACHE | STEEL/S235JR | 10812 | 52604.9 | 23188 | +10.765 | +10.859 | 355 | P72 | 2 | 2007 | GALVANISE | S235JR | ATTACHE | 0.30874 | 0.309918 | 0.00003933 | 0.00003948 | 0.00039 | 48.7233 | 0.0150429 | 0.015128 | 94
ATTACHE | STEEL/S235JR | 4311.91 | 45851.7 | 3046.33 | +4.265 | +4.359 | 331 | P62 | 2 | 2007 | GALVANISE | S235JR | ATTACHE | 0.309329 | 0.309918 | 0.000039405 | 0.00003948 | 0.00039 | 48.7682 | 0.0150854 | 0.015128 | 94
ATTACHE | STEEL/S235JR | 4311.91 | 45681.6 | 3046.33 | +4.265 | +4.359 | 331 | P62 | 2 | 2007 | GALVANISE | S235JR | ATTACHE | 0.309329 | 0.309918 | 0.000039405 | 0.00003948 | 0.00039 | 48.7682 | 0.0150854 | 0.015128 | 94
ATTACHE | STEEL/S235JR | 4311.91 | 43093.4 | 3046.33 | +4.265 | +4.359 | 331 | P62 | 2 | 2007 | GALVANISE | S235JR | ATTACHE | 0.309329 | 0.309918 | 0.000039405 | 0.00003948 | 0.00039 | 48.7682 | 0.0150854 | 0.015128 | 94
ATTACHE | STEEL/S235JR | 4311.91 | 42923.3 | 3046.33 | +4.265 | +4.359 | 331 | P62 | 2 | 2007 | GALVANISE | S235JR | ATTACHE | 0.309329 | 0.309918 | 0.000039405 | 0.00003948 | 0.00039 | 48.7682 | 0.0150854 | 0.015128 | 94
ATTACHE | STEEL/S235JR | 4311.91 | 40164.9 | 3046.33 | +4.265 | +4.359 | 331 | P62 | 2 | 2007 | GALVANISE | S235JR | ATTACHE | 0.309329 | 0.309918 | 0.000039405 | 0.00003948 | 0.00039 | 48.7682 | 0.0150854 | 0.015128 | 94
ATTACHE | STEEL/S235JR | 4311.91 | 40335.1 | 3046.33 | +4.265 | +4.359 | 331 | P62 | 2 | 2007 | GALVANISE | S235JR | ATTACHE | 0.309329 | 0.309918 | 0.000039405 | 0.00003948 | 0.00039 | 48.7682 | 0.0150854 | 0.015128 | 94
ATTACHE | STEEL/S235JR | 4311.91 | 37496.2 | 3046.33 | +4.265 | +4.359 | 331 | P62 | 2 | 2007 | GALVANISE | S235JR | ATTACHE | 0.309329 | 0.309918 | 0.000039405 | 0.00003948 | 0.00039 | 48.7682 | 0.0150854 | 0.015128 | 94
ATTACHE | STEEL/S235JR | 4311.91 | 37666.3 | 3046.33 | +4.265 | +4.359 | 331 | P62 | 2 | 2007 | GALVANISE | S235JR | ATTACHE | 0.309329 | 0.309918 | 0.000039405 | 0.00003948 | 0.00039 | 48.7682 | 0.0150854 | 0.015128 | 94
ATTACHE | STEEL/S235JR | 4311.91 | 34827.4 | 3046.33 | +4.265 | +4.359 | 331 | P62 | 2 | 2007 | GALVANISE | S235JR | ATTACHE | 0.309329 | 0.309918 | 0.000039405 | 0.00003948 | 0.00039 | 48.7682 | 0.0150854 | 0.015128 | 94
ATTACHE | STEEL/S235JR | 4311.91 | 34997.6 | 3046.33 | +4.265 | +4.359 | 331 | P62 | 2 | 2007 | GALVANISE | S235JR | ATTACHE | 0.309329 | 0.309918 | 0.000039405 | 0.00003948 | 0.00039 | 48.7682 | 0.0150854 | 0.015128 | 94
ATTACHE | STEEL/S235JR | 4311.91 | 32328.8 | 3046.33 | +4.265 | +4.359 | 331 | P62 | 2 | 2007 | GALVANISE | S235JR | ATTACHE | 0.309329 | 0.309918 | 0.000039405 | 0.00003948 | 0.00039 | 48.7682 | 0.0150854 | 0.015128 | 94
ATTACHE | STEEL/S235JR | 4311.91 | 32158.7 | 3046.33 | +4.265 | +4.359 | 331 | P62 | 2 | 2007 | GALVANISE | S235JR | ATTACHE | 0.309329 | 0.309918 | 0.000039405 | 0.00003948 | 0.00039 | 48.7682 | 0.0150854 | 0.015128 | 94
ATTACHE | STEEL/S235JR | 4311.91 | 29489.9 | 3046.33 | +4.265 | +4.359 | 331 | P62 | 2 | 2007 | GALVANISE | S235JR | ATTACHE | 0.309329 | 0.309918 | 0.000039405 | 0.00003948 | 0.00039 | 48.7682 | 0.0150854 | 0.015128 | 94
ATTACHE | STEEL/S235JR | 4311.91 | 29660.1 | 3046.33 | +4.265 | +4.359 | 331 | P62 | 2 | 2007 | GALVANISE | S235JR | ATTACHE | 0.309329 | 0.309918 | 0.000039405 | 0.00003948 | 0.00039 | 48.7682 | 0.0150854 | 0.015128 | 94
ATTACHE | STEEL/S235JR | 4311.91 | 26958.7 | 3046.33 | +4.265 | +4.359 | 331 | P62 | 2 | 2007 | GALVANISE | S235JR | ATTACHE | 0.309329 | 0.309918 | 0.000039405 | 0.00003948 | 0.00039 | 48.7682 | 0.0150854 | 0.015128 | 94
ATTACHE | STEEL/S235JR | 4311.91 | 27128.8 | 3046.33 | +4.265 | +4.359 | 331 | P62 | 2 | 2007 | GALVANISE | S235JR | ATTACHE | 0.309329 | 0.309918 | 0.000039405 | 0.00003948 | 0.00039 | 48.7682 | 0.0150854 | 0.015128 | 94
ATTACHE | STEEL/S235JR | 4311.91 | 24427.4 | 3046.33 | +4.265 | +4.359 | 331 | P62 | 2 | 2007 | GALVANISE | S235JR | ATTACHE | 0.309329 | 0.309918 | 0.000039405 | 0.00003948 | 0.00039 | 48.7682 | 0.0150854 | 0.015128 | 94
ATTACHE | STEEL/S235JR | 4311.91 | 24597.6 | 3046.33 | +4.265 | +4.359 | 331 | P62 | 2 | 2007 | GALVANISE | S235JR | ATTACHE | 0.309329 | 0.309918 | 0.000039405 | 0.00003948 | 0.00039 | 48.7682 | 0.0150854 | 0.015128 | 94
ATTACHE | STEEL/S235JR | 4311.91 | 22066.3 | 3046.33 | +4.265 | +4.359 | 331 | P62 | 2 | 2007 | GALVANISE | S235JR | ATTACHE | 0.309329 | 0.309918 | 0.000039405 | 0.00003948 | 0.00039 | 48.7682 | 0.0150854 | 0.015128 | 94
ATTACHE | STEEL/S235JR | 4311.91 | 21896.2 | 3046.33 | +4.265 | +4.359 | 331 | P62 | 2 | 2007 | GALVANISE | S235JR | ATTACHE | 0.309329 | 0.309918 | 0.000039405 | 0.00003948 | 0.00039 | 48.7682 | 0.0150854 | 0.015128 | 94
ATTACHE | STEEL/S235JR | 4311.91 | 19364.9 | 3046.33 | +4.265 | +4.359 | 331 | P62 | 2 | 2007 | GALVANISE | S235JR | ATTACHE | 0.309329 | 0.309918 | 0.000039405 | 0.00003948 | 0.00039 | 48.7682 | 0.0150854 | 0.015128 | 94
ATTACHE | STEEL/S235JR | 4311.91 | 19535.1 | 3046.33 | +4.265 | +4.359 | 331 | P62 | 2 | 2007 | GALVANISE | S235JR | ATTACHE | 0.309329 | 0.309918 | 0.000039405 | 0.00003948 | 0.00039 | 48.7682 | 0.0150854 | 0.015128 | 94
ATTACHE | STEEL/S235JR | 4311.91 | 17234.9 | 3046.33 | +4.265 | +4.359 | 331 | P62 | 2 | 2007 | GALVANISE | S235JR | ATTACHE | 0.309329 | 0.309918 | 0.000039405 | 0.00003948 | 0.00039 | 48.7682 | 0.0150854 | 0.015128 | 94
ATTACHE | STEEL/S235JR | 4311.91 | 17405.1 | 3046.33 | +4.265 | +4.359 | 331 | P62 | 2 | 2007 | GALVANISE | S235JR | ATTACHE | 0.309329 | 0.309918 | 0.000039405 | 0.00003948 | 0.00039 | 48.7682 | 0.0150854 | 0.015128 | 94
ATTACHE | STEEL/S235JR | 4311.91 | 15104.9 | 3046.33 | +4.265 | +4.359 | 331 | P62 | 2 | 2007 | GALVANISE | S235JR | ATTACHE | 0.309329 | 0.309918 | 0.000039405 | 0.00003948 | 0.00039 | 48.7682 | 0.0150854 | 0.015128 | 94
ATTACHE | STEEL/S235JR | 4311.91 | 15275.1 | 3046.33 | +4.265 | +4.359 | 331 | P62 | 2 | 2007 | GALVANISE | S235JR | ATTACHE | 0.309329 | 0.309918 | 0.000039405 | 0.00003948 | 0.00039 | 48.7682 | 0.0150854 | 0.015128 | 94
ATTACHE | STEEL/S235JR | 4311.91 | 13145.1 | 3046.33 | +4.265 | +4.359 | 331 | P62 | 2 | 2007 | GALVANISE | S235JR | ATTACHE | 0.309329 | 0.309918 | 0.000039405 | 0.00003948 | 0.00039 | 48.7682 | 0.0150854 | 0.015128 | 94
ATTACHE | STEEL/S235JR | 4311.91 | 12974.9 | 3046.33 | +4.265 | +4.359 | 331 | P62 | 2 | 2007 | GALVANISE | S235JR | ATTACHE | 0.309329 | 0.309918 | 0.000039405 | 0.00003948 | 0.00039 | 48.7682 | 0.0150854 | 0.015128 | 94
 | STEEL/E24-2 | 3478.43 | 10855 | 6322 | +3.443 | +3.513 | 332 | S4 | 6 | 6001 | GRENAILLE-PEINT | E24-2 |  | 0.23079 | 0.23079 | 0.0000294 | 0.0000294 | 0.00042 | 49.7422 | 0.01148 | 0.01148 | 70
 | STEEL/E24-2 | 3478.43 | 15115 | 6242 | +3.443 | +3.513 | 332 | S87 | 6 | 6001 | GRENAILLE-PEINT | E24-2 |  | 0.23079 | 0.23079 | 0.0000294 | 0.0000294 | 0.00042 | 49.7422 | 0.01148 | 0.01148 | 70

# IfcBeam: PL70*8 (4)
In: Undefined
Description: PL70*8; Material: STEEL/E24-2
Tekla Common - Phase: 3; Class: 3003; Finish: GRENAILLE-PEINT; Grade: E24-2; Profile: PL70*8; sets with these values: 2
Tekla Quantity - Height: 70 mm; Width: 8 mm; sets with these values: 2
Name | Center of gravity Z (mm) | Center of gravity Y (mm) | Center of gravity X (mm) | Bottom elevation | Top elevation | Part mark | Assembly mark | Name | Net weight (kg) = Gross weight (kg) = Weight (kg) = NetWeight (kg) | Net volume (m3) = Gross volume (m3) = NetVolume (m3) | Gross footprint area (m2) | Area per tons (m2) | Net surface area (m2) = Gross area (m2) = OuterSurfaceArea (m2) | Tekla Quantity, Length (mm) = BaseQuantities, Length (mm)
CV | 4724.11 | 48037.1 | 28040.8 | +4.679 | +4.769 | 743 | W6 | CV | 0.747305 | 0.0000951981 | 0 | 36.9855 | 0.0276395 | 169.997
CV | 4474.94 | 48037.1 | 30080.8 | +4.430 | +4.520 | 743 | W6 | CV | 0.747305 | 0.0000951981 | 0 | 36.9855 | 0.0276395 | 169.997
CV | 4225.77 | 48037.1 | 32120.8 | +4.181 | +4.271 | 743 | W6 | CV | 0.747305 | 0.0000951981 | 0 | 36.9855 | 0.0276395 | 169.997
LISSE | 4313.08 | 49760 | 32441 | +4.227 | +4.399 | 759 | K93 | LISSE | 0.7532 | 0.0000959491 | 0.00056 | 36.9738 | 0.0278487 | 171.338

# IfcBeam: PL75*8, PLAT
In: Undefined
Description: PL75*8; Material: STEEL/E24-2
Tekla Common - Center of gravity Z: 5526.83 mm; Center of gravity Y: 27397.5 mm; Center of gravity X: 71815.1 mm; Bottom elevation: +5.521; Top elevation: +5.533; Part mark: 851; Assembly mark: K100; Phase: 1; Class: 1010; Finish: GRENAILLE-PEINT; Grade: E24-2; Profile: PL75*8; Name: PLAT; sets with these values: 2
Tekla Quantity - Net weight: 0.989307 kg; Gross weight: 0.989307 kg; Weight: 0.989307 kg; Net volume: 0.000126026 m3; Gross volume: 0.000126026 m3; Gross footprint area: 0 m2; Area per tons: 36.4571 m2; Net surface area: 0.0360673 m2; Gross area: 0.0360673 m2; Height: 75 mm; Width: 8 mm; Length: 210.044 mm; sets with these values: 2
BaseQuantities - Length: 210.044 mm; OuterSurfaceArea: 0.0360673 m2; NetVolume: 0.000126026 m3; NetWeight: 0.989307 kg

# IfcBeam: PL8*220 (171)
In: Undefined
Description: PL8*220; Material: STEEL/S235JR
Tekla Common - Finish: GALVANISE; Grade: S235JR; Profile: PL8*220; Name: PLAT; sets with these values: 2
Tekla Quantity - Gross footprint area: 0 m2; Height: 220 mm; Width: 8 mm; sets with these values: 2
Name | Center of gravity Z (mm) | Center of gravity Y (mm) | Center of gravity X (mm) | Bottom elevation | Top elevation | Part mark | Assembly mark | Phase | Class | Net weight (kg) = Gross weight (kg) = Weight (kg) = NetWeight (kg) | Net volume (m3) = Gross volume (m3) = NetVolume (m3) | Area per tons (m2) | Net surface area (m2) = Gross area (m2) = OuterSurfaceArea (m2) | Tekla Quantity, Length (mm) = BaseQuantities, Length (mm)
PLAT | 10574 | 50520 | 20359.9 | +10.568 | +10.580 | 740 | P108 | 2 | 2007 | 1.60266 | 0.00020416 | 35.2016 | 0.056416 | 116
PLAT | 10486.2 | 50630 | 23190.9 | +10.480 | +10.492 | 740 | P107 | 2 | 2007 | 1.60266 | 0.00020416 | 35.2016 | 0.056416 | 116
PLAT | 3393.21 | 48065 | 10405.1 | +3.387 | +3.399 | 740 | P83 | 2 | 2007 | 1.60266 | 0.00020416 | 35.2016 | 0.056416 | 116
PLAT | 10398.5 | 50520 | 26018.9 | +10.393 | +10.404 | 740 | P91 | 2 | 2007 | 1.60266 | 0.00020416 | 35.2016 | 0.056416 | 116
PLAT | 10574 | 52690 | 20359.9 | +10.567 | +10.581 | 739 | P95 | 2 | 2007 | 2.0724 | 0.000264 | 34.7037 | 0.07192 | 150
PLAT | 10574 | 55455 | 20359.9 | +10.567 | +10.581 | 739 | P95 | 2 | 2007 | 2.0724 | 0.000264 | 34.7037 | 0.07192 | 150
PLAT | 10574 | 58220 | 20359.9 | +10.567 | +10.581 | 739 | P95 | 2 | 2007 | 2.0724 | 0.000264 | 34.7037 | 0.07192 | 150
PLAT | 10574 | 60985 | 20359.9 | +10.567 | +10.581 | 739 | P95 | 2 | 2007 | 2.0724 | 0.000264 | 34.7037 | 0.07192 | 150
PLAT | 3754.1 | 40250 | 8339.86 | +3.746 | +3.762 | 739 | P67 | 2 | 2007 | 2.0724 | 0.000264 | 34.7037 | 0.07192 | 150
PLAT | 3846.79 | 40250 | 5691.53 | +3.839 | +3.855 | 739 | P66 | 2 | 2007 | 2.0724 | 0.000264 | 34.7037 | 0.07192 | 150
PLAT | 4032.19 | 40250 | 394.86 | +4.024 | +4.040 | 739 | P96 | 2 | 2007 | 2.0724 | 0.000264 | 34.7037 | 0.07192 | 150
PLAT | 3754.1 | 37581.2 | 8339.86 | +3.746 | +3.762 | 739 | P67 | 2 | 2007 | 2.0724 | 0.000264 | 34.7037 | 0.07192 | 150
PLAT | 3846.79 | 37581.2 | 5691.53 | +3.839 | +3.855 | 739 | P66 | 2 | 2007 | 2.0724 | 0.000264 | 34.7037 | 0.07192 | 150
PLAT | 4032.19 | 37581.2 | 394.86 | +4.024 | +4.040 | 739 | P96 | 2 | 2007 | 2.0724 | 0.000264 | 34.7037 | 0.07192 | 150
PLAT | 3754.1 | 34912.5 | 8339.86 | +3.746 | +3.762 | 739 | P67 | 2 | 2007 | 2.0724 | 0.000264 | 34.7037 | 0.07192 | 150
PLAT | 3846.79 | 34912.5 | 5691.53 | +3.839 | +3.855 | 739 | P66 | 2 | 2007 | 2.0724 | 0.000264 | 34.7037 | 0.07192 | 150
PLAT | 4032.19 | 34912.5 | 394.86 | +4.024 | +4.040 | 739 | P96 | 2 | 2007 | 2.0724 | 0.000264 | 34.7037 | 0.07192 | 150
PLAT | 4032.19 | 32243.7 | 394.86 | +4.024 | +4.040 | 739 | P96 | 2 | 2007 | 2.0724 | 0.000264 | 34.7037 | 0.07192 | 150
PLAT | 3846.79 | 32243.7 | 5691.53 | +3.839 | +3.855 | 739 | P66 | 2 | 2007 | 2.0724 | 0.000264 | 34.7037 | 0.07192 | 150
PLAT | 3754.1 | 32243.7 | 8339.86 | +3.746 | +3.762 | 739 | P67 | 2 | 2007 | 2.0724 | 0.000264 | 34.7037 | 0.07192 | 150
PLAT | 3846.79 | 29575 | 5691.53 | +3.839 | +3.855 | 739 | P66 | 2 | 2007 | 2.0724 | 0.000264 | 34.7037 | 0.07192 | 150
PLAT | 3754.1 | 29575 | 8339.86 | +3.746 | +3.762 | 739 | P67 | 2 | 2007 | 2.0724 | 0.000264 | 34.7037 | 0.07192 | 150
PLAT | 4032.19 | 29575 | 394.86 | +4.024 | +4.040 | 739 | P96 | 2 | 2007 | 2.0724 | 0.000264 | 34.7037 | 0.07192 | 150
PLAT | 3846.79 | 27043.7 | 5691.53 | +3.839 | +3.855 | 739 | P66 | 2 | 2007 | 2.0724 | 0.000264 | 34.7037 | 0.07192 | 150
PLAT | 3754.1 | 27043.7 | 8339.86 | +3.746 | +3.762 | 739 | P67 | 2 | 2007 | 2.0724 | 0.000264 | 34.7037 | 0.07192 | 150
PLAT | 4032.19 | 27043.7 | 394.86 | +4.024 | +4.040 | 739 | P96 | 2 | 2007 | 2.0724 | 0.000264 | 34.7037 | 0.07192 | 150
PLAT | 3846.79 | 24512.5 | 5691.53 | +3.839 | +3.855 | 739 | P66 | 2 | 2007 | 2.0724 | 0.000264 | 34.7037 | 0.07192 | 150
PLAT | 3754.1 | 24512.5 | 8339.86 | +3.746 | +3.762 | 739 | P67 | 2 | 2007 | 2.0724 | 0.000264 | 34.7037 | 0.07192 | 150
PLAT | 4032.19 | 24512.5 | 394.86 | +4.024 | +4.040 | 739 | P96 | 2 | 2007 | 2.0724 | 0.000264 | 34.7037 | 0.07192 | 150
PLAT | 4032.19 | 21981.2 | 394.86 | +4.024 | +4.040 | 739 | P96 | 2 | 2007 | 2.0724 | 0.000264 | 34.7037 | 0.07192 | 150
PLAT | 3754.1 | 21981.2 | 8339.86 | +3.746 | +3.762 | 739 | P67 | 2 | 2007 | 2.0724 | 0.000264 | 34.7037 | 0.07192 | 150
PLAT | 3846.79 | 21981.2 | 5691.53 | +3.839 | +3.855 | 739 | P66 | 2 | 2007 | 2.0724 | 0.000264 | 34.7037 | 0.07192 | 150
PLAT | 4032.19 | 19450 | 394.86 | +4.024 | +4.040 | 739 | P96 | 2 | 2007 | 2.0724 | 0.000264 | 34.7037 | 0.07192 | 150
PLAT | 3846.79 | 19450 | 5691.53 | +3.839 | +3.855 | 739 | P66 | 2 | 2007 | 2.0724 | 0.000264 | 34.7037 | 0.07192 | 150
PLAT | 3754.1 | 19450 | 8339.86 | +3.746 | +3.762 | 739 | P67 | 2 | 2007 | 2.0724 | 0.000264 | 34.7037 | 0.07192 | 150
PLAT | 4032.19 | 17320 | 394.86 | +4.024 | +4.040 | 739 | P96 | 2 | 2007 | 2.0724 | 0.000264 | 34.7037 | 0.07192 | 150
PLAT | 3846.79 | 17320 | 5691.53 | +3.839 | +3.855 | 739 | P66 | 2 | 2007 | 2.0724 | 0.000264 | 34.7037 | 0.07192 | 150
PLAT | 3754.1 | 17320 | 8339.86 | +3.746 | +3.762 | 739 | P67 | 2 | 2007 | 2.0724 | 0.000264 | 34.7037 | 0.07192 | 150
PLAT | 4032.19 | 15190 | 394.86 | +4.024 | +4.040 | 739 | P96 | 2 | 2007 | 2.0724 | 0.000264 | 34.7037 | 0.07192 | 150
PLAT | 3846.79 | 15190 | 5691.53 | +3.839 | +3.855 | 739 | P66 | 2 | 2007 | 2.0724 | 0.000264 | 34.7037 | 0.07192 | 150
PLAT | 3754.1 | 15190 | 8339.86 | +3.746 | +3.762 | 739 | P67 | 2 | 2007 | 2.0724 | 0.000264 | 34.7037 | 0.07192 | 150
PLAT | 3846.79 | 13060 | 5691.53 | +3.839 | +3.855 | 739 | P66 | 2 | 2007 | 2.0724 | 0.000264 | 34.7037 | 0.07192 | 150
PLAT | 3846.79 | 10930 | 5691.53 | +3.839 | +3.855 | 739 | P78 | 2 | 2007 | 2.0724 | 0.000264 | 34.7037 | 0.07192 | 150
PLAT | 4025.54 | 10930 | 584.86 | +4.018 | +4.033 | 739 | P94 | 2 | 2007 | 2.0724 | 0.000264 | 34.7037 | 0.07192 | 150
PLAT | 4032.19 | 13060 | 394.86 | +4.024 | +4.040 | 739 | P96 | 2 | 2007 | 2.0724 | 0.000264 | 34.7037 | 0.07192 | 150
PLAT | 3754.1 | 10930 | 8339.86 | +3.746 | +3.762 | 739 | P79 | 2 | 2007 | 2.0724 | 0.000264 | 34.7037 | 0.07192 | 150
PLAT | 3754.1 | 13060 | 8339.86 | +3.746 | +3.762 | 739 | P67 | 2 | 2007 | 2.0724 | 0.000264 | 34.7037 | 0.07192 | 150
PLAT | 5415.64 | 32660 | 70901.5 | +5.405 | +5.427 | 740 | P103 | 1 | 1008 | 1.60266 | 0.00020416 | 35.2016 | 0.056416 | 116
PLAT | 5519.97 | 31395 | 72658.7 | +5.515 | +5.525 | 740 | P104 | 1 | 1008 | 1.60265 | 0.00020416 | 35.2016 | 0.056416 | 116
PLAT | 5519.97 | 30545 | 72658.7 | +5.514 | +5.526 | 739 | P97 | 1 | 1008 | 2.0724 | 0.000264 | 34.7037 | 0.07192 | 150
PLAT | 5519.97 | 27745 | 72658.7 | +5.514 | +5.526 | 739 | P97 | 1 | 1008 | 2.0724 | 0.000264 | 34.7037 | 0.07192 | 150
PLAT | 5428.18 | 18660 | 68124.9 | +5.422 | +5.434 | 740 | P102 | 1 | 1008 | 1.60266 | 0.00020416 | 35.2016 | 0.056416 | 116
PLAT | 5351.45 | 18660 | 70599.9 | +5.346 | +5.357 | 740 | P87 | 1 | 1008 | 1.60266 | 0.00020416 | 35.2016 | 0.056416 | 116
PLAT | 5415.64 | 24650 | 70901.5 | +5.398 | +5.433 | 739 | P74 | 1 | 1008 | 2.0724 | 0.000264 | 34.7037 | 0.07192 | 150
PLAT | 5415.64 | 19950 | 70901.5 | +5.405 | +5.427 | 740 | P103 | 1 | 1008 | 1.60266 | 0.00020416 | 35.2016 | 0.056416 | 116
PLAT | 5351.45 | 17090 | 70599.9 | +5.344 | +5.359 | 739 | P71 | 1 | 1008 | 2.0724 | 0.000264 | 34.7037 | 0.07192 | 150
PLAT | 5428.18 | 17090 | 68124.9 | +5.421 | +5.436 | 739 | P73 | 1 | 1008 | 2.0724 | 0.000264 | 34.7037 | 0.07192 | 150
PLAT | 5351.45 | 14730 | 70599.9 | +5.344 | +5.359 | 739 | P71 | 1 | 1008 | 2.0724 | 0.000264 | 34.7037 | 0.07192 | 150
PLAT | 5428.18 | 14730 | 68124.9 | +5.421 | +5.436 | 739 | P73 | 1 | 1008 | 2.0724 | 0.000264 | 34.7037 | 0.07192 | 150
PLAT | 5121.28 | 10010 | 78024.9 | +5.114 | +5.129 | 739 | P68 | 1 | 1008 | 2.0724 | 0.000264 | 34.7037 | 0.07192 | 150
PLAT | 5198 | 10010 | 75549.9 | +5.191 | +5.205 | 739 | P69 | 1 | 1008 | 2.0724 | 0.000264 | 34.7037 | 0.07192 | 150
PLAT | 5274.73 | 10010 | 73074.9 | +5.267 | +5.282 | 739 | P70 | 1 | 1008 | 2.0724 | 0.000264 | 34.7037 | 0.07192 | 150
PLAT | 5351.45 | 10010 | 70599.9 | +5.344 | +5.359 | 739 | P71 | 1 | 1008 | 2.0724 | 0.000264 | 34.7037 | 0.07192 | 150
PLAT | 5428.18 | 10010 | 68124.9 | +5.421 | +5.436 | 739 | P73 | 1 | 1008 | 2.0724 | 0.000264 | 34.7037 | 0.07192 | 150
PLAT | 5428.18 | 7650 | 68124.9 | +5.421 | +5.436 | 739 | P73 | 1 | 1008 | 2.0724 | 0.000264 | 34.7037 | 0.07192 | 150
PLAT | 5351.45 | 7650 | 70599.9 | +5.344 | +5.359 | 739 | P71 | 1 | 1008 | 2.0724 | 0.000264 | 34.7037 | 0.07192 | 150
PLAT | 5274.73 | 7650 | 73074.9 | +5.267 | +5.282 | 739 | P70 | 1 | 1008 | 2.0724 | 0.000264 | 34.7037 | 0.07192 | 150
PLAT | 5198 | 7650 | 75549.9 | +5.191 | +5.205 | 739 | P69 | 1 | 1008 | 2.0724 | 0.000264 | 34.7037 | 0.07192 | 150
PLAT | 5121.28 | 7650 | 78024.9 | +5.114 | +5.129 | 739 | P68 | 1 | 1008 | 2.0724 | 0.000264 | 34.7037 | 0.07192 | 150
PLAT | 5428.18 | 12370 | 68124.9 | +5.421 | +5.436 | 739 | P73 | 1 | 1008 | 2.0724 | 0.000264 | 34.7037 | 0.07192 | 150
PLAT | 5121.28 | 2550 | 78024.9 | +5.114 | +5.129 | 739 | P68 | 1 | 1008 | 2.0724 | 0.000264 | 34.7037 | 0.07192 | 150
PLAT | 5198 | 2550 | 75549.9 | +5.191 | +5.205 | 739 | P69 | 1 | 1008 | 2.0724 | 0.000264 | 34.7037 | 0.07192 | 150
PLAT | 5351.45 | 2550 | 70599.9 | +5.344 | +5.359 | 739 | P71 | 1 | 1008 | 2.0724 | 0.000264 | 34.7037 | 0.07192 | 150
PLAT | 5428.18 | 2550 | 68124.9 | +5.421 | +5.436 | 739 | P73 | 1 | 1008 | 2.0724 | 0.000264 | 34.7037 | 0.07192 | 150
PLAT | 5121.28 | 5100 | 78024.9 | +5.114 | +5.129 | 739 | P68 | 1 | 1008 | 2.0724 | 0.000264 | 34.7037 | 0.07192 | 150
PLAT | 5198 | 5100 | 75549.9 | +5.191 | +5.205 | 739 | P69 | 1 | 1008 | 2.0724 | 0.000264 | 34.7037 | 0.07192 | 150
PLAT | 5274.73 | 5100 | 73074.9 | +5.267 | +5.282 | 739 | P70 | 1 | 1008 | 2.0724 | 0.000264 | 34.7037 | 0.07192 | 150
PLAT | 5351.45 | 5100 | 70599.9 | +5.344 | +5.359 | 739 | P71 | 1 | 1008 | 2.0724 | 0.000264 | 34.7037 | 0.07192 | 150
PLAT | 5428.18 | 5100 | 68124.9 | +5.421 | +5.436 | 739 | P73 | 1 | 1008 | 2.0724 | 0.000264 | 34.7037 | 0.07192 | 150
PLAT | 5351.45 | 12370 | 70599.9 | +5.344 | +5.359 | 739 | P71 | 1 | 1008 | 2.0724 | 0.000264 | 34.7037 | 0.07192 | 150
PLAT | 5274.73 | 12370 | 73074.9 | +5.267 | +5.282 | 739 | P80 | 1 | 1008 | 2.0724 | 0.000264 | 34.7037 | 0.07192 | 150
PLAT | 5198 | 12370 | 75549.9 | +5.191 | +5.205 | 739 | P81 | 1 | 1008 | 2.0724 | 0.000264 | 34.7037 | 0.07192 | 150
PLAT | 5121.28 | 12370 | 78024.9 | +5.114 | +5.129 | 739 | P82 | 1 | 1008 | 2.0724 | 0.000264 | 34.7037 | 0.07192 | 150
PLAT | 5274.73 | 2550 | 73074.9 | +5.267 | +5.282 | 739 | P70 | 1 | 1008 | 2.0724 | 0.000264 | 34.7037 | 0.07192 | 150
PLAT | 5428.18 | 650 | 68124.9 | +5.422 | +5.434 | 740 | P102 | 1 | 1008 | 1.60266 | 0.00020416 | 35.2016 | 0.056416 | 116
PLAT | 5351.45 | 650 | 70599.9 | +5.346 | +5.357 | 740 | P87 | 1 | 1008 | 1.60266 | 0.00020416 | 35.2016 | 0.056416 | 116
PLAT | 5274.73 | 650 | 73074.9 | +5.269 | +5.281 | 740 | P88 | 1 | 1008 | 1.60266 | 0.00020416 | 35.2016 | 0.056416 | 116
PLAT | 5198 | 650 | 75549.9 | +5.192 | +5.204 | 740 | P89 | 1 | 1008 | 1.60266 | 0.00020416 | 35.2016 | 0.056416 | 116
PLAT | 5121.28 | 650 | 78024.9 | +5.115 | +5.127 | 740 | P90 | 1 | 1008 | 1.60266 | 0.00020416 | 35.2016 | 0.056416 | 116
PLAT | 5415.64 | 22050 | 70901.5 | +5.398 | +5.433 | 739 | P74 | 1 | 1008 | 2.0724 | 0.000264 | 34.7037 | 0.07192 | 150
PLAT | 5415.64 | 26545 | 70901.5 | +5.405 | +5.427 | 740 | P75 | 1 | 1008 | 1.60266 | 0.00020416 | 35.2016 | 0.056416 | 116
PLAT | 5519.97 | 29145 | 72658.7 | +5.514 | +5.526 | 739 | P97 | 1 | 1008 | 2.0724 | 0.000264 | 34.7037 | 0.07192 | 150
PLAT | 5519.97 | 26895 | 72658.7 | +5.515 | +5.525 | 740 | P104 | 1 | 1008 | 1.60265 | 0.00020416 | 35.2016 | 0.056416 | 116
PLAT | 5465.98 | 31395 | 75358.7 | +5.461 | +5.471 | 740 | P105 | 1 | 1008 | 1.60265 | 0.00020416 | 35.2016 | 0.0564159 | 116
PLAT | 5465.98 | 30545 | 75358.7 | +5.460 | +5.472 | 739 | P98 | 1 | 1008 | 2.0724 | 0.000264 | 34.7037 | 0.07192 | 150
PLAT | 5465.98 | 29145 | 75358.7 | +5.460 | +5.472 | 739 | P98 | 1 | 1008 | 2.0724 | 0.000264 | 34.7037 | 0.07192 | 150
PLAT | 5465.98 | 27745 | 75358.7 | +5.460 | +5.472 | 739 | P98 | 1 | 1008 | 2.0724 | 0.000264 | 34.7037 | 0.07192 | 150
PLAT | 5465.98 | 26895 | 75358.7 | +5.461 | +5.471 | 740 | P105 | 1 | 1008 | 1.60265 | 0.00020416 | 35.2016 | 0.056416 | 116
PLAT | 5412.25 | 31395 | 78044.9 | +5.407 | +5.417 | 740 | P106 | 1 | 1008 | 1.60265 | 0.00020416 | 35.2016 | 0.0564159 | 116
PLAT | 5412.25 | 30545 | 78044.9 | +5.406 | +5.418 | 739 | P99 | 1 | 1008 | 2.0724 | 0.000264 | 34.7037 | 0.07192 | 150
PLAT | 5412.25 | 29145 | 78044.9 | +5.406 | +5.418 | 739 | P99 | 1 | 1008 | 2.0724 | 0.000264 | 34.7037 | 0.07192 | 150
PLAT | 5412.25 | 27745 | 78044.9 | +5.406 | +5.418 | 739 | P99 | 1 | 1008 | 2.0724 | 0.000264 | 34.7037 | 0.07192 | 150
PLAT | 5412.25 | 26895 | 78044.9 | +5.407 | +5.417 | 740 | P106 | 1 | 1008 | 1.60265 | 0.00020416 | 35.2016 | 0.056416 | 116
PLAT | 3754.1 | 43008.3 | 8339.86 | +3.746 | +3.762 | 739 | P67 | 2 | 2007 | 2.0724 | 0.000264 | 34.7037 | 0.07192 | 150
PLAT | 3846.79 | 43008.3 | 5691.53 | +3.839 | +3.855 | 739 | P66 | 2 | 2007 | 2.0724 | 0.000264 | 34.7037 | 0.07192 | 150
PLAT | 4032.19 | 43008.3 | 394.86 | +4.024 | +4.040 | 739 | P96 | 2 | 2007 | 2.0724 | 0.000264 | 34.7037 | 0.07192 | 150
PLAT | 3754.1 | 45766.7 | 8339.86 | +3.746 | +3.762 | 739 | P67 | 2 | 2007 | 2.0724 | 0.000264 | 34.7037 | 0.07192 | 150
PLAT | 3846.79 | 45766.7 | 5691.53 | +3.839 | +3.855 | 739 | P66 | 2 | 2007 | 2.0724 | 0.000264 | 34.7037 | 0.07192 | 150
PLAT | 4032.19 | 45766.7 | 394.86 | +4.024 | +4.040 | 739 | P96 | 2 | 2007 | 2.0724 | 0.000264 | 34.7037 | 0.07192 | 150
PLAT | 3754.1 | 48525 | 8339.86 | +3.746 | +3.762 | 739 | P79 | 2 | 2007 | 2.0724 | 0.000264 | 34.7037 | 0.07192 | 150
PLAT | 3846.79 | 48525 | 5691.53 | +3.839 | +3.855 | 739 | P78 | 2 | 2007 | 2.0724 | 0.000264 | 34.7037 | 0.07192 | 150
PLAT | 4025.54 | 48525 | 584.86 | +4.018 | +4.033 | 739 | P94 | 2 | 2007 | 2.0724 | 0.000264 | 34.7037 | 0.07192 | 150
PLAT | 10486.2 | 65860 | 23190.9 | +10.480 | +10.492 | 740 | P100 | 2 | 2007 | 1.60266 | 0.00020416 | 35.2016 | 0.056416 | 116
PLAT | 10310.9 | 65970 | 28846.9 | +10.305 | +10.317 | 740 | P85 | 2 | 2007 | 1.60266 | 0.00020416 | 35.2016 | 0.056416 | 116
PLAT | 10223.2 | 65970 | 31674.9 | +10.217 | +10.229 | 740 | P86 | 2 | 2007 | 1.60266 | 0.00020416 | 35.2016 | 0.056416 | 116
PLAT | 10574 | 65970 | 20359.9 | +10.568 | +10.580 | 740 | P101 | 2 | 2007 | 1.60266 | 0.00020416 | 35.2016 | 0.056416 | 116
PLAT | 10398.5 | 65970 | 26018.9 | +10.393 | +10.404 | 740 | P84 | 2 | 2007 | 1.60266 | 0.00020416 | 35.2016 | 0.056416 | 116
PLAT | 10223.2 | 63750 | 31674.9 | +10.216 | +10.231 | 739 | P63 | 2 | 2007 | 2.0724 | 0.000264 | 34.7037 | 0.07192 | 150
PLAT | 10310.9 | 63750 | 28846.9 | +10.303 | +10.318 | 739 | P65 | 2 | 2007 | 2.0724 | 0.000264 | 34.7037 | 0.07192 | 150
PLAT | 10398.5 | 63750 | 26018.8 | +10.391 | +10.406 | 739 | P64 | 2 | 2007 | 2.0724 | 0.000264 | 34.7037 | 0.07192 | 150
PLAT | 10486.2 | 63750 | 23190.8 | +10.479 | +10.494 | 739 | P72 | 2 | 2007 | 2.0724 | 0.000264 | 34.7037 | 0.07192 | 150
PLAT | 10574 | 63750 | 20359.9 | +10.567 | +10.581 | 739 | P95 | 2 | 2007 | 2.0724 | 0.000264 | 34.7037 | 0.07192 | 150
PLAT | 10486.2 | 60985 | 23190.8 | +10.479 | +10.494 | 739 | P72 | 2 | 2007 | 2.0724 | 0.000264 | 34.7037 | 0.07192 | 150
PLAT | 10398.5 | 60985 | 26018.8 | +10.391 | +10.406 | 739 | P64 | 2 | 2007 | 2.0724 | 0.000264 | 34.7037 | 0.07192 | 150
PLAT | 10310.9 | 60985 | 28846.9 | +10.303 | +10.318 | 739 | P65 | 2 | 2007 | 2.0724 | 0.000264 | 34.7037 | 0.07192 | 150
PLAT | 10223.2 | 60985 | 31674.9 | +10.216 | +10.231 | 739 | P63 | 2 | 2007 | 2.0724 | 0.000264 | 34.7037 | 0.07192 | 150
PLAT | 10486.2 | 58220 | 23190.8 | +10.479 | +10.494 | 739 | P72 | 2 | 2007 | 2.0724 | 0.000264 | 34.7037 | 0.07192 | 150
PLAT | 10398.5 | 58220 | 26018.8 | +10.391 | +10.406 | 739 | P64 | 2 | 2007 | 2.0724 | 0.000264 | 34.7037 | 0.07192 | 150
PLAT | 10310.9 | 58220 | 28846.9 | +10.303 | +10.318 | 739 | P65 | 2 | 2007 | 2.0724 | 0.000264 | 34.7037 | 0.07192 | 150
PLAT | 10223.2 | 58220 | 31674.9 | +10.216 | +10.231 | 739 | P63 | 2 | 2007 | 2.0724 | 0.000264 | 34.7037 | 0.07192 | 150
PLAT | 10486.2 | 55455 | 23190.8 | +10.479 | +10.494 | 739 | P72 | 2 | 2007 | 2.0724 | 0.000264 | 34.7037 | 0.07192 | 150
PLAT | 10398.5 | 55455 | 26018.8 | +10.391 | +10.406 | 739 | P64 | 2 | 2007 | 2.0724 | 0.000264 | 34.7037 | 0.07192 | 150
PLAT | 10310.9 | 55455 | 28846.9 | +10.303 | +10.318 | 739 | P65 | 2 | 2007 | 2.0724 | 0.000264 | 34.7037 | 0.07192 | 150
PLAT | 10223.2 | 55455 | 31674.9 | +10.216 | +10.231 | 739 | P63 | 2 | 2007 | 2.0724 | 0.000264 | 34.7037 | 0.07192 | 150
PLAT | 10486.2 | 52690 | 23190.8 | +10.479 | +10.494 | 739 | P72 | 2 | 2007 | 2.0724 | 0.000264 | 34.7037 | 0.07192 | 150
PLAT | 10398.5 | 52690 | 26018.8 | +10.391 | +10.406 | 739 | P64 | 2 | 2007 | 2.0724 | 0.000264 | 34.7037 | 0.07192 | 150
PLAT | 10310.9 | 52690 | 28846.9 | +10.303 | +10.318 | 739 | P65 | 2 | 2007 | 2.0724 | 0.000264 | 34.7037 | 0.07192 | 150
PLAT | 10223.2 | 52690 | 31674.9 | +10.216 | +10.231 | 739 | P63 | 2 | 2007 | 2.0724 | 0.000264 | 34.7037 | 0.07192 | 150
PLAT | 10223.2 | 50520 | 31674.9 | +10.217 | +10.229 | 740 | P93 | 2 | 2007 | 1.60266 | 0.00020416 | 35.2016 | 0.056416 | 116
PLAT | 10310.9 | 50520 | 28846.9 | +10.305 | +10.317 | 740 | P92 | 2 | 2007 | 1.60266 | 0.00020416 | 35.2016 | 0.056416 | 116
PLAT | 3939.5 | 48525 | 3043.19 | +3.932 | +3.947 | 739 | P77 | 2 | 2007 | 2.0724 | 0.000264 | 34.7037 | 0.07192 | 150
PLAT | 3939.5 | 45766.7 | 3043.19 | +3.932 | +3.947 | 739 | P62 | 2 | 2007 | 2.0724 | 0.000264 | 34.7037 | 0.07192 | 150
PLAT | 3939.5 | 43008.3 | 3043.19 | +3.932 | +3.947 | 739 | P62 | 2 | 2007 | 2.0724 | 0.000264 | 34.7037 | 0.07192 | 150
PLAT | 3939.5 | 40250 | 3043.19 | +3.932 | +3.947 | 739 | P62 | 2 | 2007 | 2.0724 | 0.000264 | 34.7037 | 0.07192 | 150
PLAT | 3939.5 | 37581.2 | 3043.19 | +3.932 | +3.947 | 739 | P62 | 2 | 2007 | 2.0724 | 0.000264 | 34.7037 | 0.07192 | 150
PLAT | 3939.5 | 34912.5 | 3043.19 | +3.932 | +3.947 | 739 | P62 | 2 | 2007 | 2.0724 | 0.000264 | 34.7037 | 0.07192 | 150
PLAT | 3939.5 | 32243.7 | 3043.19 | +3.932 | +3.947 | 739 | P62 | 2 | 2007 | 2.0724 | 0.000264 | 34.7037 | 0.07192 | 150
PLAT | 3939.5 | 29575 | 3043.19 | +3.932 | +3.947 | 739 | P62 | 2 | 2007 | 2.0724 | 0.000264 | 34.7037 | 0.07192 | 150
PLAT | 3939.5 | 27043.7 | 3043.19 | +3.932 | +3.947 | 739 | P62 | 2 | 2007 | 2.0724 | 0.000264 | 34.7037 | 0.07192 | 150
PLAT | 3939.5 | 24512.5 | 3043.19 | +3.932 | +3.947 | 739 | P62 | 2 | 2007 | 2.0724 | 0.000264 | 34.7037 | 0.07192 | 150
PLAT | 3939.5 | 21981.2 | 3043.19 | +3.932 | +3.947 | 739 | P62 | 2 | 2007 | 2.0724 | 0.000264 | 34.7037 | 0.07192 | 150
PLAT | 3939.5 | 19450 | 3043.19 | +3.932 | +3.947 | 739 | P62 | 2 | 2007 | 2.0724 | 0.000264 | 34.7037 | 0.07192 | 150
PLAT | 3939.5 | 17320 | 3043.19 | +3.932 | +3.947 | 739 | P62 | 2 | 2007 | 2.0724 | 0.000264 | 34.7037 | 0.07192 | 150
PLAT | 3939.5 | 15190 | 3043.19 | +3.932 | +3.947 | 739 | P62 | 2 | 2007 | 2.0724 | 0.000264 | 34.7037 | 0.07192 | 150
PLAT | 3939.5 | 10930 | 3043.19 | +3.932 | +3.947 | 739 | P77 | 2 | 2007 | 2.0724 | 0.000264 | 34.7037 | 0.07192 | 150
PLAT | 3939.5 | 13060 | 3043.19 | +3.932 | +3.947 | 739 | P62 | 2 | 2007 | 2.0724 | 0.000264 | 34.7037 | 0.07192 | 150
PLAT | 3393.22 | 15190 | 10405.2 | +3.386 | +3.401 | 739 | P76 | 2 | 2007 | 2.0724 | 0.000264 | 34.7037 | 0.07192 | 150
PLAT | 3393.22 | 17320 | 10405.2 | +3.386 | +3.401 | 739 | P76 | 2 | 2007 | 2.0724 | 0.000264 | 34.7037 | 0.07192 | 150
PLAT | 3393.22 | 13060 | 10405.2 | +3.386 | +3.401 | 739 | P76 | 2 | 2007 | 2.0724 | 0.000264 | 34.7037 | 0.07192 | 150
PLAT | 3393.22 | 21981.2 | 10405.2 | +3.386 | +3.401 | 739 | P76 | 2 | 2007 | 2.0724 | 0.000264 | 34.7037 | 0.07192 | 150
PLAT | 3393.22 | 27043.8 | 10405.2 | +3.386 | +3.401 | 739 | P76 | 2 | 2007 | 2.0724 | 0.000264 | 34.7037 | 0.07192 | 150
PLAT | 3393.22 | 32243.8 | 10405.2 | +3.386 | +3.401 | 739 | P76 | 2 | 2007 | 2.0724 | 0.000264 | 34.7037 | 0.07192 | 150
PLAT | 3393.22 | 37581.2 | 10405.2 | +3.386 | +3.401 | 739 | P76 | 2 | 2007 | 2.0724 | 0.000264 | 34.7037 | 0.07192 | 150
PLAT | 3393.22 | 43008.3 | 10405.2 | +3.386 | +3.401 | 739 | P76 | 2 | 2007 | 2.0724 | 0.000264 | 34.7037 | 0.07192 | 150
PLAT | 3393.22 | 19450 | 10405.2 | +3.386 | +3.401 | 739 | P76 | 2 | 2007 | 2.0724 | 0.000264 | 34.7037 | 0.07192 | 150
PLAT | 3393.22 | 24512.5 | 10405.2 | +3.386 | +3.401 | 739 | P76 | 2 | 2007 | 2.0724 | 0.000264 | 34.7037 | 0.07192 | 150
PLAT | 3393.22 | 29575 | 10405.2 | +3.386 | +3.401 | 739 | P76 | 2 | 2007 | 2.0724 | 0.000264 | 34.7037 | 0.07192 | 150
PLAT | 3393.22 | 34912.5 | 10405.2 | +3.386 | +3.401 | 739 | P76 | 2 | 2007 | 2.0724 | 0.000264 | 34.7037 | 0.07192 | 150
PLAT | 3393.22 | 45766.7 | 10405.2 | +3.386 | +3.401 | 739 | P76 | 2 | 2007 | 2.0724 | 0.000264 | 34.7037 | 0.07192 | 150
PLAT | 3393.22 | 40250 | 10405.2 | +3.386 | +3.401 | 739 | P76 | 2 | 2007 | 2.0724 | 0.000264 | 34.7037 | 0.07192 | 150
PLAT | 3393.21 | 11385 | 10405.1 | +3.387 | +3.399 | 740 | P83 | 2 | 2007 | 1.60266 | 0.00020416 | 35.2016 | 0.056416 | 116

# IfcBeam: PL80*10
In: Undefined
Description: PL80*10; Material: STEEL/E24-2
Tekla Common - Center of gravity Z: 4964.38 mm; Center of gravity Y: 29940 mm; Center of gravity X: 79140 mm; Bottom elevation: +4.834; Top elevation: +5.094; Part mark: 231; Assembly mark: P11; Phase: 1; Class: 1011; Finish: GRENAILLE-PEINT; Grade: E24-2; Profile: PL80*10; sets with these values: 2
Tekla Quantity - Net weight: 1.6328 kg; Gross weight: 1.6328 kg; Weight: 1.6328 kg; Net volume: 0.000208 m3; Gross volume: 0.000208 m3; Gross footprint area: 0.0008 m2; Area per tons: 29.6423 m2; Net surface area: 0.0484 m2; Gross area: 0.0484 m2; Height: 80 mm; Width: 10 mm; Length: 260 mm; sets with these values: 2
BaseQuantities - Length: 260 mm; OuterSurfaceArea: 0.0484 m2; NetVolume: 0.000208 m3; NetWeight: 1.6328 kg

# IfcBeam: PL80*6
In: Undefined
Description: PL80*6; Material: STEEL/E24-2
Tekla Common - Center of gravity Z: 4866.86 mm; Center of gravity Y: 33560 mm; Center of gravity X: 79038 mm; Bottom elevation: +4.827; Top elevation: +4.907; Part mark: 344; Assembly mark: N37; Phase: 1; Class: 1011; Finish: GRENAILLE-PEINT; Grade: E24-2; Profile: PL80*6; sets with these values: 2
Tekla Quantity - Net weight: 10.6635 kg; Gross weight: 10.6635 kg; Weight: 10.6635 kg; Net volume: 0.0013584 m3; Gross volume: 0.0013584 m3; Gross footprint area: 0.01698 m2; Area per tons: 45.7376 m2; Net surface area: 0.48772 m2; Gross area: 0.48772 m2; Height: 80 mm; Width: 6 mm; Length: 2830 mm; sets with these values: 2
BaseQuantities - Length: 2830 mm; OuterSurfaceArea: 0.48772 m2; NetVolume: 0.0013584 m3; NetWeight: 10.6635 kg

# IfcBeam: PL80*8 (53)
In: Undefined
Description: PL80*8
Tekla Common - Finish: GRENAILLE-PEINT; Profile: PL80*8; sets with these values: 2
Tekla Quantity - Height: 80 mm; Width: 8 mm; sets with these values: 2
Name | Material | Center of gravity Z (mm) | Center of gravity Y (mm) | Center of gravity X (mm) | Bottom elevation | Top elevation | Part mark | Assembly mark | Phase | Class | Grade | Name | Net weight (kg) = Gross weight (kg) = Weight (kg) = NetWeight (kg) | Net volume (m3) = Gross volume (m3) = NetVolume (m3) | Gross footprint area (m2) | Area per tons (m2) | Net surface area (m2) = Gross area (m2) = OuterSurfaceArea (m2) | Tekla Quantity, Length (mm) = BaseQuantities, Length (mm)
SUSPENTE | STEEL/E24-2 | 3124 | 15190 | 650 | +3.120 | +3.128 | 762 | S8 | 6 | 6001 | E24-2 | SUSPENTE | 0.95456 | 0.0001216 | 0.0152 | 36.3728 | 0.03472 | 190
SUSPENTE | STEEL/E24-2 | 3124 | 13060 | 650 | +3.120 | +3.128 | 762 | S7 | 6 | 6001 | E24-2 | SUSPENTE | 0.95456 | 0.0001216 | 0.0152 | 36.3728 | 0.03472 | 190
SUSPENTE | STEEL/E24-2 | 3124 | 10930 | 650 | +3.120 | +3.128 | 762 | S8 | 6 | 6001 | E24-2 | SUSPENTE | 0.95456 | 0.0001216 | 0.0152 | 36.3728 | 0.03472 | 190
SUSPENTE | STEEL/E24-2 | 3124 | 13060 | 3315 | +3.120 | +3.128 | 762 | S5 | 6 | 6001 | E24-2 | SUSPENTE | 0.95456 | 0.0001216 | 0.0152 | 36.3728 | 0.03472 | 190
SUSPENTE | STEEL/E24-2 | 3124 | 10930 | 3315 | +3.120 | +3.128 | 762 | S6 | 6 | 6001 | E24-2 | SUSPENTE | 0.95456 | 0.0001216 | 0.0152 | 36.3728 | 0.03472 | 190
ATTACHE | STEEL/E24-2 | 5896 | 18990 | 71812 | +5.892 | +5.900 | H44 | H44 | 4 | 4001 | E24-2 | ATTACHE | 0.582784 | 0.00007424 | 0.00928 | 37.2282 | 0.021696 | 116
ATTACHE | STEEL/E24-2 | 5896 | 18310 | 71812 | +5.892 | +5.900 | H44 | H44 | 4 | 4001 | E24-2 | ATTACHE | 0.582784 | 0.00007424 | 0.00928 | 37.2282 | 0.021696 | 116
 | STEEL/S235JR | 5784 | 13550 | 71929 | +5.744 | +5.824 | 800 | P123 | 1 | 1011 | S235JR |  | 1.0048 | 0.000128 | 0.0016 | 36.3057 | 0.03648 | 200
 | STEEL/E24-2 | 4712.09 | 69157 | 44190.9 | +4.672 | +4.752 | 676 | L45 | 3 | 3003 | E24-2 |  | 0.65312 | 0.0000832 | 0.00104 | 36.9917 | 0.02416 | 130
 | STEEL/E24-2 | 5397.09 | 69157 | 44190.9 | +5.357 | +5.437 | 676 | L45 | 3 | 3003 | E24-2 |  | 0.65312 | 0.0000832 | 0.00104 | 36.9917 | 0.02416 | 130
 | STEEL/E24-2 | 5397.09 | 69157 | 55865.9 | +5.357 | +5.437 | 676 | L44 | 1 | 1003 | E24-2 |  | 0.65312 | 0.0000832 | 0.00104 | 36.9917 | 0.02416 | 130
 | STEEL/E24-2 | 4712.09 | 69157 | 55865.9 | +4.672 | +4.752 | 676 | L44 | 1 | 1003 | E24-2 |  | 0.65312 | 0.0000832 | 0.00104 | 36.9917 | 0.02416 | 130
 | STEEL/E24-2 | 4712.09 | 69157 | 67540.9 | +4.672 | +4.752 | 676 | L44 | 1 | 1003 | E24-2 |  | 0.65312 | 0.0000832 | 0.00104 | 36.9917 | 0.02416 | 130
 | STEEL/E24-2 | 5397.09 | 69157 | 67540.9 | +5.357 | +5.437 | 676 | L44 | 1 | 1003 | E24-2 |  | 0.65312 | 0.0000832 | 0.00104 | 36.9917 | 0.02416 | 130
 | STEEL/E24-2 | 4712.09 | -6.99989 | 44190.9 | +4.672 | +4.752 | 676 | L43 | 3 | 3003 | E24-2 |  | 0.65312 | 0.0000832 | 0.00104 | 36.9917 | 0.02416 | 130
 | STEEL/E24-2 | 5397.09 | -6.99989 | 44190.9 | +5.357 | +5.437 | 676 | L43 | 3 | 3003 | E24-2 |  | 0.65312 | 0.0000832 | 0.00104 | 36.9917 | 0.02416 | 130
 | STEEL/E24-2 | 4712.09 | -6.99989 | 55865.9 | +4.672 | +4.752 | 676 | L42 | 1 | 1003 | E24-2 |  | 0.65312 | 0.0000832 | 0.00104 | 36.9917 | 0.02416 | 130
 | STEEL/E24-2 | 5397.09 | -6.99989 | 55865.9 | +5.357 | +5.437 | 676 | L42 | 1 | 1003 | E24-2 |  | 0.65312 | 0.0000832 | 0.00104 | 36.9917 | 0.02416 | 130
 | STEEL/E24-2 | 4712.09 | -6.99989 | 67540.9 | +4.672 | +4.752 | 676 | L42 | 1 | 1003 | E24-2 |  | 0.65312 | 0.0000832 | 0.00104 | 36.9917 | 0.02416 | 130
 | STEEL/E24-2 | 5397.09 | -6.99989 | 67540.9 | +5.357 | +5.437 | 676 | L42 | 1 | 1003 | E24-2 |  | 0.65312 | 0.0000832 | 0.00104 | 36.9917 | 0.02416 | 130
GOUSSET | STEEL/E24-2 | 10124.8 | 50009 | 29361.1 | +10.084 | +10.166 | 727 | B10 | 2 | 2004 | E24-2 | GOUSSET | 0.40192 | 0.0000512 | 0 | 38.2166 | 0.01536 | 80
GOUSSET | STEEL/E24-2 | 10124.8 | 49965 | 29361.1 | +10.120 | +10.130 | 726 | B10 | 2 | 2004 | E24-2 | GOUSSET | 0.40192 | 0.0000512 | 0 | 38.2166 | 0.01536 | 80
GOUSSET | STEEL/E24-2 | 10322.2 | 66431 | 22993.6 | +10.281 | +10.363 | 727 | B10 | 2 | 2004 | E24-2 | GOUSSET | 0.40192 | 0.0000512 | 0 | 38.2166 | 0.01536 | 80
GOUSSET | STEEL/E24-2 | 10124.8 | 52537.7 | 29361.1 | +10.084 | +10.166 | 727 | B10 | 2 | 2004 | E24-2 | GOUSSET | 0.40192 | 0.0000512 | 0 | 38.2166 | 0.01536 | 80
GOUSSET | STEEL/E24-2 | 10227.5 | 50065 | 26177.5 | +10.222 | +10.233 | 706 | B6 | 2 | 2004 | E24-2 | GOUSSET | 0.60288 | 0.0000768 | 0 | 37.155 | 0.0224 | 120
GOUSSET | STEEL/E24-2 | 10322.2 | 52537.7 | 22993.6 | +10.281 | +10.363 | 727 | B11 | 2 | 2004 | E24-2 | GOUSSET | 0.40192 | 0.0000512 | 0 | 38.2166 | 0.01536 | 80
GOUSSET | STEEL/E24-2 | 10322.2 | 50015 | 22993.6 | +10.317 | +10.327 | 726 | B11 | 2 | 2004 | E24-2 | GOUSSET | 0.40192 | 0.0000512 | 0 | 38.2166 | 0.01536 | 80
GOUSSET | STEEL/E24-2 | 10124.8 | 52581.7 | 29361.1 | +10.120 | +10.130 | 726 | B10 | 2 | 2004 | E24-2 | GOUSSET | 0.40192 | 0.0000512 | 0 | 38.2166 | 0.01536 | 80
GOUSSET | STEEL/E24-2 | 10322.2 | 50059 | 22993.6 | +10.281 | +10.363 | 727 | B11 | 2 | 2004 | E24-2 | GOUSSET | 0.40192 | 0.0000512 | 0 | 38.2166 | 0.01536 | 80
GOUSSET | STEEL/E24-2 | 10322.2 | 52581.7 | 22993.6 | +10.317 | +10.327 | 726 | B11 | 2 | 2004 | E24-2 | GOUSSET | 0.40192 | 0.0000512 | 0 | 38.2166 | 0.01536 | 80
GOUSSET | STEEL/E24-2 | 10124.8 | 66475 | 29361.1 | +10.120 | +10.130 | 726 | B10 | 2 | 2004 | E24-2 | GOUSSET | 0.40192 | 0.0000512 | 0 | 38.2166 | 0.01536 | 80
GOUSSET | STEEL/E24-2 | 10124.8 | 66431 | 29361.1 | +10.084 | +10.166 | 727 | B10 | 2 | 2004 | E24-2 | GOUSSET | 0.40192 | 0.0000512 | 0 | 38.2166 | 0.01536 | 80
GOUSSET | STEEL/E24-2 | 10124.8 | 63902.3 | 29361.1 | +10.084 | +10.166 | 727 | B10 | 2 | 2004 | E24-2 | GOUSSET | 0.40192 | 0.0000512 | 0 | 38.2166 | 0.01536 | 80
GOUSSET | STEEL/E24-2 | 10124.8 | 63858.3 | 29361.1 | +10.120 | +10.130 | 726 | B10 | 2 | 2004 | E24-2 | GOUSSET | 0.40192 | 0.0000512 | 0 | 38.2166 | 0.01536 | 80
GOUSSET | STEEL/E24-2 | 10322.2 | 66475 | 22993.6 | +10.317 | +10.327 | 726 | B10 | 2 | 2004 | E24-2 | GOUSSET | 0.40192 | 0.0000512 | 0 | 38.2166 | 0.01536 | 80
GOUSSET | STEEL/E24-2 | 10322.2 | 63902.3 | 22993.6 | +10.281 | +10.363 | 727 | B10 | 2 | 2004 | E24-2 | GOUSSET | 0.40192 | 0.0000512 | 0 | 38.2166 | 0.01536 | 80
GOUSSET | STEEL/E24-2 | 10322.2 | 63858.3 | 22993.6 | +10.317 | +10.327 | 726 | B10 | 2 | 2004 | E24-2 | GOUSSET | 0.40192 | 0.0000512 | 0 | 38.2166 | 0.01536 | 80
GOUSSET | STEEL/E24-2 | 10227.5 | 66375 | 26177.5 | +10.222 | +10.233 | 706 | B6 | 2 | 2004 | E24-2 | GOUSSET | 0.60288 | 0.0000768 | 0 | 37.155 | 0.0224 | 120
ATTACHE | STEEL/E24-2 | 3020 | 10215 | 626 | +2.980 | +3.060 | 683 | P131 | 2 | 2003 | E24-2 | ATTACHE | 0.808864 | 0.00010304 | 0.001288 | 36.6143 | 0.029616 | 161
ATTACHE | STEEL/E24-2 | 3020 | 10215 | 8904 | +2.980 | +3.060 | 760 | P130 | 2 | 2003 | E24-2 | ATTACHE | 0.808864 | 0.00010304 | 0.001288 | 36.6143 | 0.029616 | 161
SUSPENTE | STEEL/E24-2 | 3124 | 13060 | 6325 | +3.120 | +3.128 | 762 | S3 | 6 | 6001 | E24-2 | SUSPENTE | 0.95456 | 0.0001216 | 0.0152 | 36.3728 | 0.03472 | 190
SUSPENTE | STEEL/E24-2 | 3124 | 10930 | 6325 | +3.120 | +3.128 | 762 | S4 | 6 | 6001 | E24-2 | SUSPENTE | 0.95456 | 0.0001216 | 0.0152 | 36.3728 | 0.03472 | 190
SUSPENTE | STEEL/E24-2 | 3124 | 15190 | 3315 | +3.120 | +3.128 | 762 | S6 | 6 | 6001 | E24-2 | SUSPENTE | 0.95456 | 0.0001216 | 0.0152 | 36.3728 | 0.03472 | 190
SUSPENTE | STEEL/E24-2 | 3124 | 17320 | 3315 | +3.120 | +3.128 | 762 | S5 | 6 | 6001 | E24-2 | SUSPENTE | 0.95456 | 0.0001216 | 0.0152 | 36.3728 | 0.03472 | 190
SUSPENTE | STEEL/E24-2 | 3124 | 17320 | 650 | +3.120 | +3.128 | 762 | S7 | 6 | 6001 | E24-2 | SUSPENTE | 0.95456 | 0.0001216 | 0.0152 | 36.3728 | 0.03472 | 190
SUSPENTE | STEEL/E24-2 | 3124 | 19450 | 650 | +3.120 | +3.128 | 762 | S8 | 6 | 6001 | E24-2 | SUSPENTE | 0.95456 | 0.0001216 | 0.0152 | 36.3728 | 0.03472 | 190
SUSPENTE | STEEL/E24-2 | 3124 | 19450 | 3315 | +3.120 | +3.128 | 762 | S6 | 6 | 6001 | E24-2 | SUSPENTE | 0.95456 | 0.0001216 | 0.0152 | 36.3728 | 0.03472 | 190
SUSPENTE | STEEL/E24-2 | 3124 | 21981.2 | 3315 | +3.120 | +3.128 | 762 | S5 | 6 | 6001 | E24-2 | SUSPENTE | 0.95456 | 0.0001216 | 0.0152 | 36.3728 | 0.03472 | 190
SUSPENTE | STEEL/E24-2 | 3124 | 21981.2 | 650 | +3.120 | +3.128 | 762 | S7 | 6 | 6001 | E24-2 | SUSPENTE | 0.95456 | 0.0001216 | 0.0152 | 36.3728 | 0.03472 | 190
SUSPENTE | STEEL/E24-2 | 3124 | 24512.5 | 650 | +3.120 | +3.128 | 762 | S8 | 6 | 6001 | E24-2 | SUSPENTE | 0.95456 | 0.0001216 | 0.0152 | 36.3728 | 0.03472 | 190
SUSPENTE | STEEL/E24-2 | 3124 | 29575 | 650 | +3.120 | +3.128 | 762 | S9 | 6 | 6001 | E24-2 | SUSPENTE | 0.95456 | 0.0001216 | 0.0152 | 36.3728 | 0.03472 | 190
SUSPENTE | STEEL/E24-2 | 3124 | 27043.8 | 650 | +3.120 | +3.128 | 762 | S10 | 6 | 6001 | E24-2 | SUSPENTE | 0.95456 | 0.0001216 | 0.0152 | 36.3728 | 0.03472 | 190
SUSPENTE | STEEL/E24-2 | 3124 | 32243.8 | 650 | +3.120 | +3.128 | 762 | S10 | 6 | 6001 | E24-2 | SUSPENTE | 0.95456 | 0.0001216 | 0.0152 | 36.3728 | 0.03472 | 190

# IfcBeam: PL800*400, MACONNERIE
In: Undefined
Description: PL800*400; Material: CONCRETE/BETON COURANT
Tekla Common - Center of gravity Z: 5560 mm; Center of gravity Y: 59544.7 mm; Center of gravity X: 32525 mm; Bottom elevation: +5.160; Top elevation: +5.960; Part mark: Z79; Assembly mark: Z79; Phase: 10; Class: 72; Grade: BETON COURANT; Profile: PL800*400; Name: MACONNERIE; sets with these values: 2
Tekla Quantity - Net weight: 13204.4 kg; Gross weight: 13204.4 kg; Weight: 13204.4 kg; Net volume: 6.28781 m3; Gross volume: 6.28781 m3; Gross footprint area: 7.85976 m2; Area per tons: 3.6199 m2; Net surface area: 47.7986 m2; Gross area: 47.7986 m2; Height: 800 mm; Width: 400 mm; Length: 19649.4 mm; sets with these values: 2
BaseQuantities - Length: 19649.4 mm; OuterSurfaceArea: 47.7986 m2; NetVolume: 6.28781 m3; NetWeight: 13204.4 kg

# IfcBeam: PL860*200 (2)
In: Undefined
Description: PL860*200; Material: CONCRETE/BETON COURANT
Tekla Common - Center of gravity Z: 6570 mm; Center of gravity Y: 48922.5 mm; Bottom elevation: +6.140; Top elevation: +7.000; Part mark: Z23; Assembly mark: Z23; Phase: 10; Class: 75; Grade: BETON COURANT; Profile: PL860*200; Name: MACONNERIE; sets with these values: 2
Tekla Quantity - Net weight: 576.114 kg; Gross weight: 576.114 kg; Weight: 576.114 kg; Net volume: 0.27434 m3; Gross volume: 0.27434 m3; Gross footprint area: 0.319 m2; Area per tons: 6.46643 m2; Net surface area: 3.7254 m2; Gross area: 3.7254 m2; Height: 860 mm; Width: 200 mm; Length: 1595 mm; sets with these values: 2
BaseQuantities - Length: 1595 mm; OuterSurfaceArea: 3.7254 m2; NetVolume: 0.27434 m3; NetWeight: 576.114 kg
Name | Center of gravity X (mm)
MACONNERIE | 27745
MACONNERIE | 20639.9

# IfcBeam: PL9000*200, PREFA
In: Undefined
Description: PL9000*200; Material: CONCRETE/BETON COURANT
Tekla Common - Center of gravity Z: 4600 mm; Center of gravity Y: 35308.2 mm; Center of gravity X: 15040 mm; Bottom elevation: +4.500; Top elevation: +4.700; Part mark: Z53; Assembly mark: Z53; Phase: 10; Class: 77; Grade: BETON COURANT; Profile: PL9000*200; Name: PREFA; sets with these values: 2
Tekla Quantity - Net weight: 274301 kg; Gross weight: 274301 kg; Weight: 274301 kg; Net volume: 130.62 m3; Gross volume: 130.62 m3; Gross footprint area: 653.098 m2; Area per tons: 4.88085 m2; Net surface area: 1338.82 m2; Gross area: 1338.82 m2; Height: 9000 mm; Width: 200 mm; Length: 72566.4 mm; sets with these values: 2
BaseQuantities - Length: 72566.4 mm; OuterSurfaceArea: 1338.82 m2; NetVolume: 130.62 m3; NetWeight: 274301 kg

# IfcBeam: PL96*3 (20)
In: Undefined
Description: PL96*3; Material: STEEL/E24-2
Tekla Common - Part mark: 1243; Phase: 4; Class: 4001; Finish: GRENAILLE-PEINT; Grade: E24-2; Profile: PL96*3; sets with these values: 2
Tekla Quantity - Net weight: 0.217037 kg; Gross weight: 0.217037 kg; Weight: 0.217037 kg; Net volume: 0.000027648 m3; Gross volume: 0.000027648 m3; Gross footprint area: 0.009216 m2; Area per tons: 90.2335 m2; Net surface area: 0.019584 m2; Gross area: 0.019584 m2; Height: 96 mm; Width: 3 mm; Length: 96 mm; sets with these values: 2
BaseQuantities - Length: 96 mm; OuterSurfaceArea: 0.019584 m2; NetVolume: 0.000027648 m3; NetWeight: 0.217037 kg
Name | Center of gravity Z (mm) | Center of gravity Y (mm) | Center of gravity X (mm) | Bottom elevation | Top elevation | Assembly mark
 | 5584.5 | 26000 | 32500 | +5.583 | +5.586 | E4
 | 5584.5 | 25500 | 32500 | +5.583 | +5.586 | E4
 | 4245.5 | 26000 | 32500 | +4.244 | +4.247 | E4
 | 4245.5 | 25500 | 32500 | +4.244 | +4.247 | E4
 | 5584.5 | 26000 | 44175 | +5.583 | +5.586 | E4
 | 5584.5 | 25500 | 44175 | +5.583 | +5.586 | E4
 | 4245.5 | 26000 | 44175 | +4.244 | +4.247 | E4
 | 4245.5 | 25500 | 44175 | +4.244 | +4.247 | E4
 | 4008.5 | 18900 | 71802 | +4.007 | +4.010 | E5
 | 4008.5 | 18400 | 71802 | +4.007 | +4.010 | E5
 | 5883.5 | 18900 | 71802 | +5.882 | +5.885 | E5
 | 5883.5 | 18400 | 71802 | +5.882 | +5.885 | E5
 | 5584.5 | 23100 | 67525 | +5.583 | +5.586 | E4
 | 5584.5 | 22600 | 67525 | +5.583 | +5.586 | E4
 | 4245.5 | 23100 | 67525 | +4.244 | +4.247 | E4
 | 4245.5 | 22600 | 67525 | +4.244 | +4.247 | E4
 | 4245.5 | 26000 | 55850 | +4.244 | +4.247 | E4
 | 5584.5 | 26000 | 55850 | +5.583 | +5.586 | E4
 | 5584.5 | 25500 | 55850 | +5.583 | +5.586 | E4
 | 4245.5 | 25500 | 55850 | +4.244 | +4.247 | E4

# IfcBeam: TUBE-168.3*4.5 (2)
In: Undefined
Description: TUBE-168.3*4.5; Material: STEEL/E24-2
Tekla Common - Center of gravity Z: 1350.17 mm; Center of gravity X: 15099.5 mm; Bottom elevation: -0.310; Top elevation: +3.011; Part mark: 1362; Assembly mark: B18; Phase: 2; Class: 2002; Finish: GRENAILLE-PEINT; Grade: E24-2; Profile: TUBE-168.3*4.5; Name: BUTON; sets with these values: 2
Tekla Quantity - Net weight: 185.727 kg; Gross weight: 185.727 kg; Weight: 185.727 kg; Net volume: 0.0236595 m3; Gross volume: 0.0236595 m3; Gross footprint area: 0 m2; Area per tons: 29.3499 m2; Net surface area: 5.45106 m2; Gross area: 5.45106 m2; Height: 168.3 mm; Width: 168.3 mm; Length: 10334.8 mm; sets with these values: 2
BaseQuantities - Length: 10334.8 mm; OuterSurfaceArea: 5.45106 m2; NetVolume: 0.0236595 m3; NetWeight: 185.727 kg
Name | Center of gravity Y (mm)
BUTON | 10942
BUTON | 48513

# IfcBeam: TUBE-C-100*100*3 (11)
In: Undefined
Description: TUBE-C-100*100*3
Tekla Common - Phase: 1; Finish: GRENAILLE-PEINT; Profile: TUBE-C-100*100*3; sets with these values: 2
Tekla Quantity - Area per tons: 43.1281 m2; Height: 100 mm; Width: 100 mm; sets with these values: 2
Name | Material | Center of gravity Z (mm) | Center of gravity Y (mm) | Center of gravity X (mm) | Bottom elevation | Top elevation | Part mark | Assembly mark | Class | Grade | Name | Net weight (kg) = NetWeight (kg) | Gross weight (kg) = Weight (kg) | Net volume (m3) = NetVolume (m3) | Gross volume (m3) | Gross footprint area (m2) | Net surface area (m2) | Gross area (m2) = OuterSurfaceArea (m2) | Tekla Quantity, Length (mm) = BaseQuantities, Length (mm)
MONTANT | STEEL/S235JR | 4479.58 | 32205 | 79185 | +3.845 | +5.114 | M12 | M12 | 1011 | S235JR | MONTANT | 11.6008 | 11.4513 | 0.00147781 | 0.00145877 | 0.001164 | 0.50904 | 0.493874 | 1269.6
BUTON | STEEL/E24-2 | 2813.55 | 12187.4 | 79279 | +2.236 | +3.391 | 973 | B17 | 1002 | E24-2 | BUTON | 24.4807 | 24.1653 | 0.00311856 | 0.00307838 | 0 | 1.07287 | 1.0422 | 2679.18
LISSE | STEEL/S235JR | 4817.58 | 37621 | 79085 | +4.768 | +4.868 | 974 | L101 | 1003 | S235JR | LISSE | 47.9531 | 47.3351 | 0.00610867 | 0.00602995 | 0.5248 | 2.1004 | 2.04147 | 5248
LISSE | STEEL/S235JR | 4817.58 | 65099.5 | 79085 | +4.768 | +4.868 | 976 | L103 | 1003 | S235JR | LISSE | 73.9124 | 72.9599 | 0.0094156 | 0.00929426 | 0.8089 | 3.2368 | 3.14662 | 8089
LISSE | STEEL/S235JR | 4817.58 | 55850 | 79085 | +4.768 | +4.868 | 975 | L102 | 1003 | S235JR | LISSE | 94.9376 | 93.7142 | 0.012094 | 0.0119381 | 1.039 | 4.1572 | 4.04171 | 10390
LISSE | STEEL/S235JR | 4817.58 | 45450 | 79085 | +4.768 | +4.868 | 975 | L102 | 1003 | S235JR | LISSE | 94.9376 | 93.7142 | 0.012094 | 0.0119381 | 1.039 | 4.1572 | 4.04171 | 10390
BUTON | STEEL/E24-2 | 4314.25 | 16500 | 79225 | +3.926 | +4.703 | 969 | B1 | 1002 | E24-2 | BUTON | 54.031 | 53.4385 | 0.00688293 | 0.00680745 | 0 | 2.36647 | 2.3047 | 5924.67
BUTON | STEEL/E24-2 | 3974.79 | 22050 | 79225 | +3.925 | +4.025 | 970 | B2 | 1002 | E24-2 | BUTON | 47.2806 | 46.6713 | 0.006023 | 0.00594539 | 0.51744 | 2.07096 | 2.01284 | 5174.4
BUTON | STEEL/E24-2 | 4479.59 | 27250 | 79225 | +3.926 | +5.033 | 971 | B3 | 1002 | E24-2 | BUTON | 48.1635 | 47.7179 | 0.00613547 | 0.00607872 | 0 | 2.10963 | 2.05798 | 5290.44
BUTON | STEEL/E24-2 | 4455.95 | 69205 | 58460.9 | +4.058 | +4.854 | 972 | B16 | 1002 | E24-2 | BUTON | 45.3746 | 44.7899 | 0.0057802 | 0.00570572 | 0 | 1.98752 | 1.9317 | 4965.81
BUTON | STEEL/E24-2 | 4455.95 | 69205 | 70135.9 | +4.058 | +4.854 | 972 | B16 | 1002 | E24-2 | BUTON | 45.3746 | 44.7899 | 0.0057802 | 0.00570572 | 0 | 1.98752 | 1.9317 | 4965.81

# IfcBeam: TUBE-C-100*100*4 (5)
In: Undefined
Description: TUBE-C-100*100*4; Material: STEEL/E24-2
Tekla Common - Phase: 4; Class: 4001; Finish: GRENAILLE-PEINT; Grade: E24-2; Profile: TUBE-C-100*100*4; Name: SUPPORT; sets with these values: 2
Tekla Quantity - Gross footprint area: 0.001536 m2; Area per tons: 32.6074 m2; Height: 100 mm; Width: 100 mm; sets with these values: 2
Name | Center of gravity Z (mm) | Center of gravity Y (mm) | Center of gravity X (mm) | Bottom elevation | Top elevation | Part mark | Assembly mark | Net weight (kg) = NetWeight (kg) | Gross weight (kg) = Weight (kg) | Net volume (m3) = NetVolume (m3) | Gross volume (m3) | Net surface area (m2) | Gross area (m2) = OuterSurfaceArea (m2) | Tekla Quantity, Length (mm) = BaseQuantities, Length (mm)
SUPPORT | 4915 | 25500 | 55850 | +4.247 | +5.583 | 1371 | E4 | 16.109 | 15.8153 | 0.0020521 | 0.00201469 | 0.536 | 0.515696 | 1336
SUPPORT | 4915 | 25500 | 44175 | +4.247 | +5.583 | 1371 | E4 | 16.109 | 15.8153 | 0.0020521 | 0.00201469 | 0.536 | 0.515696 | 1336
SUPPORT | 4915 | 25500 | 32500 | +4.247 | +5.583 | 1371 | E4 | 16.109 | 15.8153 | 0.0020521 | 0.00201469 | 0.536 | 0.515696 | 1336
SUPPORT | 4915 | 22600 | 67525 | +4.247 | +5.583 | 1371 | E4 | 16.109 | 15.8153 | 0.0020521 | 0.00201469 | 0.536 | 0.515696 | 1336
SUPPORT | 4946 | 18900 | 71802 | +4.010 | +5.882 | 1372 | E5 | 22.5718 | 22.1604 | 0.00287539 | 0.00282298 | 0.7504 | 0.722592 | 1872

# IfcBeam: TUBE-C-120*120*4 (16)
In: Undefined
Description: TUBE-C-120*120*4
Tekla Common - Profile: TUBE-C-120*120*4; sets with these values: 2
Tekla Quantity - Area per tons: 32.4743 m2; Height: 120 mm; Width: 120 mm; sets with these values: 2
Name | Material | Center of gravity Z (mm) | Center of gravity Y (mm) | Center of gravity X (mm) | Bottom elevation | Top elevation | Part mark | Assembly mark | Phase | Class | Finish | Grade | Name | Net weight (kg) = NetWeight (kg) | Gross weight (kg) = Weight (kg) | Net volume (m3) = NetVolume (m3) | Gross volume (m3) | Gross footprint area (m2) | Net surface area (m2) | Gross area (m2) = OuterSurfaceArea (m2) | Tekla Quantity, Length (mm) = BaseQuantities, Length (mm)
SOLIVE | STEEL/S235JR | 5760 | 42706.5 | 20187.5 | +5.700 | +5.820 | 880 | S1 | 2 | 2007 | GALVANISE | S235JR | SOLIVE | 16.5365 | 16.287 | 0.00210656 | 0.00207478 | 0.1362 | 0.54672 | 0.52891 | 1135
SOLIVE | STEEL/S235JR | 5760 | 37506.5 | 20187.5 | +5.700 | +5.820 | 880 | S1 | 2 | 2007 | GALVANISE | S235JR | SOLIVE | 16.5365 | 16.287 | 0.00210656 | 0.00207478 | 0.1362 | 0.54672 | 0.52891 | 1135
SOLIVE | STEEL/S235JR | 5760 | 32306.5 | 20187.5 | +5.700 | +5.820 | 880 | S1 | 2 | 2007 | GALVANISE | S235JR | SOLIVE | 16.5365 | 16.287 | 0.00210656 | 0.00207478 | 0.1362 | 0.54672 | 0.52891 | 1135
