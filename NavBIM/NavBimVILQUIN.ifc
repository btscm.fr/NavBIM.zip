Properties of the parts of a building model (IFC2X3), part 19 of 32

# IfcBeam: UPF-100*50*4 (379)
Name | Material | Center of gravity Z (mm) | Center of gravity Y (mm) | Center of gravity X (mm) | Bottom elevation | Top elevation | Part mark | Assembly mark | Phase | Class | Finish | Grade | Name | Net weight (kg) = Weight (kg) = NetWeight (kg) | Gross weight (kg) | Net volume (m3) = NetVolume (m3) | Gross volume (m3) | Gross footprint area (m2) | Area per tons (m2) | Net surface area (m2) = OuterSurfaceArea (m2) | Gross area (m2) | Width (mm) | Tekla Quantity, Length (mm) = BaseQuantities, Length (mm)
SOLIVE | STEEL/S235JR | 4315 | 33578.1 | 3029.35 | +4.265 | +4.365 | S78 | S78 | 2 | 2007 | GALVANISE | S235JR | SOLIVE | 15.3056 | 15.3056 | 0.00194976 | 0.00194976 | 0.126938 | 65.1216 | 0.996726 | 0.996726 | 50 | 2538.75
SOLIVE | STEEL/S235JR | 4315 | 30909.4 | 3029.35 | +4.265 | +4.365 | S78 | S78 | 2 | 2007 | GALVANISE | S235JR | SOLIVE | 15.3056 | 15.3056 | 0.00194976 | 0.00194976 | 0.126938 | 65.1216 | 0.996726 | 0.996726 | 50 | 2538.75
SOLIVE | STEEL/S235JR | 4315 | 28309.4 | 3029.35 | +4.265 | +4.365 | S76 | S76 | 2 | 2007 | GALVANISE | S235JR | SOLIVE | 14.4767 | 14.4767 | 0.00184416 | 0.00184416 | 0.120063 | 65.1273 | 0.942826 | 0.942826 | 50 | 2401.25
SOLIVE | STEEL/S235JR | 4315 | 25778.1 | 3029.35 | +4.265 | +4.365 | S76 | S76 | 2 | 2007 | GALVANISE | S235JR | SOLIVE | 14.4767 | 14.4767 | 0.00184416 | 0.00184416 | 0.120063 | 65.1273 | 0.942826 | 0.942826 | 50 | 2401.25
SOLIVE | STEEL/S235JR | 4315 | 23246.9 | 3029.35 | +4.265 | +4.365 | S76 | S76 | 2 | 2007 | GALVANISE | S235JR | SOLIVE | 14.4767 | 14.4767 | 0.00184416 | 0.00184416 | 0.120063 | 65.1273 | 0.942826 | 0.942826 | 50 | 2401.25
SOLIVE | STEEL/S235JR | 4315 | 20715.6 | 3029.35 | +4.265 | +4.365 | S76 | S76 | 2 | 2007 | GALVANISE | S235JR | SOLIVE | 14.4767 | 14.4767 | 0.00184416 | 0.00184416 | 0.120063 | 65.1273 | 0.942826 | 0.942826 | 50 | 2401.25
SOLIVE | STEEL/S235JR | 4315 | 18385 | 3029.35 | +4.265 | +4.365 | S77 | S77 | 2 | 2007 | GALVANISE | S235JR | SOLIVE | 12.0576 | 12.0576 | 0.001536 | 0.001536 | 0.1 | 65.1486 | 0.785536 | 0.785536 | 50 | 2000
SOLIVE | STEEL/S235JR | 4315 | 16255 | 3029.35 | +4.265 | +4.365 | S77 | S77 | 2 | 2007 | GALVANISE | S235JR | SOLIVE | 12.0576 | 12.0576 | 0.001536 | 0.001536 | 0.1 | 65.1486 | 0.785536 | 0.785536 | 50 | 2000
SOLIVE | STEEL/S235JR | 4315 | 11537.5 | 3029.35 | +4.265 | +4.365 | S55 | S55 | 2 | 2007 | GALVANISE | S235JR | SOLIVE | 17.574 | 17.574 | 0.00223872 | 0.00223872 | 0.14575 | 65.1086 | 1.14422 | 1.14422 | 50 | 2915
SOLIVE | STEEL/S235JR | 4315 | 14125 | 3029.35 | +4.265 | +4.365 | S77 | S77 | 2 | 2007 | GALVANISE | S235JR | SOLIVE | 12.0576 | 12.0576 | 0.001536 | 0.001536 | 0.1 | 65.1486 | 0.785536 | 0.785536 | 50 | 2000
SOLIVE | STEEL/S235JR | 4415 | 47590.8 | -378.979 | +4.365 | +4.465 | S43 | S43 | 2 | 2007 | GALVANISE | S235JR | SOLIVE | 21.9348 | 21.9348 | 0.00279425 | 0.00279425 | 0.181917 | 65.0913 | 1.42777 | 1.42777 | 50 | 3638.34
SOLIVE | STEEL/S235JR | 4415 | 43008.3 | -378.979 | +4.365 | +4.465 | S69 | S69 | 2 | 2007 | GALVANISE | S235JR | SOLIVE | 33.1986 | 33.1986 | 0.00422911 | 0.00422911 | 0.275333 | 65.0675 | 2.16015 | 2.16015 | 50 | 5506.66
SOLIVE | STEEL/S235JR | 4415 | 37581.2 | -378.979 | +4.365 | +4.465 | S70 | S70 | 2 | 2007 | GALVANISE | S235JR | SOLIVE | 32.1184 | 32.1184 | 0.00409152 | 0.00409152 | 0.266375 | 65.0691 | 2.08992 | 2.08992 | 50 | 5327.5
SOLIVE | STEEL/S235JR | 4415 | 32243.7 | -378.979 | +4.365 | +4.465 | S70 | S70 | 2 | 2007 | GALVANISE | S235JR | SOLIVE | 32.1184 | 32.1184 | 0.00409152 | 0.00409152 | 0.266375 | 65.0691 | 2.08992 | 2.08992 | 50 | 5327.5
SOLIVE | STEEL/S235JR | 4415 | 12632.5 | -378.979 | +4.365 | +4.465 | S48 | S48 | 2 | 2007 | GALVANISE | S235JR | SOLIVE | 30.777 | 30.777 | 0.00392064 | 0.00392064 | 0.25525 | 65.0711 | 2.0027 | 2.0027 | 50 | 5105
SOLIVE | STEEL/S235JR | 4415 | 17320 | -378.979 | +4.365 | +4.465 | S71 | S71 | 2 | 2007 | GALVANISE | S235JR | SOLIVE | 25.6224 | 25.6224 | 0.003264 | 0.003264 | 0.2125 | 65.0812 | 1.66754 | 1.66754 | 50 | 4250
SOLIVE | STEEL/S235JR | 4415 | 21981.2 | -378.979 | +4.365 | +4.465 | S72 | S72 | 2 | 2007 | GALVANISE | S235JR | SOLIVE | 30.4605 | 30.4605 | 0.00388032 | 0.00388032 | 0.252625 | 65.0717 | 1.98212 | 1.98212 | 50 | 5052.5
SOLIVE | STEEL/S235JR | 4415 | 27043.7 | -378.979 | +4.365 | +4.465 | S72 | S72 | 2 | 2007 | GALVANISE | S235JR | SOLIVE | 30.4605 | 30.4605 | 0.00388032 | 0.00388032 | 0.252625 | 65.0717 | 1.98212 | 1.98212 | 50 | 5052.5
SOLIVE | STEEL/S235JR | 4415 | 47037.7 | 2663.34 | +4.365 | +4.465 | S54 | S54 | 2 | 2007 | GALVANISE | S235JR | SOLIVE | 36.4542 | 36.4542 | 0.00464384 | 0.00464384 | 0.302333 | 65.0634 | 2.37183 | 2.37183 | 50 | 6046.67
SOLIVE | STEEL/S235JR | 4415 | 47037.7 | 8080.84 | +4.365 | +4.465 | S81 | S81 | 2 | 2007 | GALVANISE | S235JR | SOLIVE | 28.7473 | 28.7473 | 0.00366208 | 0.00366208 | 0.238417 | 65.0747 | 1.87072 | 1.87072 | 50 | 4768.33
LISSE | STEEL/E24-2 | 3686.02 | 10580.1 | 8769.74 | +3.650 | +3.700 | 1135 | L35 | 2 | 2003 | GRENAILLE-PEINT | E24-2 | LISSE | 3.36612 | 3.36612 | 0.000428805 | 0.000428805 | 0.055834 | 65.4775 | 0.220405 | 0.220405 | 4 | 558.34
CHEVETRE | STEEL/S235JR | 5042.09 | 3825 | 78771.8 | +4.991 | +5.092 | U9 | U9 | 3 | 3003 | GRENAILLE-PEINT | S235JR | CHEVETRE | 14.4088 | 14.4088 | 0.00183552 | 0.00183552 | 0 | 65.1278 | 0.938416 | 0.938416 | 50 | 2390
CHEVETRE | STEEL/S235JR | 5058.45 | 3825 | 78244.1 | +5.008 | +5.110 | U10 | U10 | 3 | 3003 | GRENAILLE-PEINT | S235JR | CHEVETRE | 14.4088 | 14.4088 | 0.00183552 | 0.00183552 | 0 | 65.1278 | 0.938416 | 0.938416 | 50 | 2390
CHEVETRE | STEEL/S235JR | 5348.99 | 1275 | 68871.8 | +5.298 | +5.399 | U10 | U10 | 3 | 3003 | GRENAILLE-PEINT | S235JR | CHEVETRE | 14.4088 | 14.4088 | 0.00183552 | 0.00183552 | 0 | 65.1278 | 0.938416 | 0.938416 | 50 | 2390
CHEVETRE | STEEL/S235JR | 5365.35 | 1275 | 68344.1 | +5.315 | +5.416 | U9 | U9 | 3 | 3003 | GRENAILLE-PEINT | S235JR | CHEVETRE | 14.4088 | 14.4088 | 0.00183552 | 0.00183552 | 0 | 65.1278 | 0.938416 | 0.938416 | 50 | 2390
CHEVETRE | STEEL/S235JR | 5050.27 | 2730.02 | 78508 | +4.993 | +5.108 | U8 | U8 | 3 | 3003 | GRENAILLE-PEINT | S235JR | CHEVETRE | 2.95409 | 2.95409 | 0.000376317 | 0.000376317 | 0 | 65.5412 | 0.193614 | 0.193614 | 50 | 489.996
CHEVETRE | STEEL/S235JR | 5050.27 | 3257.98 | 78508 | +4.993 | +5.108 | U8 | U8 | 3 | 3003 | GRENAILLE-PEINT | S235JR | CHEVETRE | 2.95409 | 2.95409 | 0.000376317 | 0.000376317 | 0 | 65.5412 | 0.193614 | 0.193614 | 50 | 489.996
CHEVETRE | STEEL/S235JR | 5357.17 | 1842.02 | 68608 | +5.300 | +5.415 | U8 | U8 | 3 | 3003 | GRENAILLE-PEINT | S235JR | CHEVETRE | 2.95409 | 2.95409 | 0.000376317 | 0.000376317 | 0 | 65.5412 | 0.193614 | 0.193614 | 50 | 489.996
CHEVETRE | STEEL/S235JR | 5357.17 | 2369.98 | 68608 | +5.300 | +5.415 | U8 | U8 | 3 | 3003 | GRENAILLE-PEINT | S235JR | CHEVETRE | 2.95409 | 2.95409 | 0.000376317 | 0.000376317 | 0 | 65.5412 | 0.193614 | 0.193614 | 50 | 489.996
CHEVETRE | STEEL/E24-2 | 3861.3 | 45479 | 3675.84 | +3.797 | +3.925 | 1145 | U6 | 2 | 2003 | GRENAILLE-PEINT | E24-2 | CHEVETRE | 4.82304 | 4.82304 | 0.0006144 | 0.0006144 | 0 | 65.3397 | 0.315136 | 0.315136 | 50 | 799.999
CHEVETRE | STEEL/E24-2 | 10454.3 | 65137.5 | 22411.9 | +10.403 | +10.505 | 1147 | U7 | 4 | 4001 | GRENAILLE-PEINT | E24-2 | CHEVETRE | 15.705 | 15.705 | 0.00200064 | 0.00200064 | 0 | 65.119 | 1.0227 | 1.0227 | 50 | 2605
CHEVETRE | STEEL/E24-2 | 10470.2 | 64844 | 21898.2 | +10.405 | +10.536 | 1148 | U7 | 4 | 4001 | GRENAILLE-PEINT | E24-2 | CHEVETRE | 6.02879 | 6.02879 | 0.000767999 | 0.000767999 | 0 | 65.276 | 0.393535 | 0.393535 | 50 | 999.998
CHEVETRE | STEEL/E24-2 | 10486.2 | 65137.5 | 21384.5 | +10.436 | +10.537 | 1147 | U7 | 4 | 4001 | GRENAILLE-PEINT | E24-2 | CHEVETRE | 15.705 | 15.705 | 0.00200064 | 0.00200064 | 0 | 65.119 | 1.0227 | 1.0227 | 50 | 2605

# IfcBeam: UPF-120*50*4 (3)
In: Undefined
Description: UPF-120*50*4; Material: STEEL/S235JR
Tekla Common - Center of gravity Z: 5937.15 mm; Center of gravity X: 71812 mm; Bottom elevation: +5.900; Top elevation: +5.950; Phase: 1; Class: 1003; Finish: GRENAILLE-PEINT; Grade: S235JR; Profile: UPF-120*50*4; Name: LISSE; sets with these values: 2
Tekla Quantity - Height: 120 mm; Width: 50 mm; sets with these values: 2
Name | Center of gravity Y (mm) | Part mark | Assembly mark | Net weight (kg) = Gross weight (kg) = Weight (kg) = NetWeight (kg) | Net volume (m3) = Gross volume (m3) = NetVolume (m3) | Gross footprint area (m2) | Area per tons (m2) | Net surface area (m2) = Gross area (m2) = OuterSurfaceArea (m2) | Tekla Quantity, Length (mm) = BaseQuantities, Length (mm)
LISSE | 24197.5 | 892 | L8 | 28.5244 | 0.00363368 | 0.5142 | 64.9555 | 1.85282 | 4285
LISSE | 19570 | 891 | L9 | 32.9512 | 0.0041976 | 0.594 | 64.9475 | 2.1401 | 4950
LISSE | 15267.5 | 890 | L10 | 24.1975 | 0.00308248 | 0.4362 | 64.9661 | 1.57202 | 3635

# IfcBeam: UPF-80*50*4 (12)
In: Undefined
Description: UPF-80*50*4; Material: STEEL/E24-2
Tekla Common - Phase: 2; Class: 2003; Finish: GRENAILLE-PEINT; Grade: E24-2; Profile: UPF-80*50*4; Name: CHEVETRE; sets with these values: 2
Tekla Quantity - Gross footprint area: 0 m2; Area per tons: 6.48052 m2; Height: 80 mm; Width: 50 mm; sets with these values: 2
Name | Center of gravity Z (mm) | Center of gravity Y (mm) | Center of gravity X (mm) | Bottom elevation | Top elevation | Part mark | Assembly mark | Net weight (kg) = NetWeight (kg) | Gross weight (kg) = Weight (kg) | Net volume (m3) = NetVolume (m3) | Gross volume (m3) | Net surface area (m2) | Gross area (m2) = OuterSurfaceArea (m2) | Tekla Quantity, Length (mm) = BaseQuantities, Length (mm)
CHEVETRE | 3330.68 | 18385 | 9872.5 | +3.290 | +3.372 | 1366 | U16 | 10.6396 | 106.396 | 0.00135536 | 0.0135536 | 0.694816 | 0.6895 | 1970
CHEVETRE | 3317.33 | 18385 | 9441.96 | +3.276 | +3.358 | 1366 | U16 | 10.6396 | 106.396 | 0.00135536 | 0.0135536 | 0.694816 | 0.6895 | 1970
CHEVETRE | 3324 | 18678.5 | 9657.23 | +3.278 | +3.370 | 1364 | U16 | 2.16032 | 21.6032 | 0.0002752 | 0.002752 | 0.142176 | 0.14 | 400
CHEVETRE | 3324 | 19109.3 | 9657.23 | +3.278 | +3.370 | 1364 | U16 | 2.16032 | 21.6032 | 0.0002752 | 0.002752 | 0.142176 | 0.14 | 400
CHEVETRE | 3330.68 | 28309.4 | 9872.5 | +3.290 | +3.372 | 1365 | U15 | 12.8066 | 128.066 | 0.00163142 | 0.0163142 | 0.836056 | 0.829937 | 2371.25
CHEVETRE | 3324 | 29134.3 | 9657.23 | +3.278 | +3.370 | 1364 | U15 | 2.16032 | 21.6032 | 0.0002752 | 0.002752 | 0.142176 | 0.14 | 400
CHEVETRE | 3317.33 | 28309.4 | 9441.96 | +3.276 | +3.358 | 1365 | U15 | 12.8066 | 128.066 | 0.00163142 | 0.0163142 | 0.836056 | 0.829937 | 2371.25
CHEVETRE | 3324 | 28703.5 | 9657.23 | +3.278 | +3.370 | 1364 | U15 | 2.16032 | 21.6032 | 0.0002752 | 0.002752 | 0.142176 | 0.14 | 400
CHEVETRE | 3324 | 39378.5 | 9657.23 | +3.278 | +3.370 | 1364 | U14 | 2.16032 | 21.6032 | 0.0002752 | 0.002752 | 0.142176 | 0.14 | 400
CHEVETRE | 3324 | 39809.3 | 9657.23 | +3.278 | +3.370 | 1364 | U14 | 2.16032 | 21.6032 | 0.0002752 | 0.002752 | 0.142176 | 0.14 | 400
CHEVETRE | 3317.33 | 38915.6 | 9441.96 | +3.276 | +3.358 | 1363 | U14 | 13.5493 | 135.493 | 0.00172602 | 0.0172602 | 0.884456 | 0.878062 | 2508.75
CHEVETRE | 3330.68 | 38915.6 | 9872.5 | +3.290 | +3.372 | 1363 | U14 | 13.5493 | 135.493 | 0.00172602 | 0.0172602 | 0.884456 | 0.878062 | 2508.75

# IfcBeam: UPN100 (12)
In: Undefined
Description: UPN100
Tekla Common - Profile: UPN100; sets with these values: 2
Tekla Quantity - Area per tons: 34.9139 m2; Height: 100 mm; Width: 50 mm; sets with these values: 2
Name | Material | Center of gravity Z (mm) | Center of gravity Y (mm) | Center of gravity X (mm) | Bottom elevation | Top elevation | Part mark | Assembly mark | Phase | Class | Finish | Grade | Name | Net weight (kg) = NetWeight (kg) | Gross weight (kg) = Weight (kg) | Net volume (m3) | Gross volume (m3) | Gross footprint area (m2) | Net surface area (m2) | Gross area (m2) = OuterSurfaceArea (m2) | Tekla Quantity, Length (mm) = BaseQuantities, Length (mm) | NetVolume (m3)
SOLIVE | STEEL/S235JR | 5800 | 29687.5 | 70885.1 | +5.750 | +5.850 | S85 | S85 | 1 | 1008 | GALVANISE | S235JR | SOLIVE | 65.131 | 65.2276 | 0.00829694 | 0.00830925 | 0.30775 | 2.39084 | 2.27735 | 6155 | 0.00829694
LISSE | STEEL/E24-2 | 4323.13 | 25770.6 | -205 | +4.290 | +4.340 | 1186 | L49 | 2 | 2003 | GRENAILLE-PEINT | E24-2 | LISSE | 80.091 | 80.2098 | 0.0102027 | 0.0102178 | 0.756875 | 2.93937 | 2.80044 | 7568.75 | 0.0102027
LISSE | STEEL/E24-2 | 4323.13 | 18585.6 | -205 | +4.290 | +4.340 | 1187 | L50 | 2 | 2003 | GRENAILLE-PEINT | E24-2 | LISSE | 71.7578 | 71.8643 | 0.00914113 | 0.00915469 | 0.678125 | 2.63382 | 2.50906 | 6781.25 | 0.00914113
LISSE | STEEL/E24-2 | 2946.87 | 25770.6 | -205 | +2.930 | +2.980 | 1186 | L49 | 2 | 2003 | GRENAILLE-PEINT | E24-2 | LISSE | 80.091 | 80.2098 | 0.0102027 | 0.0102178 | 0.128669 | 2.93937 | 2.80044 | 7568.75 | 0.0102027
LISSE | STEEL/E24-2 | 2946.87 | 18585.6 | -205 | +2.930 | +2.980 | 1187 | L50 | 2 | 2003 | GRENAILLE-PEINT | E24-2 | LISSE | 71.7578 | 71.8643 | 0.00914113 | 0.00915469 | 0.115281 | 2.63382 | 2.50906 | 6781.25 | 0.00914112
LISSE | STEEL/E24-2 | 2946.87 | 12610 | -205 | +2.930 | +2.980 | 1188 | L51 | 2 | 2003 | GRENAILLE-PEINT | E24-2 | LISSE | 54.4963 | 54.5771 | 0.0069422 | 0.0069525 | 0.08755 | 2.0009 | 1.9055 | 5150 | 0.0069422
LISSE | STEEL/E24-2 | 4323.13 | 12610 | -205 | +4.290 | +4.340 | 1188 | L51 | 2 | 2003 | GRENAILLE-PEINT | E24-2 | LISSE | 54.4963 | 54.5771 | 0.0069422 | 0.0069525 | 0.515 | 2.0009 | 1.9055 | 5150 | 0.0069422
LISSE | STEEL/E24-2 | 4323.13 | 9980 | 5132.5 | +4.290 | +4.340 | 1189 | L52 | 2 | 2003 | GRENAILLE-PEINT | E24-2 | LISSE | 114.019 | 114.188 | 0.0145247 | 0.0145463 | 1.0775 | 4.1834 | 3.98675 | 10775 | 0.0145247
LISSE | STEEL/E24-2 | 2946.87 | 9980 | 5132.5 | +2.930 | +2.980 | 1189 | L52 | 2 | 2003 | GRENAILLE-PEINT | E24-2 | LISSE | 114.019 | 114.188 | 0.0145247 | 0.0145463 | 0.183175 | 4.1834 | 3.98675 | 10775 | 0.0145247
LISSE | STEEL/E24-2 | 2946.87 | 31522.5 | -205 | +2.930 | +2.980 | 1191 | L54 | 5 | 5001 | GRENAILLE-PEINT | E24-2 | LISSE | 41.4277 | 41.4892 | 0.00527742 | 0.00528525 | 0.066555 | 1.52172 | 1.44855 | 3915 | 0.00527742
LISSE | STEEL/E24-2 | 4323.13 | 31522.5 | -205 | +4.290 | +4.340 | 1191 | L54 | 5 | 5001 | GRENAILLE-PEINT | E24-2 | LISSE | 41.4277 | 41.4892 | 0.00527742 | 0.00528525 | 0.3915 | 1.52172 | 1.44855 | 3915 | 0.00527742
LISSE | STEEL/E24-2 | 3635 | 29591.9 | -205 | +2.992 | +4.278 | 1190 | L53 | 5 | 5001 | GRENAILLE-PEINT | E24-2 | LISSE | 13.6082 | 13.6284 | 0.00173353 | 0.0017361 | 0.001348 | 0.501664 | 0.47582 | 1286 | 0.00173353

# IfcBeam: UPN120 (34)
In: Undefined
Description: UPN120
Tekla Common - Profile: UPN120; sets with these values: 2
Tekla Quantity - Area per tons: 32.2218 m2; Height: 120 mm; sets with these values: 2
Name | Material | Center of gravity Z (mm) | Center of gravity Y (mm) | Center of gravity X (mm) | Bottom elevation | Top elevation | Part mark | Assembly mark | Phase | Class | Finish | Grade | Name | Net weight (kg) = NetWeight (kg) | Gross weight (kg) = Weight (kg) | Net volume (m3) = NetVolume (m3) | Gross volume (m3) | Gross footprint area (m2) | Net surface area (m2) | Gross area (m2) = OuterSurfaceArea (m2) | Width (mm) | Tekla Quantity, Length (mm) = BaseQuantities, Length (mm)
LISSE | STEEL/E24-2 | 3300.26 | -2238.53 | 20624.9 | +3.000 | +3.600 | 1320 | L116 | 3 | 3003 | GRENAILLE-PEINT | E24-2 | LISSE | 7.56721 | 8.007 | 0.000963975 | 0.00102 | 0 | 0.257207 | 0.258 | 55 | 600
LISSE | STEEL/E24-2 | 3300 | -2314.97 | 20581.3 | +3.000 | +3.600 | 1321 | L115 | 3 | 3003 | GRENAILLE-PEINT | E24-2 | LISSE | 7.55917 | 8.007 | 0.000962952 | 0.00102 | 0 | 0.25701 | 0.258 | 55 | 600
LISSE | STEEL/E24-2 | 3017.44 | -1378.13 | 38409.6 | +3.000 | +3.055 | 1314 | L80 | 3 | 3003 | GRENAILLE-PEINT | E24-2 | LISSE | 157.846 | 157.584 | 0.0201078 | 0.0200744 | 0.212407 | 5.26639 | 5.07765 | 7 | 11808.5
LISSE | STEEL/E24-2 | 3582.56 | -1378.12 | 38409.6 | +3.545 | +3.600 | 1313 | L80 | 3 | 3003 | GRENAILLE-PEINT | E24-2 | LISSE | 157.846 | 157.584 | 0.0201078 | 0.0200744 | 1.41604 | 5.26639 | 5.07765 | 7 | 11808.5
LISSE | STEEL/E24-2 | 3582.58 | -2179.14 | 26555.5 | +3.545 | +3.600 | 1312 | L115 | 3 | 3003 | GRENAILLE-PEINT | E24-2 | LISSE | 159.86 | 159.718 | 0.0203644 | 0.0203462 | 1.4362 | 5.3343 | 5.1464 | 7 | 11968.4
LISSE | STEEL/E24-2 | 3017.42 | -2179.14 | 26555.5 | +3.000 | +3.055 | 1311 | L115 | 3 | 3003 | GRENAILLE-PEINT | E24-2 | LISSE | 159.86 | 159.718 | 0.0203644 | 0.0203462 | 0.214441 | 5.3343 | 5.1464 | 7 | 11968.4
SOLIVE | STEEL/S235JR | 5760 | 44006.5 | 20447.6 | +5.700 | +5.820 | S100 | S100 | 2 | 2007 | GALVANISE | S235JR | SOLIVE | 32.9059 | 32.8287 | 0.00419184 | 0.004182 | 0.1353 | 1.10057 | 1.0578 | 55 | 2460
SOLIVE | STEEL/S235JR | 5760 | 40106.5 | 20447.6 | +5.700 | +5.820 | S101 | S101 | 2 | 2007 | GALVANISE | S235JR | SOLIVE | 67.6846 | 67.5257 | 0.00862224 | 0.008602 | 0.2783 | 2.26017 | 2.1758 | 55 | 5060
SOLIVE | STEEL/S235JR | 5760 | 34906.5 | 20447.6 | +5.700 | +5.820 | S101 | S101 | 2 | 2007 | GALVANISE | S235JR | SOLIVE | 67.6846 | 67.5257 | 0.00862224 | 0.008602 | 0.2783 | 2.26017 | 2.1758 | 55 | 5060
SOLIVE | STEEL/S235JR | 5760 | 29706.5 | 20447.6 | +5.700 | +5.820 | S101 | S101 | 2 | 2007 | GALVANISE | S235JR | SOLIVE | 67.6846 | 67.5257 | 0.00862224 | 0.008602 | 0.2783 | 2.26017 | 2.1758 | 55 | 5060
SOLIVE | STEEL/S235JR | 5760 | 24506.5 | 20447.6 | +5.700 | +5.820 | S101 | S101 | 2 | 2007 | GALVANISE | S235JR | SOLIVE | 67.6846 | 67.5257 | 0.00862224 | 0.008602 | 0.2783 | 2.26017 | 2.1758 | 55 | 5060
SOLIVE | STEEL/S235JR | 5760 | 19570 | 20447.6 | +5.700 | +5.820 | S102 | S102 | 2 | 2007 | GALVANISE | S235JR | SOLIVE | 60.6352 | 60.4929 | 0.00772423 | 0.0077061 | 0.249315 | 2.02513 | 1.94919 | 55 | 4533
SOLIVE | STEEL/S235JR | 5760 | 14873.5 | 20447.6 | +5.700 | +5.820 | S103 | S103 | 2 | 2007 | GALVANISE | S235JR | SOLIVE | 61.2639 | 61.1201 | 0.00780432 | 0.007786 | 0.2519 | 2.04609 | 1.9694 | 55 | 4580
SOLIVE | STEEL/S235JR | 5760 | 11190 | 20447.6 | +5.700 | +5.820 | S104 | S104 | 2 | 2007 | GALVANISE | S235JR | SOLIVE | 33.5346 | 33.4559 | 0.00427193 | 0.0042619 | 0.137885 | 1.12153 | 1.07801 | 55 | 2507
SOLIVE | STEEL/S235JR | 5760 | 7411.5 | 20447.6 | +5.700 | +5.820 | S105 | S105 | 2 | 2007 | GALVANISE | S235JR | SOLIVE | 63.8054 | 63.6557 | 0.00812808 | 0.008109 | 0.26235 | 2.13083 | 2.0511 | 55 | 4770
SOLIVE | STEEL/S235JR | 5760 | 34906.5 | 19637.4 | +5.700 | +5.820 | S101 | S101 | 2 | 2007 | GALVANISE | S235JR | SOLIVE | 67.6846 | 67.5257 | 0.00862224 | 0.008602 | 0.2783 | 2.26017 | 2.1758 | 55 | 5060
SOLIVE | STEEL/S235JR | 5760 | 40106.5 | 19637.4 | +5.700 | +5.820 | S101 | S101 | 2 | 2007 | GALVANISE | S235JR | SOLIVE | 67.6846 | 67.5257 | 0.00862224 | 0.008602 | 0.2783 | 2.26017 | 2.1758 | 55 | 5060
SOLIVE | STEEL/S235JR | 5760 | 44006.5 | 19637.4 | +5.700 | +5.820 | S100 | S100 | 2 | 2007 | GALVANISE | S235JR | SOLIVE | 32.9059 | 32.8287 | 0.00419184 | 0.004182 | 0.1353 | 1.10057 | 1.0578 | 55 | 2460
SOLIVE | STEEL/S235JR | 5760 | 29706.5 | 19637.4 | +5.700 | +5.820 | S101 | S101 | 2 | 2007 | GALVANISE | S235JR | SOLIVE | 67.6846 | 67.5257 | 0.00862224 | 0.008602 | 0.2783 | 2.26017 | 2.1758 | 55 | 5060
SOLIVE | STEEL/S235JR | 5760 | 46963.3 | 20447.6 | +5.700 | +5.820 | S107 | S107 | 2 | 2007 | GALVANISE | S235JR | SOLIVE | 42.45 | 42.3504 | 0.00540764 | 0.00539495 | 0.174542 | 1.41879 | 1.36461 | 55 | 3173.5
SOLIVE | STEEL/S235JR | 5760 | 19570 | 19637.4 | +5.700 | +5.820 | S102 | S102 | 2 | 2007 | GALVANISE | S235JR | SOLIVE | 60.6352 | 60.4929 | 0.00772423 | 0.0077061 | 0.249315 | 2.02513 | 1.94919 | 55 | 4533
SOLIVE | STEEL/S235JR | 5760 | 24506.5 | 19637.4 | +5.700 | +5.820 | S101 | S101 | 2 | 2007 | GALVANISE | S235JR | SOLIVE | 67.6846 | 67.5257 | 0.00862224 | 0.008602 | 0.2783 | 2.26017 | 2.1758 | 55 | 5060
SOLIVE | STEEL/S235JR | 5760 | 2519.25 | 19637.4 | +5.700 | +5.820 | S106 | S106 | 2 | 2007 | GALVANISE | S235JR | SOLIVE | 63.3306 | 63.1819 | 0.00806759 | 0.00804865 | 0.260398 | 2.11499 | 2.03584 | 55 | 4734.5
SOLIVE | STEEL/S235JR | 5760 | 7411.5 | 19637.4 | +5.700 | +5.820 | S105 | S105 | 2 | 2007 | GALVANISE | S235JR | SOLIVE | 63.8054 | 63.6557 | 0.00812808 | 0.008109 | 0.26235 | 2.13083 | 2.0511 | 55 | 4770
SOLIVE | STEEL/S235JR | 5760 | 2519.25 | 20447.6 | +5.700 | +5.820 | S106 | S106 | 2 | 2007 | GALVANISE | S235JR | SOLIVE | 63.3306 | 63.1819 | 0.00806759 | 0.00804865 | 0.260398 | 2.11499 | 2.03584 | 55 | 4734.5
SOLIVE | STEEL/S235JR | 5760 | 46963.3 | 19637.4 | +5.700 | +5.820 | S107 | S107 | 2 | 2007 | GALVANISE | S235JR | SOLIVE | 42.45 | 42.3504 | 0.00540764 | 0.00539495 | 0.174542 | 1.41879 | 1.36461 | 55 | 3173.5
SOLIVE | STEEL/S235JR | 5760 | 48597.6 | 20042.5 | +5.700 | +5.820 | 1302 | S99 | 2 | 2007 | GALVANISE | S235JR | SOLIVE | 11.3031 | 11.2765 | 0.00143988 | 0.0014365 | 0.046475 | 0.380278 | 0.36335 | 55 | 845
SOLIVE | STEEL/S235JR | 5760 | 14873.5 | 19637.4 | +5.700 | +5.820 | S103 | S103 | 2 | 2007 | GALVANISE | S235JR | SOLIVE | 61.2639 | 61.1201 | 0.00780432 | 0.007786 | 0.2519 | 2.04609 | 1.9694 | 55 | 4580
SOLIVE | STEEL/S235JR | 5760 | 11190 | 19637.4 | +5.700 | +5.820 | S104 | S104 | 2 | 2007 | GALVANISE | S235JR | SOLIVE | 33.5346 | 33.4559 | 0.00427193 | 0.0042619 | 0.137885 | 1.12153 | 1.07801 | 55 | 2507
EMPANNON | STEEL/E24-2 | 3817.9 | 10043.4 | 4630.41 | +3.599 | +4.037 | 1301 | L52 | 2 | 2003 | GRENAILLE-PEINT | E24-2 | EMPANNON | 121.333 | 121.048 | 0.0154565 | 0.0154202 | 0 | 4.04894 | 3.9004 | 55 | 9070.69
LISSE | STEEL/E24-2 | 3017.28 | -1331.34 | 20624.9 | +3.000 | +3.055 | 1317 | L116 | 3 | 3003 | GRENAILLE-PEINT | E24-2 | LISSE | 24.245 | 24.4209 | 0.00308854 | 0.00311095 | 0.0319494 | 0.812574 | 0.786886 | 55 | 1829.97
LISSE | STEEL/E24-2 | 3582.72 | -1331.09 | 20624.9 | +3.545 | +3.600 | 1316 | L116 | 3 | 3003 | GRENAILLE-PEINT | E24-2 | LISSE | 24.2381 | 24.4222 | 0.00308766 | 0.0031111 | 0.219607 | 0.812388 | 0.786926 | 55 | 1830.06
LISSE | STEEL/E24-2 | 3582.56 | -554.959 | 44213.7 | +3.545 | +3.600 | 1315 | L80 | 3 | 3003 | GRENAILLE-PEINT | E24-2 | LISSE | 2.93938 | 3.04045 | 0.000374443 | 0.000387319 | 0.0263693 | 0.101429 | 0.0979689 | 55 | 227.835
LISSE | STEEL/E24-2 | 3300 | -1907.15 | 32551.4 | +3.055 | +3.545 | 1319 | L80 | 3 | 3003 | GRENAILLE-PEINT | E24-2 | LISSE | 6.55444 | 6.53905 | 0.00083496 | 0.000833 | 0.001704 | 0.221948 | 0.2107 | 55 | 490

# IfcBeam: UPN140 (2)
In: Undefined
Description: UPN140
Tekla Common - Phase: 1; Profile: UPN140; sets with these values: 2
Tekla Quantity - Area per tons: 30.5982 m2; Width: 60 mm; sets with these values: 2
Name | Material | Center of gravity Z (mm) | Center of gravity Y (mm) | Center of gravity X (mm) | Bottom elevation | Top elevation | Part mark | Assembly mark | Class | Finish | Grade | Name | Net weight (kg) = NetWeight (kg) | Gross weight (kg) = Weight (kg) | Net volume (m3) = NetVolume (m3) | Gross volume (m3) | Gross footprint area (m2) | Net surface area (m2) | Gross area (m2) = OuterSurfaceArea (m2) | Height (mm) | Tekla Quantity, Length (mm) = BaseQuantities, Length (mm)
EMPANNON | STEEL/E24-2 | 5481.09 | 27384.1 | 70759.2 | +5.393 | +5.570 | 1193 | K100 | 1010 | GRENAILLE-PEINT | E24-2 | EMPANNON | 30.2883 | 30.7426 | 0.00385839 | 0.00391625 | 0 | 0.961868 | 0.940668 | 140.001 | 1919.73
SOLIVE | STEEL/S235JR | 5780 | 22862.5 | 71632.9 | +5.710 | +5.850 | S86 | S86 | 1008 | GALVANISE | S235JR | SOLIVE | 119.865 | 119.865 | 0.0152694 | 0.0152694 | 0.4491 | 3.79149 | 3.66765 | 140 | 7485

# IfcBeam: UPN160 (17)
In: Undefined
Description: UPN160
Tekla Common - Profile: UPN160; sets with these values: 2
Tekla Quantity - Area per tons: 29.1932 m2; Height: 160 mm; Width: 65 mm; sets with these values: 2
Name | Material | Center of gravity Z (mm) | Center of gravity Y (mm) | Center of gravity X (mm) | Bottom elevation | Top elevation | Part mark | Assembly mark | Phase | Class | Finish | Grade | Name | Net weight (kg) = NetWeight (kg) | Gross weight (kg) = Weight (kg) | Net volume (m3) = NetVolume (m3) | Gross volume (m3) | Gross footprint area (m2) | Net surface area (m2) | Gross area (m2) = OuterSurfaceArea (m2) | Tekla Quantity, Length (mm) = BaseQuantities, Length (mm)
MONTANT | STEEL/E24-2 | 3235.5 | 19620 | 74355.1 | +3.077 | +3.394 | 1296 | M15 | 7 | 7001 | GRENAILLE-PEINT | E24-2 | MONTANT | 5.99094 | 5.97228 | 0.000763177 | 0.0007608 | 0.0024075 | 0.18392 | 0.17435 | 317
LINTEAU | STEEL/E24-2 | 3420.05 | 19620 | 76212 | +3.400 | +3.465 | 1293 | L114 | 7 | 7001 | GRENAILLE-PEINT | E24-2 | LINTEAU | 70.9464 | 70.7254 | 0.00903775 | 0.0090096 | 0.078834 | 2.12582 | 2.0647 | 3754
EMPANNON | STEEL/E24-2 | 4317.88 | 49774.9 | 32525 | +4.237 | +4.399 | 1289 | N43 | 3 | 3003 | GRENAILLE-PEINT | E24-2 | EMPANNON | 3.05691 | 3.04738 | 0.000389415 | 0.000388202 | 0.0024075 | 0.0962041 | 0.0889629 | 161.751
MONTANT | STEEL/E24-2 | 1397 | -145 | 22546.9 | -0.200 | +2.994 | 1295 | M16 | 3 | 3003 | GRENAILLE-PEINT | E24-2 | MONTANT | 60.363 | 60.175 | 0.00768955 | 0.0076656 | 0.0024075 | 1.80943 | 1.7567 | 3194
LINTEAU | STEEL/E24-2 | 3019.95 | -144.271 | 30579 | +3.000 | +3.065 | L112 | L112 | 3 | 3003 | GRENAILLE-PEINT | E24-2 | LINTEAU | 71.8994 | 72.3833 | 0.00915916 | 0.0092208 | 0.079422 | 2.15694 | 2.1131 | 3842
SOLIVE | STEEL/S235JR | 7285 | 68037.5 | 19780.1 | +7.205 | +7.365 | 1286 | S94 | 2 | 2007 | GALVANISE | S235JR | SOLIVE | 46.5858 | 46.4406 | 0.00593449 | 0.00591601 | 0.160225 | 1.39754 | 1.35575 | 2465
SOLIVE | STEEL/S235JR | 7285 | 66740.1 | 23692.5 | +7.205 | +7.365 | 1285 | S92 | 2 | 2007 | GALVANISE | S235JR | SOLIVE | 147.884 | 147.423 | 0.0188387 | 0.01878 | 0.508625 | 4.42594 | 4.30375 | 7825
SOLIVE | STEEL/S235JR | 7285 | 69335 | 23692.5 | +7.205 | +7.365 | 1285 | S91 | 2 | 2007 | GALVANISE | S235JR | SOLIVE | 147.884 | 147.423 | 0.0188387 | 0.01878 | 0.508625 | 4.42594 | 4.30375 | 7825
SOLIVE | STEEL/S235JR | 7645 | 66740.1 | 30175 | +7.565 | +7.725 | 1284 | S90 | 2 | 2007 | GALVANISE | S235JR | SOLIVE | 95.6283 | 95.3304 | 0.012182 | 0.012144 | 0.3289 | 2.86372 | 2.783 | 5060
SOLIVE | STEEL/S235JR | 7645 | 69335 | 30175 | +7.565 | +7.725 | 1284 | S89 | 2 | 2007 | GALVANISE | S235JR | SOLIVE | 95.6283 | 95.3304 | 0.0121819 | 0.012144 | 0.3289 | 2.86371 | 2.783 | 5060
SOLIVE | STEEL/S235JR | 7645 | 68037.5 | 32704.9 | +7.565 | +7.725 | 1286 | S93 | 2 | 2007 | GALVANISE | S235JR | SOLIVE | 46.5857 | 46.4406 | 0.00593449 | 0.005916 | 0.160225 | 1.39754 | 1.35575 | 2465
LINTEAU | STEEL/E24-2 | 3020 | -144.632 | 22816.7 | +3.000 | +3.065 | L111 | L111 | 3 | 3003 | GRENAILLE-PEINT | E24-2 | LINTEAU | 71.1205 | 71.2529 | 0.00905994 | 0.0090768 | 0.078792 | 2.13234 | 2.0801 | 3782
EMPANNON | STEEL/S235JR | 10304.9 | 66499.9 | 26265 | +10.025 | +10.584 | 1281 | K103 | 2 | 2005 | GRENAILLE-PEINT | S235JR | EMPANNON | 243.44 | 242.682 | 0.0310115 | 0.0309149 | 0 | 7.2827 | 7.08466 | 12881.2
EMPANNON | STEEL/S235JR | 10216.2 | 49940.1 | 29125 | +10.025 | +10.407 | 1282 | K104 | 2 | 2005 | GRENAILLE-PEINT | S235JR | EMPANNON | 135.287 | 134.865 | 0.017234 | 0.0171803 | 0 | 4.04934 | 3.93715 | 7158.46
EMPANNON | STEEL/S235JR | 10416.4 | 49990.1 | 22667.5 | +10.248 | +10.584 | 1283 | K105 | 2 | 2005 | GRENAILLE-PEINT | S235JR | EMPANNON | 107.398 | 107.063 | 0.0136812 | 0.0136386 | 0 | 3.21557 | 3.12551 | 5682.75
LINTEAU | STEEL/E24-2 | 3019.95 | -144.271 | 26687.5 | +3.000 | +3.065 | L112 | L112 | 3 | 3003 | GRENAILLE-PEINT | E24-2 | LINTEAU | 71.8805 | 72.3644 | 0.00915676 | 0.0092184 | 0.079401 | 2.15638 | 2.11255 | 3841
LINTEAU | STEEL/E24-2 | 3020.05 | 19620 | 76212 | +3.000 | +3.065 | 1292 | L113 | 7 | 7001 | GRENAILLE-PEINT | E24-2 | LINTEAU | 70.9464 | 70.7254 | 0.00903775 | 0.0090096 | 0.078834 | 2.12582 | 2.0647 | 3754

# IfcBeam: UPN180 (13)
In: Undefined
Description: UPN180; Material: STEEL/E24-2
Tekla Common - Finish: GRENAILLE-PEINT; Grade: E24-2; Profile: UPN180; sets with these values: 2
Tekla Quantity - Area per tons: 27.7525 m2; Height: 180 mm; Width: 70 mm; sets with these values: 2
Name | Center of gravity Z (mm) | Center of gravity Y (mm) | Center of gravity X (mm) | Bottom elevation | Top elevation | Part mark | Assembly mark | Phase | Class | Name | Net weight (kg) = NetWeight (kg) | Gross weight (kg) = Weight (kg) | Net volume (m3) = NetVolume (m3) | Gross volume (m3) | Gross footprint area (m2) | Net surface area (m2) | Gross area (m2) = OuterSurfaceArea (m2) | Tekla Quantity, Length (mm) = BaseQuantities, Length (mm)
EMPANNON | 4591.99 | 49779 | 30153.5 | +4.222 | +4.962 | 999 | K93 | 3 | 3003 | EMPANNON | 101.273 | 101.612 | 0.012901 | 0.0129442 | 0 | 2.87664 | 2.81998 | 4622.93
LINTEAU | 2421.03 | 69285 | 58816.3 | +2.400 | +2.470 | L30 | L30 | 1 | 1003 | LINTEAU | 124.857 | 124.679 | 0.0159054 | 0.0158827 | 0.124793 | 3.54519 | 3.46016 | 5672.4
POTEAUX | 1172 | 69285 | 57514 | -0.050 | +2.394 | 1010 | P47 | 1 | 1003 | POTEAUX | 53.7959 | 53.7191 | 0.00685298 | 0.0068432 | 0.002804 | 1.53066 | 1.49084 | 2444
LINTEAU | 2421.03 | -135 | 58804.8 | +2.400 | +2.470 | L29 | L29 | 1 | 1003 | LINTEAU | 124.35 | 124.173 | 0.0158408 | 0.0158182 | 0.124286 | 3.5308 | 3.4461 | 5649.35
ATTACHE | 4982.06 | 13535 | 79114 | +4.902 | +5.062 | H50 | H50 | 1 | 1010 | ATTACHE | 3.52182 | 3.5168 | 0.00044864 | 0.000448 | 0.002804 | 0.105448 | 0.0976 | 160
POTEAUX | 1172 | 69285 | 60156 | -0.050 | +2.394 | 1010 | P46 | 1 | 1003 | POTEAUX | 53.7959 | 53.7191 | 0.00685298 | 0.0068432 | 0.002804 | 1.53066 | 1.49084 | 2444
LINTEAU | 2421.03 | 62787.5 | 79245 | +2.400 | +2.470 | 1003 | L28 | 1 | 1003 | LINTEAU | 73.8482 | 73.7429 | 0.00940742 | 0.009394 | 0.07381 | 2.09913 | 2.04655 | 3355
LINTEAU | 3533.03 | 69285 | 70491.3 | +3.512 | +3.582 | L31 | L31 | 1 | 1003 | LINTEAU | 124.857 | 124.679 | 0.0159054 | 0.0158827 | 0.124793 | 3.54519 | 3.46016 | 5672.4
POTEAUX | 1758 | 69285 | 70064 | +0.010 | +3.506 | 1005 | P42 | 1 | 1003 | POTEAUX | 76.9519 | 76.8421 | 0.00980278 | 0.0097888 | 0.002804 | 2.18711 | 2.13256 | 3496
POTEAUX | 1758 | 69285 | 71506 | +0.010 | +3.506 | 1005 | P43 | 1 | 1003 | POTEAUX | 76.9519 | 76.8421 | 0.00980278 | 0.0097888 | 0.002804 | 2.18711 | 2.13256 | 3496
LINTEAU | 2421.03 | 69285 | 70785 | +2.400 | +2.470 | 1000 | L25 | 1 | 1003 | LINTEAU | 30.5518 | 30.5082 | 0.00389195 | 0.0038864 | 0.030536 | 0.87172 | 0.84668 | 1388
LINTEAU | 2421.03 | 65607 | 79245 | +2.400 | +2.470 | 1001 | L26 | 1 | 1003 | LINTEAU | 44.9913 | 44.9271 | 0.00573138 | 0.0057232 | 0.044968 | 1.28106 | 1.24684 | 2044
LINTEAU | 2421.03 | 60470.5 | 79245 | +2.400 | +2.470 | 1002 | L27 | 1 | 1003 | LINTEAU | 22.8698 | 22.8372 | 0.00291336 | 0.0029092 | 0.022858 | 0.653944 | 0.63379 | 1039

# IfcBeam: UPN200 (7)
In: Undefined
Description: UPN200; Material: STEEL/E24-2
Tekla Common - Finish: GRENAILLE-PEINT; Grade: E24-2; Profile: UPN200; sets with these values: 2
Tekla Quantity - Area per tons: 26.1107 m2; Height: 200 mm; sets with these values: 2
Name | Center of gravity Z (mm) | Center of gravity Y (mm) | Center of gravity X (mm) | Bottom elevation | Top elevation | Part mark | Assembly mark | Phase | Class | Name | Net weight (kg) = NetWeight (kg) | Gross weight (kg) = Weight (kg) | Net volume (m3) = NetVolume (m3) | Gross volume (m3) | Gross footprint area (m2) | Net surface area (m2) | Gross area (m2) = OuterSurfaceArea (m2) | Width (mm) | Tekla Quantity, Length (mm) = BaseQuantities, Length (mm)
LISSE | 2952.01 | 12752.1 | 7637.3 | +2.930 | +3.005 | 363 | L35 | 2 | 2003 | LISSE | 138.255 | 137.852 | 0.0176121 | 0.0175608 | 0.125431 | 3.73124 | 3.59941 | 8.5 | 5453.65
LISSE | 2952.01 | 17325.3 | 5540.83 | +2.930 | +3.005 | 364 | L36 | 2 | 2003 | LISSE | 116.084 | 115.744 | 0.0147877 | 0.0147445 | 0.105316 | 3.1339 | 3.02216 | 8.5 | 4579.03
LISSE | 2952.01 | 21985.8 | 4022.19 | +2.930 | +3.005 | 365 | L34 | 2 | 2003 | LISSE | 131.683 | 131.299 | 0.0167749 | 0.016726 | 0.119468 | 3.55418 | 3.4283 | 8.5 | 5194.4
LISSE | 2952.01 | 32246.5 | 2537.85 | +2.930 | +3.005 | 367 | L33 | 2 | 2003 | LISSE | 135.061 | 134.667 | 0.0172052 | 0.017155 | 0.122533 | 3.64517 | 3.51624 | 8.5 | 5327.63
LISSE | 2952.01 | 27039.5 | 2982.42 | +2.930 | +3.005 | 366 | L37 | 2 | 2003 | LISSE | 129.201 | 128.824 | 0.0164587 | 0.0164107 | 0.117217 | 3.48731 | 3.36368 | 8.5 | 5096.49
EMPANNON | 5273.57 | 19255.5 | 69691.5 | +5.110 | +5.437 | K90 | K90 | 1 | 1010 | EMPANNON | 104.321 | 104.171 | 0.0132893 | 0.0132702 | 0 | 2.81699 | 2.71998 | 75 | 4121.18
EMPANNON | 5092.82 | 13423 | 75521.9 | +4.875 | +5.311 | 362 | K56 | 1 | 1010 | EMPANNON | 193.269 | 192.701 | 0.0246203 | 0.0245479 | 0 | 5.21335 | 5.03155 | 75 | 7623.56

# IfcBeam: UPN220, EMPANNON
In: Undefined
Description: UPN220; Material: STEEL/E24-2
Tekla Common - Center of gravity Z: 5300.42 mm; Center of gravity Y: 27378.4 mm; Center of gravity X: 71814.7 mm; Bottom elevation: +5.078; Top elevation: +5.525; Part mark: 1202; Assembly mark: K100; Phase: 1; Class: 1010; Finish: GRENAILLE-PEINT; Grade: E24-2; Profile: UPN220; Name: EMPANNON; sets with these values: 2
Tekla Quantity - Net weight: 13.1122 kg; Gross weight: 13.1244 kg; Weight: 13.1244 kg; Net volume: 0.00167035 m3; Gross volume: 0.0016719 m3; Gross footprint area: 0 m2; Area per tons: 24.524 m2; Net surface area: 0.337576 m2; Gross area: 0.321863 m2; Height: 220 mm; Width: 80 mm; Length: 447.032 mm; sets with these values: 2
BaseQuantities - Length: 447.032 mm; OuterSurfaceArea: 0.321863 m2; NetVolume: 0.00167035 m3; NetWeight: 13.1122 kg

# IfcBeam: UPN260 (10)
In: Undefined
Description: UPN260
Tekla Common - Finish: GRENAILLE-PEINT; Profile: UPN260; sets with these values: 2
Tekla Quantity - Area per tons: 21.8908 m2; Height: 260 mm; Width: 90 mm; sets with these values: 2
Name | Material | Center of gravity Z (mm) | Center of gravity Y (mm) | Center of gravity X (mm) | Bottom elevation | Top elevation | Part mark | Assembly mark | Phase | Class | Grade | Name | Net weight (kg) = NetWeight (kg) | Gross weight (kg) = Weight (kg) | Net volume (m3) = NetVolume (m3) | Gross volume (m3) | Gross footprint area (m2) | Net surface area (m2) | Gross area (m2) = OuterSurfaceArea (m2) | Tekla Quantity, Length (mm) = BaseQuantities, Length (mm)
POUTRES | STEEL/E24-2 | 4984.38 | 27250 | 79109.2 | +4.854 | +5.114 | N31 | N31 | 1 | 1011 | E24-2 | POUTRES | 197.265 | 196.857 | 0.0251293 | 0.0250774 | 0.46728 | 4.4748 | 4.30936 | 5192
POUTRES | STEEL/E24-2 | 3402.96 | 19066.5 | 79109.2 | +3.273 | +3.533 | N23 | N23 | 1 | 1011 | E24-2 | POUTRES | 423.975 | 423.099 | 0.0540096 | 0.053898 | 1.00431 | 9.60642 | 9.26197 | 11159
POUTRES | STEEL/E24-2 | 3402.96 | 27279 | 79109.2 | +3.273 | +3.533 | N24 | N24 | 1 | 1011 | E24-2 | POUTRES | 199.469 | 199.056 | 0.02541 | 0.0253575 | 0.4725 | 4.52468 | 4.3575 | 5250
POUTRES | STEEL/E24-2 | 4653.72 | 3780.5 | 79109.2 | +4.524 | +4.784 | N25 | N25 | 1 | 1011 | E24-2 | POUTRES | 293.732 | 293.125 | 0.037418 | 0.0373407 | 0.69579 | 6.65834 | 6.41673 | 7731
POUTRES | STEEL/E24-2 | 4653.72 | 10629 | 79109.2 | +4.524 | +4.784 | N26 | N26 | 1 | 1011 | E24-2 | POUTRES | 226.064 | 225.597 | 0.028798 | 0.0287385 | 0.5355 | 5.12668 | 4.9385 | 5950
POUTRES | STEEL/E24-2 | 3974.79 | 36200.5 | 79109.2 | +3.845 | +4.105 | N27 | N27 | 1 | 1011 | E24-2 | POUTRES | 307.409 | 306.774 | 0.0391604 | 0.0390795 | 0.72819 | 6.96794 | 6.71553 | 8091
POUTRES | STEEL/E24-2 | 3974.79 | 45450 | 79109.2 | +3.845 | +4.105 | N28 | N28 | 1 | 1011 | E24-2 | POUTRES | 394.834 | 394.018 | 0.0502973 | 0.0501934 | 0.93528 | 8.9468 | 8.62536 | 10392
POUTRES | STEEL/E24-2 | 3974.79 | 55850 | 79109.2 | +3.845 | +4.105 | N29 | N29 | 1 | 1011 | E24-2 | POUTRES | 394.834 | 394.018 | 0.0502973 | 0.0501934 | 0.93528 | 8.9468 | 8.62536 | 10392
POUTRES | STEEL/E24-2 | 3974.79 | 65144.5 | 79109.2 | +3.845 | +4.105 | N30 | N30 | 1 | 1011 | E24-2 | POUTRES | 310.829 | 310.187 | 0.039596 | 0.0395142 | 0.73629 | 7.04534 | 6.79023 | 8181
SUPPORT | STEEL/S235JR | 3877.32 | 29549.2 | -129.65 | +3.747 | +4.007 | 455 | L53 | 5 | 5001 | S235JR | SUPPORT | 8.76522 | 8.74711 | 0.00111659 | 0.00111428 | 0.020763 | 0.208082 | 0.191481 | 230.7

# IfcBeam: UPN300, POUTRES
In: Undefined
Description: UPN300; Material: STEEL/E24-2
Tekla Common - Center of gravity Z: 4965.59 mm; Center of gravity Y: 32455.9 mm; Center of gravity X: 79105.6 mm; Bottom elevation: +4.814; Top elevation: +5.114; Part mark: 1160; Assembly mark: N37; Phase: 1; Class: 1011; Finish: GRENAILLE-PEINT; Grade: E24-2; Profile: UPN300; Name: POUTRES; sets with these values: 2
Tekla Quantity - Net weight: 240.162 kg; Gross weight: 242.329 kg; Weight: 242.329 kg; Net volume: 0.0305939 m3; Gross volume: 0.03087 m3; Gross footprint area: 0.525 m2; Area per tons: 20.5815 m2; Net surface area: 5.11548 m2; Gross area: 4.9875 m2; Height: 300 mm; Width: 100 mm; Length: 5250 mm; sets with these values: 2
BaseQuantities - Length: 5250 mm; OuterSurfaceArea: 4.9875 m2; NetVolume: 0.0305939 m3; NetWeight: 240.162 kg

# IfcColumn: BLU300*80*5 (4)
In: Undefined
Description: BLU300*80*5; Material: STEEL/E24-2
Tekla Common - Center of gravity Y: -75 mm; Bottom elevation: -0.200; Phase: 1; Class: 1003; Finish: GRENAILLE-PEINT; Grade: E24-2; Profile: BLU300*80*5; Name: POTEAUX; sets with these values: 2
Tekla Quantity - Gross footprint area: 0.00225 m2; Height: 300 mm; Width: 80 mm; sets with these values: 2
Name | Center of gravity Z (mm) | Center of gravity X (mm) | Top elevation | Part mark | Assembly mark | Net weight (kg) = Gross weight (kg) = Weight (kg) = NetWeight (kg) | Net volume (m3) = Gross volume (m3) = NetVolume (m3) | Area per tons (m2) | Net surface area (m2) = Gross area (m2) = OuterSurfaceArea (m2) | Tekla Quantity, Length (mm) = BaseQuantities, Length (mm)
POTEAUX | 2349.55 | 73815.8 | +4.899 | 884 | P110 | 90.063 | 0.011473 | 51.5716 | 4.64469 | 5099.11
POTEAUX | 2338.2 | 70984.2 | +4.876 | 885 | P109 | 89.6619 | 0.0114219 | 51.5718 | 4.62402 | 5076.4
POTEAUX | 2333.51 | 74819.2 | +4.867 | 886 | P111 | 89.4962 | 0.0114008 | 51.5719 | 4.61549 | 5067.02
POTEAUX | 2289.26 | 78350.8 | +4.779 | 887 | P112 | 87.9331 | 0.0112017 | 51.5728 | 4.53495 | 4978.52

# IfcColumn: HEA100 (10)
In: Undefined
Description: HEA100; Material: STEEL/E24-2
Tekla Common - Finish: GRENAILLE-PEINT; Grade: E24-2; Profile: HEA100; sets with these values: 2
Tekla Quantity - Area per tons: 33.7099 m2; Width: 100 mm; sets with these values: 2
Name | Center of gravity Z (mm) | Center of gravity Y (mm) | Center of gravity X (mm) | Bottom elevation | Top elevation | Part mark | Assembly mark | Phase | Class | Name | Net weight (kg) = NetWeight (kg) | Gross weight (kg) = Weight (kg) | Net volume (m3) = NetVolume (m3) | Gross volume (m3) | Gross footprint area (m2) | Net surface area (m2) | Gross area (m2) = OuterSurfaceArea (m2) | Height (mm) | Tekla Quantity, Length (mm) = BaseQuantities, Length (mm)
SUPPORT | 3876.28 | 24650 | 54492.7 | +3.500 | +4.258 | 1323 | E6 | 4 | 4001 | SUPPORT | 11.8145 | 12.621 | 0.00150504 | 0.00160777 | 0 | 0.44198 | 0.425452 | 96 | 758.381
SUPPORT | 4359.4 | 24650 | 58256.9 | +3.500 | +5.225 | 1324 | E7 | 4 | 4001 | SUPPORT | 26.9848 | 28.7015 | 0.00343756 | 0.00365624 | 0 | 1.00434 | 0.967523 | 96 | 1724.64
ATTACHE | 3170 | 10851.3 | 8643.56 | +3.020 | +3.320 | H79 | H79 | 2 | 2003 | ATTACHE | 2.68469 | 4.99258 | 0.000341998 | 0.000635997 | 0.00114 | 0.10788 | 0.168299 | 76 | 299.999
ATTACHE | 3170 | 17234.9 | 5533.77 | +3.020 | +3.320 | H79 | H79 | 2 | 2003 | ATTACHE | 2.68469 | 4.99258 | 0.000341998 | 0.000635997 | 0.00114 | 0.10788 | 0.168299 | 76 | 299.999
ATTACHE | 3170 | 32152.2 | 2493.87 | +3.020 | +3.320 | H79 | H79 | 2 | 2003 | ATTACHE | 2.68469 | 4.99258 | 0.000341998 | 0.000635997 | 0.00114 | 0.10788 | 0.168299 | 76 | 299.999
ATTACHE | 3170 | 26953.4 | 2950.29 | +3.020 | +3.320 | H79 | H79 | 2 | 2003 | ATTACHE | 2.68469 | 4.99258 | 0.000341998 | 0.000635997 | 0.00114 | 0.10788 | 0.168299 | 76 | 299.999
ATTACHE | 3170 | 21893 | 4000.23 | +3.020 | +3.320 | H79 | H79 | 2 | 2003 | ATTACHE | 2.68469 | 4.99258 | 0.000341998 | 0.000635997 | 0.00114 | 0.10788 | 0.168299 | 76 | 299.999
ATTACHE | 3170 | 12978.8 | 7464.74 | +3.020 | +3.320 | H79 | H79 | 2 | 2003 | ATTACHE | 2.68469 | 4.99258 | 0.000341998 | 0.000635997 | 0.00114 | 0.10788 | 0.168299 | 76 | 299.999
SUPPORT | 4359.4 | 27250 | 58256.9 | +3.500 | +5.225 | 1324 | E7 | 4 | 4001 | SUPPORT | 26.9848 | 28.7015 | 0.00343756 | 0.00365624 | 0 | 1.00434 | 0.967523 | 96 | 1724.64
SUPPORT | 3876.28 | 27250 | 54492.7 | +3.500 | +4.258 | 1323 | E6 | 4 | 4001 | SUPPORT | 11.8145 | 12.621 | 0.00150504 | 0.00160777 | 0 | 0.44198 | 0.425452 | 96 | 758.381

# IfcColumn: HEA120, MONTANT
In: Undefined
Description: HEA120; Material: STEEL/E24-2
Tekla Common - Center of gravity Z: 4859.57 mm; Center of gravity Y: 13502 mm; Center of gravity X: 75520 mm; Bottom elevation: +3.893; Top elevation: +5.824; Part mark: 579; Assembly mark: M5; Phase: 1; Class: 1007; Finish: GRENAILLE-PEINT; Grade: E24-2; Profile: HEA120; Name: MONTANT; sets with these values: 2
Tekla Quantity - Net weight: 36.4909 kg; Gross weight: 38.3297 kg; Weight: 38.3297 kg; Net volume: 0.00464853 m3; Gross volume: 0.00488277 m3; Gross footprint area: 0.00241 m2; Area per tons: 33.5975 m2; Net surface area: 1.35116 m2; Gross area: 1.28778 m2; Height: 114 mm; Width: 120 mm; Length: 1930.71 mm; sets with these values: 2
BaseQuantities - Length: 1930.71 mm; OuterSurfaceArea: 1.28778 m2; NetVolume: 0.00464853 m3; NetWeight: 36.4909 kg

# IfcColumn: HEA140 (6)
In: Undefined
Description: HEA140; Material: STEEL/E24-2
Tekla Common - Center of gravity Y: -158.5 mm; Finish: GRENAILLE-PEINT; Grade: E24-2; Profile: HEA140; Name: ATTACHE; sets with these values: 2
Tekla Quantity - Gross footprint area: 0.003018 m2; Area per tons: 32.2123 m2; Height: 133 mm; Width: 140 mm; sets with these values: 2
Name | BaseQuantities, Length (mm) = Tekla Quantity, Length (mm) | OuterSurfaceArea (m2) = Gross area (m2) | NetVolume (m3) = Net volume (m3) | NetWeight (kg) = Net weight (kg) | Center of gravity Z (mm) | Center of gravity X (mm) | Bottom elevation | Top elevation | Part mark | Assembly mark | Phase | Class | Gross weight (kg) = Weight (kg) | Gross volume (m3) | Net surface area (m2)
ATTACHE | 1215.43 | 0.965051 | 0.00366817 | 28.7951 | 5357.28 | 38362.5 | +4.750 | +5.965 | 869 | P114 | 3 | 3001 | 29.9591 | 0.00381645 | 0.996611
ATTACHE | 1215.43 | 0.965051 | 0.00366817 | 28.7951 | 5357.28 | 61712.5 | +4.750 | +5.965 | 873 | P116 | 1 | 1001 | 29.9591 | 0.00381645 | 0.996611
ATTACHE | 1003.37 | 0.796676 | 0.00302817 | 23.7711 | 5373.31 | 74420 | +4.872 | +5.875 | 872 | P117 | 1 | 1001 | 24.7321 | 0.00315058 | 0.823783
ATTACHE | 1215.43 | 0.965051 | 0.00366817 | 28.7951 | 5357.28 | 50037.5 | +4.750 | +5.965 | 873 | P115 | 1 | 1001 | 29.9591 | 0.00381645 | 0.996611
ATTACHE | 1453.06 | 1.15373 | 0.00438534 | 34.4249 | 5238.47 | 28633 | +4.512 | +5.965 | 870 | P121 | 3 | 3001 | 35.8165 | 0.00456261 | 1.19028
ATTACHE | 977.8 | 0.776373 | 0.002951 | 23.1654 | 5476.1 | 24742 | +4.987 | +5.965 | 871 | P120 | 3 | 3001 | 24.1018 | 0.00307029 | 0.802943

# IfcColumn: HEA180 (9)
In: Undefined
Description: HEA180; Material: STEEL/E24-2
Tekla Common - Bottom elevation: -0.388; Phase: 2; Finish: GRENAILLE-PEINT; Grade: E24-2; Profile: HEA180; Name: POTEAUX; sets with these values: 2
Tekla Quantity - Gross footprint area: 0.004332 m2; Area per tons: 28.6835 m2; Height: 171 mm; Width: 180 mm; sets with these values: 2
Name | Center of gravity Z (mm) | Center of gravity Y (mm) | Center of gravity X (mm) | Top elevation | Part mark | Assembly mark | Class | Net weight (kg) = NetWeight (kg) | Gross weight (kg) = Weight (kg) | Net volume (m3) = NetVolume (m3) | Gross volume (m3) | Net surface area (m2) | Gross area (m2) = OuterSurfaceArea (m2) | Tekla Quantity, Length (mm) = BaseQuantities, Length (mm)
POTEAUX | 1626 | 10215 | 8810 | +3.640 | 382 | P130 | 2003 | 136.977 | 143.238 | 0.0174493 | 0.0182468 | 4.23806 | 4.10856 | 4028
POTEAUX | 1620 | 18560 | 1.37063e-14 | +3.628 | 384 | P125 | 2001 | 136.569 | 142.811 | 0.0173973 | 0.0181925 | 4.22546 | 4.09632 | 4016
POTEAUX | 1407.34 | 10930 | 9295 | +3.203 | 380 | P129 | 2001 | 122.105 | 127.686 | 0.0155548 | 0.0162657 | 3.77887 | 3.66248 | 3590.67
POTEAUX | 1407.34 | 48525 | 9295 | +3.203 | 379 | P128 | 2001 | 122.105 | 127.686 | 0.0155548 | 0.0162657 | 3.77887 | 3.66248 | 3590.67
POTEAUX | 1620 | 10930 | 1.37046e-14 | +3.628 | 384 | P125 | 2001 | 136.569 | 142.811 | 0.0173973 | 0.0181925 | 4.22546 | 4.09632 | 4016
POTEAUX | 1770 | 10215 | 720 | +3.928 | 383 | P131 | 2003 | 146.771 | 153.479 | 0.0186969 | 0.0195515 | 4.54046 | 4.40232 | 4316
POTEAUX | 1620 | 48525 | 1.37461e-14 | +3.628 | 378 | P127 | 2001 | 136.569 | 142.811 | 0.0173973 | 0.0181925 | 4.22546 | 4.09632 | 4016
POTEAUX | 1620 | 26100 | 1.37025e-14 | +3.628 | 384 | P125 | 2001 | 136.569 | 142.811 | 0.0173973 | 0.0181925 | 4.22546 | 4.09632 | 4016
POTEAUX | 1620 | 40250 | 1.37433e-14 | +3.628 | 377 | P126 | 2001 | 136.569 | 142.811 | 0.0173973 | 0.0181925 | 4.22546 | 4.09632 | 4016

# IfcColumn: HEA200 (3)
In: Undefined
Description: HEA200; Material: STEEL/E24-2
Tekla Common - Center of gravity Z: 1407.34 mm; Center of gravity X: 9295 mm; Bottom elevation: -0.388; Top elevation: +3.203; Part mark: 376; Assembly mark: P124; Phase: 2; Class: 2001; Finish: GRENAILLE-PEINT; Grade: E24-2; Profile: HEA200; Name: POTEAUX; sets with these values: 2
Tekla Quantity - Net weight: 143.893 kg; Gross weight: 151.645 kg; Weight: 151.645 kg; Net volume: 0.0183304 m3; Gross volume: 0.0193178 m3; Gross footprint area: 0.005105 m2; Area per tons: 26.9931 m2; Net surface area: 4.20052 m2; Gross area: 4.09336 m2; Height: 190 mm; Width: 200 mm; Length: 3590.67 mm; sets with these values: 2
BaseQuantities - Length: 3590.67 mm; OuterSurfaceArea: 4.09336 m2; NetVolume: 0.0183304 m3; NetWeight: 143.893 kg
Name | Center of gravity Y (mm)
POTEAUX | 29575
POTEAUX | 19450
POTEAUX | 40250

# IfcColumn: HEA220 (3)
In: Undefined
Description: HEA220; Material: STEEL/E24-2
Tekla Common - Phase: 1; Class: 1011; Finish: GRENAILLE-PEINT; Grade: E24-2; Profile: HEA220; Name: POTEAUX; sets with these values: 2
Tekla Quantity - Area per tons: 24.9626 m2; Height: 210 mm; Width: 220 mm; sets with these values: 2
Name | Center of gravity Z (mm) | Center of gravity Y (mm) | Center of gravity X (mm) | Bottom elevation | Top elevation | Part mark | Assembly mark | Net weight (kg) = NetWeight (kg) | Gross weight (kg) = Weight (kg) | Net volume (m3) = NetVolume (m3) | Gross volume (m3) | Gross footprint area (m2) | Net surface area (m2) | Gross area (m2) = OuterSurfaceArea (m2) | Tekla Quantity, Length (mm) = BaseQuantities, Length (mm)
POTEAUX | 2704.86 | 13550 | 71816.4 | -0.388 | +5.888 | 129 | P123 | 298.551 | 316.784 | 0.038032 | 0.0403547 | 0.005122 | 7.97359 | 7.90776 | 6276
POTEAUX | 4394 | 27250 | 71815 | +3.490 | +5.298 | 130 | N5 | 87.3709 | 91.2597 | 0.01113 | 0.0116254 | 0.006156 | 2.3374 | 2.27808 | 1808
POTEAUX | 1550 | 26050 | 71815 | -0.388 | +3.488 | 131 | P118 | 187.306 | 195.643 | 0.0238607 | 0.0249227 | 0.006156 | 4.99685 | 4.88376 | 3876

# IfcColumn: IPE200 (18)
In: Undefined
Description: IPE200; Material: STEEL/E24-2
Tekla Common - Finish: GRENAILLE-PEINT; Grade: E24-2; Profile: IPE200; Name: POTEAUX; sets with these values: 2
Tekla Quantity - Gross footprint area: 0.0027248 m2; Area per tons: 34.3279 m2; Height: 200 mm; Width: 100 mm; sets with these values: 2
Name | Center of gravity Z (mm) | Center of gravity Y (mm) | Center of gravity X (mm) | Bottom elevation | Top elevation | Part mark | Assembly mark | Phase | Class | Net weight (kg) = NetWeight (kg) | Gross weight (kg) = Weight (kg) | Net volume (m3) = NetVolume (m3) | Gross volume (m3) | Net surface area (m2) | Gross area (m2) = OuterSurfaceArea (m2) | Tekla Quantity, Length (mm) = BaseQuantities, Length (mm)
POTEAUX | 2175.79 | 69275 | 38362.5 | -0.388 | +4.740 | 113 | P21 | 3 | 3001 | 109.677 | 114.717 | 0.0139716 | 0.0146136 | 4.05008 | 3.93798 | 5127.57
POTEAUX | 2743.5 | 7650 | 79235 | -0.388 | +5.875 | 100 | P6 | 1 | 1011 | 133.964 | 140.119 | 0.0170654 | 0.0178495 | 4.9457 | 4.80998 | 6263
POTEAUX | 2743.5 | 1750 | 79235 | -0.388 | +5.875 | 101 | P7 | 1 | 1011 | 133.964 | 140.119 | 0.0170654 | 0.0178495 | 4.9457 | 4.80998 | 6263
POTEAUX | 2743.5 | 13550 | 79235 | -0.388 | +5.875 | 102 | P8 | 1 | 1011 | 133.964 | 140.119 | 0.0170654 | 0.0178495 | 4.9457 | 4.80998 | 6263
POTEAUX | 2743.5 | 19450 | 79235 | -0.388 | +5.875 | 103 | P9 | 1 | 1011 | 133.964 | 140.119 | 0.0170654 | 0.0178495 | 4.9457 | 4.80998 | 6263
POTEAUX | 2743.5 | 24650 | 79235 | -0.388 | +5.875 | 104 | P10 | 1 | 1011 | 133.964 | 140.119 | 0.0170654 | 0.0178495 | 4.9457 | 4.80998 | 6263
POTEAUX | 2743.5 | 29850 | 79235 | -0.388 | +5.875 | 105 | P11 | 1 | 1011 | 133.964 | 140.119 | 0.0170654 | 0.0178495 | 4.9457 | 4.80998 | 6263
POTEAUX | 2743.5 | 35050 | 79235 | -0.388 | +5.875 | 106 | P12 | 1 | 1001 | 133.964 | 140.119 | 0.0170654 | 0.0178495 | 4.9457 | 4.80998 | 6263
POTEAUX | 2743.5 | 40250 | 79235 | -0.388 | +5.875 | 107 | P13 | 1 | 1001 | 133.964 | 140.119 | 0.0170654 | 0.0178495 | 4.9457 | 4.80998 | 6263
POTEAUX | 2743.5 | 45450 | 79235 | -0.388 | +5.875 | 107 | P13 | 1 | 1001 | 133.964 | 140.119 | 0.0170654 | 0.0178495 | 4.9457 | 4.80998 | 6263
POTEAUX | 2743.5 | 50650 | 79235 | -0.388 | +5.875 | 107 | P13 | 1 | 1001 | 133.964 | 140.119 | 0.0170654 | 0.0178495 | 4.9457 | 4.80998 | 6263
POTEAUX | 2913.5 | 55850 | 79235 | -0.048 | +5.875 | 108 | P16 | 1 | 1001 | 126.691 | 132.512 | 0.016139 | 0.0168806 | 4.67751 | 4.54886 | 5923
POTEAUX | 2913.5 | 61050 | 79235 | -0.048 | +5.875 | 108 | P14 | 1 | 1001 | 126.691 | 132.512 | 0.016139 | 0.0168806 | 4.67751 | 4.54886 | 5923
POTEAUX | 2913.5 | 64525 | 79235 | -0.048 | +5.875 | 108 | P15 | 1 | 1001 | 126.691 | 132.512 | 0.016139 | 0.0168806 | 4.67751 | 4.54886 | 5923
POTEAUX | 2961 | 69275 | 79185 | -0.048 | +5.970 | 109 | P17 | 1 | 1011 | 128.723 | 134.638 | 0.0163978 | 0.0171513 | 4.75245 | 4.62182 | 6018
POTEAUX | 2375.79 | 69275 | 73387.5 | +0.012 | +4.740 | 110 | P18 | 1 | 1001 | 101.121 | 105.768 | 0.0128817 | 0.0134736 | 3.73456 | 3.63078 | 4727.57
POTEAUX | 2175.79 | 69275 | 61712.5 | -0.388 | +4.740 | 111 | P19 | 1 | 1001 | 109.677 | 114.717 | 0.0139716 | 0.0146136 | 4.05008 | 3.93798 | 5127.57
POTEAUX | 2175.79 | 69275 | 50037.5 | -0.388 | +4.740 | 112 | P20 | 1 | 1001 | 109.677 | 114.717 | 0.0139716 | 0.0146136 | 4.05008 | 3.93798 | 5127.57

# IfcColumn: IPE400 (8)
In: Undefined
Description: IPE400; Material: STEEL/E24-2
Tekla Common - Finish: GRENAILLE-PEINT; Grade: E24-2; Profile: IPE400; Name: POTEAUX; sets with these values: 2
Tekla Quantity - Gross footprint area: 0.0043349 m2; Area per tons: 22.1159 m2; Height: 400 mm; Width: 180 mm; sets with these values: 2
Name | Center of gravity Z (mm) | Center of gravity Y (mm) | Center of gravity X (mm) | Bottom elevation | Top elevation | Part mark | Assembly mark | Phase | Class | Net weight (kg) = NetWeight (kg) | Gross weight (kg) = Weight (kg) | Net volume (m3) = NetVolume (m3) | Gross volume (m3) | Net surface area (m2) | Gross area (m2) = OuterSurfaceArea (m2) | Tekla Quantity, Length (mm) = BaseQuantities, Length (mm)
POTEAUX | 2653.92 | 7650 | 67609.1 | -0.375 | +5.890 | 8 | P38 | 1 | 1001 | 383.088 | 415.573 | 0.0488011 | 0.0529393 | 9.11703 | 9.19076 | 6265
POTEAUX | 2732.5 | 7650 | 55938.6 | -0.375 | +5.890 | 12 | P4 | 1 | 1001 | 393.579 | 415.573 | 0.0501375 | 0.0529392 | 9.35832 | 9.19076 | 6265
POTEAUX | 2755.85 | 61050 | 44262.6 | -0.375 | +5.975 | 9 | P1 | 1 | 1001 | 396.472 | 421.211 | 0.050506 | 0.0536575 | 9.42887 | 9.31545 | 6350
POTEAUX | 2755.85 | 61050 | 55937.6 | -0.375 | +5.975 | 10 | P2 | 1 | 1001 | 396.472 | 421.211 | 0.050506 | 0.0536575 | 9.42887 | 9.31545 | 6350
POTEAUX | 2925.89 | 61050 | 67612.5 | -0.035 | +5.975 | 7 | P37 | 1 | 1001 | 374.939 | 398.658 | 0.0477629 | 0.0507845 | 8.91791 | 8.81667 | 6010
POTEAUX | 2632.49 | 7650 | 44263.7 | -0.575 | +5.890 | 11 | P3 | 1 | 1001 | 406.246 | 428.84 | 0.0517511 | 0.0546293 | 9.65888 | 9.48416 | 6465
POTEAUX | 2732.5 | 7650 | 32588.6 | -0.375 | +5.890 | 13 | P5 | 3 | 3001 | 393.579 | 415.573 | 0.0501375 | 0.0529393 | 9.35832 | 9.19076 | 6265
POTEAUX | 2732.5 | 7650 | 20913.6 | -0.375 | +5.890 | 1 | P39 | 2 | 2001 | 393.579 | 415.573 | 0.0501375 | 0.0529393 | 9.35832 | 9.19076 | 6265

# IfcColumn: IPE500 (18)
In: Undefined
Description: IPE500; Material: STEEL/E24-2
Tekla Common - Finish: GRENAILLE-PEINT; Grade: E24-2; Profile: IPE500; Name: POTEAUX; sets with these values: 2
Tekla Quantity - Area per tons: 19.1522 m2; Height: 500 mm; Width: 200 mm; sets with these values: 2
Name | Center of gravity Z (mm) | Center of gravity Y (mm) | Center of gravity X (mm) | Bottom elevation | Top elevation | Part mark | Assembly mark | Phase | Class | Net weight (kg) = NetWeight (kg) | Gross weight (kg) = Weight (kg) | Net volume (m3) = NetVolume (m3) | Gross volume (m3) | Gross footprint area (m2) | Net surface area (m2) | Gross area (m2) = OuterSurfaceArea (m2) | Tekla Quantity, Length (mm) = BaseQuantities, Length (mm)
POTEAUX | 2726.33 | 40250 | 32638.1 | -0.375 | +5.890 | 119 | P31 | 3 | 3001 | 543.998 | 570.491 | 0.0692992 | 0.072674 | 0.0054338 | 11.0613 | 10.9262 | 6265
POTEAUX | 2726.33 | 40250 | 67663.1 | -0.375 | +5.890 | 120 | P33 | 1 | 1001 | 543.998 | 570.491 | 0.0692992 | 0.072674 | 0.0054338 | 11.0613 | 10.9262 | 6265
POTEAUX | 2726.33 | 40250 | 44313.1 | -0.375 | +5.890 | 128 | P35 | 1 | 1001 | 543.998 | 570.491 | 0.0692992 | 0.072674 | 0.0054338 | 11.0613 | 10.9262 | 6265
POTEAUX | 2726.33 | 19450 | 55988.1 | -0.375 | +5.890 | 128 | P36 | 1 | 1001 | 543.998 | 570.491 | 0.0692992 | 0.072674 | 0.0054338 | 11.0613 | 10.9262 | 6265
POTEAUX | 2726.33 | 19450 | 20963.1 | -0.375 | +5.890 | 118 | P29 | 2 | 2001 | 543.998 | 570.491 | 0.0692992 | 0.072674 | 0.0054338 | 11.0613 | 10.9262 | 6265
POTEAUX | 2726.33 | 19450 | 32638.1 | -0.375 | +5.890 | 119 | P32 | 3 | 3001 | 543.998 | 570.491 | 0.0692992 | 0.072674 | 0.0054338 | 11.0613 | 10.9262 | 6265
POTEAUX | 2726.33 | 19450 | 44313.1 | -0.375 | +5.890 | 128 | P36 | 1 | 1001 | 543.998 | 570.491 | 0.0692992 | 0.072674 | 0.0054338 | 11.0613 | 10.9262 | 6265
POTEAUX | 2922.5 | 69125 | 67550 | -0.035 | +5.880 | 115 | P23 | 1 | 1001 | 518.821 | 538.62 | 0.0660918 | 0.068614 | 0.0111736 | 10.5487 | 10.3158 | 5915
POTEAUX | 2752.5 | 69125 | 55875 | -0.375 | +5.880 | 116 | P27 | 1 | 1001 | 548.643 | 569.58 | 0.0698909 | 0.072558 | 0.0111736 | 11.1537 | 10.9087 | 6255
POTEAUX | 2752.5 | 69125 | 44200 | -0.375 | +5.880 | 116 | P26 | 1 | 1001 | 548.643 | 569.58 | 0.0698909 | 0.072558 | 0.0111736 | 11.1537 | 10.9087 | 6255
POTEAUX | 2652.5 | 25 | 44200 | -0.575 | +5.880 | 114 | P22 | 1 | 1001 | 566.186 | 587.792 | 0.0721256 | 0.074878 | 0.0111736 | 11.5097 | 11.2575 | 6455
POTEAUX | 2752.5 | 25 | 55875 | -0.375 | +5.880 | 116 | P25 | 1 | 1001 | 548.643 | 569.58 | 0.0698909 | 0.072558 | 0.0111736 | 11.1537 | 10.9087 | 6255
POTEAUX | 2752.5 | 25 | 67550 | -0.375 | +5.880 | 116 | P24 | 1 | 1001 | 548.643 | 569.58 | 0.0698909 | 0.072558 | 0.0111736 | 11.1537 | 10.9087 | 6255
POTEAUX | 2726.33 | 40250 | 20963.1 | -0.375 | +5.890 | 118 | P30 | 2 | 2001 | 543.998 | 570.491 | 0.0692992 | 0.072674 | 0.0054338 | 11.0613 | 10.9262 | 6265
POTEAUX | 2726.33 | 19450 | 67663.1 | -0.375 | +5.890 | 117 | P28 | 1 | 1001 | 543.998 | 570.491 | 0.0692992 | 0.072674 | 0.0054338 | 11.0613 | 10.9262 | 6265
POTEAUX | 2726.33 | 40250 | 67663.1 | -0.375 | +5.890 | 127 | P33 | 1 | 1001 | 543.998 | 570.491 | 0.0692992 | 0.072674 | 0.0054338 | 11.0613 | 10.9262 | 6265
POTEAUX | 2726.33 | 40250 | 55988.1 | -0.375 | +5.890 | 128 | P35 | 1 | 1001 | 543.998 | 570.491 | 0.0692992 | 0.072674 | 0.0054338 | 11.0613 | 10.9262 | 6265
POTEAUX | 2726.33 | 40250 | 79338.1 | -0.375 | +5.890 | P34 | P34 | 1 | 1001 | 543.998 | 570.491 | 0.0692992 | 0.072674 | 0.0054338 | 11.0613 | 10.9262 | 6265

# IfcColumn: IPEA300 (9)
In: Undefined
Description: IPEA300; Material: STEEL/E36-3
Tekla Common - Center of gravity Y: -76.5 mm; Bottom elevation: -0.388; Finish: GRENAILLE-PEINT; Grade: E36-3; Profile: IPEA300; Name: POTEAUX; sets with these values: 2
Tekla Quantity - Gross footprint area: 0.00445946 m2; Area per tons: 31.7786 m2; Height: 297 mm; Width: 150 mm; sets with these values: 2
Name | Center of gravity Z (mm) | Center of gravity X (mm) | Top elevation | Part mark | Assembly mark | Phase | Class | Net weight (kg) = NetWeight (kg) | Gross weight (kg) = Weight (kg) | Net volume (m3) = NetVolume (m3) | Gross volume (m3) | Net surface area (m2) | Gross area (m2) = OuterSurfaceArea (m2) | Tekla Quantity, Length (mm) = BaseQuantities, Length (mm)
POTEAUX | 2746 | 20850 | +5.880 | 14 | P119 | 2 | 2001 | 219.422 | 228.798 | 0.0279519 | 0.0291462 | 7.41644 | 7.27088 | 6268
POTEAUX | 2294.6 | 24742 | +4.977 | 15 | P120 | 3 | 3001 | 187.818 | 195.843 | 0.0239259 | 0.0249482 | 6.34952 | 6.22364 | 5365.2
POTEAUX | 2056.97 | 28633 | +4.502 | 16 | P121 | 3 | 3001 | 171.181 | 178.495 | 0.0218065 | 0.0227382 | 5.78785 | 5.67233 | 4889.94
POTEAUX | 2746 | 32525 | +5.880 | 14 | P113 | 3 | 3001 | 219.422 | 228.798 | 0.0279519 | 0.0291462 | 7.41644 | 7.27088 | 6268
POTEAUX | 2175.79 | 38362.5 | +4.740 | 17 | P114 | 3 | 3001 | 179.5 | 187.169 | 0.0228662 | 0.0238432 | 6.06868 | 5.94798 | 5127.57
POTEAUX | 2175.79 | 50037.5 | +4.740 | 18 | P115 | 1 | 1001 | 179.5 | 187.169 | 0.0228662 | 0.0238432 | 6.06868 | 5.94798 | 5127.57
POTEAUX | 2175.79 | 61712.5 | +4.740 | 18 | P116 | 1 | 1001 | 179.5 | 187.169 | 0.0228662 | 0.0238432 | 6.06868 | 5.94798 | 5127.57
POTEAUX | 2236.82 | 74420 | +4.862 | 19 | P117 | 1 | 1001 | 183.773 | 191.625 | 0.0234105 | 0.0244108 | 6.21293 | 6.08957 | 5249.63
POTEAUX | 2746 | 79225 | +5.880 | 20 | P122 | 1 | 1011 | 219.422 | 228.798 | 0.0279519 | 0.0291462 | 7.41644 | 7.27088 | 6268

# IfcColumn: L100*10 (15)
In: Undefined
Description: L100*10
Tekla Common - Finish: GRENAILLE-PEINT; Profile: L100*10; sets with these values: 2
Tekla Quantity - Gross footprint area: 0.0019 m2; Area per tons: 187.102 m2; Height: 100 mm; Width: 100 mm; sets with these values: 2
Name | Material | BaseQuantities, Length (mm) = Tekla Quantity, Length (mm) | OuterSurfaceArea (m2) = Gross area (m2) | NetVolume (m3) = Net volume (m3) | NetWeight (kg) = Net weight (kg) | Center of gravity Z (mm) | Center of gravity Y (mm) | Center of gravity X (mm) | Bottom elevation | Top elevation | Part mark | Assembly mark | Phase | Class | Grade | Name | Gross weight (kg) = Weight (kg) | Gross volume (m3) | Net surface area (m2)
ATTACHE | STEEL/S235JR | 210 | 0.5922 | 0.000399 | 3.13215 | 10021.4 | 63782.7 | 32696.3 | +9.916 | +10.126 | H73 | H73 | 2 | 2005 | S235JR | ATTACHE | 3.16512 | 0.0004032 | 0.0878
 | STEEL/E24-2 | 130 | 0.3666 | 0.000247 | 1.93895 | 4904.38 | 31261.3 | 79163.7 | +4.839 | +4.969 | 1230 | P48 | 1 | 1003 | E24-2 |  | 1.95936 | 0.0002496 | 0.0558
 | STEEL/E24-2 | 130 | 0.3666 | 0.000247 | 1.93895 | 3934.78 | 66606.3 | 79163.7 | +3.870 | +4.000 | 1230 | P41 | 1 | 1003 | E24-2 |  | 1.95936 | 0.0002496 | 0.0558
ATTACHE | STEEL/S235JR | 210 | 0.5922 | 0.000399 | 3.13215 | 10021.4 | 58252.7 | 32696.3 | +9.916 | +10.126 | H73 | H73 | 2 | 2005 | S235JR | ATTACHE | 3.16512 | 0.0004032 | 0.0878
ATTACHE | STEEL/S235JR | 210 | 0.5922 | 0.000399 | 3.13215 | 10021.4 | 52722.7 | 32696.3 | +9.916 | +10.126 | H73 | H73 | 2 | 2005 | S235JR | ATTACHE | 3.16512 | 0.0004032 | 0.0878
ATTACHE | STEEL/S235JR | 210 | 0.5922 | 0.000399 | 3.13215 | 10021.4 | 55487.7 | 32696.3 | +9.916 | +10.126 | H73 | H73 | 2 | 2005 | S235JR | ATTACHE | 3.16512 | 0.0004032 | 0.0878
ATTACHE | STEEL/S235JR | 210 | 0.5922 | 0.000399 | 3.13215 | 10021.4 | 61017.7 | 32696.3 | +9.916 | +10.126 | H73 | H73 | 2 | 2005 | S235JR | ATTACHE | 3.16512 | 0.0004032 | 0.0878
