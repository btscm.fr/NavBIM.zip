Properties of the parts of a building model (IFC2X3), part 30 of 32

# IfcPlate: PL200*8285, MACONNERIE
Tekla Common - Center of gravity Z: 6040 mm; Center of gravity Y: 59240.5 mm; Center of gravity X: 23824.8 mm; Bottom elevation: +5.940; Top elevation: +6.140; Part mark: Z46; Assembly mark: Z46; Phase: 10; Class: 75; Grade: BETON COURANT; Profile: PL200*8285; Name: MACONNERIE; sets with these values: 2
Tekla Quantity - Net weight: 64365.8 kg; Gross weight: 69019.9 kg; Weight: 64365.8 kg; Net volume: 30.6504 m3; Gross volume: 32.8666 m3; Gross footprint area: 153.252 m2; Area per tons: 4.99085 m2; Net surface area: 321.24 m2; Gross area: 164.333 m2; Height: 8285 mm; Width: 200 mm; Length: 19835 mm; sets with these values: 2

# IfcPlate: PL220*7305, MACONNERIE
In: Undefined
Description: PL220*7305; Material: CONCRETE/BETON COURANT
Tekla Common - Center of gravity Z: 3030 mm; Center of gravity Y: 58347 mm; Center of gravity X: 24381.5 mm; Bottom elevation: +2.920; Top elevation: +3.140; Part mark: Z62; Assembly mark: Z62; Phase: 10; Class: 75; Grade: BETON COURANT; Profile: PL220*7305; Name: MACONNERIE; sets with these values: 2
Tekla Quantity - Net weight: 67546.4 kg; Gross weight: 72325.3 kg; Weight: 67546.4 kg; Net volume: 32.165 m3; Gross volume: 34.4404 m3; Gross footprint area: 146.204 m2; Area per tons: 4.56954 m2; Net surface area: 308.656 m2; Gross area: 156.548 m2; Height: 7305.1 mm; Width: 220 mm; Length: 21430 mm; sets with these values: 2

# IfcPlate: PL3*130 (4)
In: Undefined
Description: PL3*130; Material: STEEL/S235JR
Tekla Common - Center of gravity Z: 3475 mm; Center of gravity X: -183.5 mm; Bottom elevation: +3.260; Top elevation: +3.690; Part mark: 1240; Assembly mark: E3; Phase: 4; Class: 4000; Finish: GALVANISE; Grade: S235JR; Profile: PL3*130; Name: CV; sets with these values: 2
Tekla Quantity - Net weight: 1.22452 kg; Gross weight: 1.31645 kg; Weight: 1.22452 kg; Net volume: 0.000155989 m3; Gross volume: 0.000155989 m3; Gross footprint area: 0.00039 m2; Area per tons: 88.3925 m2; Net surface area: 0.108238 m2; Gross area: 0.0559 m2; Height: 130 mm; Width: 3 mm; Length: 430 mm; sets with these values: 2
Name | Center of gravity Y (mm)
CV | 40317.9
CV | 40182.1
CV | 48457.1
CV | 48592.9

# IfcPlate: PL3*50 (2)
In: Undefined
Description: PL3*50; Material: STEEL/E24-2
Tekla Common - Center of gravity Y: -717.606 mm; Center of gravity X: 44273.5 mm; Part mark: 1244; Assembly mark: L80; Phase: 3; Class: 3003; Finish: GRENAILLE-PEINT; Grade: E24-2; Profile: PL3*50; sets with these values: 2
Tekla Quantity - Net weight: 0.130803 kg; Gross weight: 0.130803 kg; Weight: 0.130803 kg; Net volume: 0.0000166627 m3; Gross volume: 0.0000166627 m3; Gross footprint area: 0.000333255 m2; Area per tons: 92.3148 m2; Net surface area: 0.012075 m2; Gross area: 0.00555425 m2; Height: 50 mm; Width: 3 mm; Length: 111.085 mm; sets with these values: 2
Name | Center of gravity Z (mm) | Bottom elevation | Top elevation
 | 3570 | +3.545 | +3.595
 | 3030 | +3.005 | +3.055

# IfcPlate: PL6*104, ATTACHE
In: Undefined
Description: PL6*104; Material: STEEL/E24-2
Tekla Common - Center of gravity Z: 5827 mm; Center of gravity Y: 13504.3 mm; Center of gravity X: 71908.9 mm; Bottom elevation: +5.824; Top elevation: +5.830; Part mark: 353; Assembly mark: P123; Phase: 1; Class: 1011; Finish: GRENAILLE-PEINT; Grade: E24-2; Profile: PL6*104; Name: ATTACHE; sets with these values: 2
Tekla Quantity - Net weight: 0.824202 kg; Gross weight: 0.864568 kg; Weight: 0.824202 kg; Net volume: 0.000104994 m3; Gross volume: 0.000104994 m3; Gross footprint area: 0.017499 m2; Area per tons: 46.4359 m2; Net surface area: 0.0382726 m2; Gross area: 0.018356 m2; Height: 104 mm; Width: 6 mm; Length: 176.5 mm; sets with these values: 2

# IfcPlate: PL6*115 (2)
In: Undefined
Description: PL6*115
Tekla Common - Profile: PL6*115; sets with these values: 2
Tekla Quantity - Height: 115 mm; Width: 6 mm; sets with these values: 2
Name | Material | Center of gravity Z (mm) | Center of gravity Y (mm) | Center of gravity X (mm) | Bottom elevation | Top elevation | Part mark | Assembly mark | Phase | Class | Finish | Grade | Net weight (kg) = Weight (kg) | Gross weight (kg) | Net volume (m3) = Gross volume (m3) | Gross footprint area (m2) | Area per tons (m2) | Net surface area (m2) | Gross area (m2) | Length (mm)
 | STEEL/E24-2 | 3 | 20644 | 78321.7 | +0.000 | +0.006 | 337 | P52 | 7 | 7001 | GRENAILLE-PEINT | E24-2 | 0.68295 | 0.704145 | 0.000087 | 0.0145 | 46.6133 | 0.0318346 | 0.01495 | 130
CV | STEEL/S235JR | 4752.08 | 44387.5 | -732 | +4.685 | +4.800 | 323 | L6 | 4 | 4000 | GALVANISE | S235JR | 0.54165 | 0.812475 | 0.000069 | 0.0009 | 47.4565 | 0.0257048 | 0.01725 | 150 | Tekla Common - Name: CV

# IfcPlate: PL6*117 (6)
In: Undefined
Description: PL6*117; Material: STEEL/S235JR
Tekla Common - Part mark: 319; Phase: 1; Class: 1001; Finish: GRENAILLE-PEINT; Grade: S235JR; Profile: PL6*117; Name: TOLE; sets with these values: 2
Tekla Quantity - Net weight: 0.941402 kg; Gross weight: 0.946701 kg; Weight: 0.941402 kg; Net volume: 0.000119924 m3; Gross volume: 0.000119924 m3; Gross footprint area: 0.0199873 m2; Area per tons: 46.0869 m2; Net surface area: 0.0433863 m2; Gross area: 0.0200998 m2; Height: 117.2 mm; Width: 6 mm; Length: 171.5 mm; sets with these values: 2
Name | Center of gravity Z (mm) | Center of gravity Y (mm) | Center of gravity X (mm) | Bottom elevation | Top elevation | Assembly mark
TOLE | 2397 | 69280.3 | 61650.8 | +2.394 | +2.400 | P19
TOLE | 2479 | 64463.3 | 79240.3 | +2.476 | +2.482 | P15
TOLE | 2479 | 60988.3 | 79240.3 | +2.476 | +2.482 | P14
TOLE | 3509 | 69280.3 | 73325.8 | +3.506 | +3.512 | P18
TOLE | 2479 | 61111.7 | 79240.3 | +2.476 | +2.482 | P14
TOLE | 2479 | 64586.7 | 79240.3 | +2.476 | +2.482 | P15

# IfcPlate: PL6*134 (22)
In: Undefined
Description: PL6*134; Material: STEEL/S235JR
Tekla Common - Center of gravity Z: 5741.5 mm; Bottom elevation: +5.602; Top elevation: +5.881; Part mark: 358; Phase: 2; Class: 2007; Finish: GALVANISE; Grade: S235JR; Profile: PL6*134; Name: PLAT; sets with these values: 2
Tekla Quantity - Net weight: 1.75836 kg; Gross weight: 1.75836 kg; Weight: 1.75836 kg; Net volume: 0.000223994 m3; Gross volume: 0.000223994 m3; Gross footprint area: 0.000804 m2; Area per tons: 45.2787 m2; Net surface area: 0.079616 m2; Gross area: 0.0373324 m2; Height: 134 mm; Width: 6 mm; Length: 278.6 mm; sets with these values: 2
Name | Center of gravity Y (mm) | Center of gravity X (mm) | Assembly mark
PLAT | 42643.5 | 20688 | S1
PLAT | 42769.5 | 20688 | S1
PLAT | 37443.5 | 20688 | S1
PLAT | 37569.5 | 20688 | S1
PLAT | 32243.5 | 20688 | S1
PLAT | 32369.5 | 20688 | S1
PLAT | 21843.5 | 20688 | S1
PLAT | 21969.5 | 20688 | S1
PLAT | 12576.5 | 20688 | S1
PLAT | 12450.5 | 20688 | S1
PLAT | 45243.5 | 20688 | S1
PLAT | 45369.5 | 20688 | S1
PLAT | 19.0019 | 20683 | S2
PLAT | 144.998 | 20683 | S2
PLAT | 27169.5 | 20688 | S1
PLAT | 27043.5 | 20688 | S1
PLAT | 17296.5 | 20688 | S1
PLAT | 17170.5 | 20688 | S1
PLAT | 9803.5 | 20688 | S1
PLAT | 9929.5 | 20688 | S1
PLAT | 5019.5 | 20688 | S1
PLAT | 4893.5 | 20688 | S1

# IfcPlate: PL6*140, TOLE
In: Undefined
Description: PL6*140; Material: STEEL/S235JR
Tekla Common - Center of gravity Z: 2397 mm; Center of gravity Y: -130.02 mm; Center of gravity X: 61639.1 mm; Bottom elevation: +2.394; Top elevation: +2.400; Part mark: 318; Assembly mark: P116; Phase: 1; Class: 1001; Finish: GRENAILLE-PEINT; Grade: S235JR; Profile: PL6*140; Name: TOLE; sets with these values: 2
Tekla Quantity - Net weight: 1.12096 kg; Gross weight: 1.12626 kg; Weight: 1.12096 kg; Net volume: 0.000142797 m3; Gross volume: 0.000142797 m3; Gross footprint area: 0.0237995 m2; Area per tons: 45.743 m2; Net surface area: 0.0512759 m2; Gross area: 0.023912 m2; Height: 140 mm; Width: 6 mm; Length: 170.8 mm; sets with these values: 2

# IfcPlate: PL6*160 (3)
In: Undefined
Description: PL6*160; Material: STEEL/S235JR
Tekla Common - Part mark: 317; Phase: 1; Class: 1001; Finish: GRENAILLE-PEINT; Grade: S235JR; Profile: PL6*160; Name: TOLE; sets with these values: 2
Tekla Quantity - Net weight: 1.22119 kg; Gross weight: 1.2359 kg; Weight: 1.22119 kg; Net volume: 0.000155565 m3; Gross volume: 0.000155565 m3; Gross footprint area: 0.0259275 m2; Area per tons: 45.5747 m2; Net surface area: 0.0556551 m2; Gross area: 0.02624 m2; Height: 160 mm; Width: 6 mm; Length: 164 mm; sets with these values: 2
Name | Center of gravity Z (mm) | Center of gravity Y (mm) | Center of gravity X (mm) | Bottom elevation | Top elevation | Assembly mark
TOLE | 2397 | 69276.1 | 55961 | +2.394 | +2.400 | P27
TOLE | 2397 | -126.112 | 55961 | +2.394 | +2.400 | P25
TOLE | 3509 | 69276.1 | 67636 | +3.506 | +3.512 | P23

# IfcPlate: PL6*165, CV
In: Undefined
Description: PL6*165; Material: STEEL/S235JR
Tekla Common - Center of gravity Z: 4266.94 mm; Center of gravity Y: 44387.5 mm; Center of gravity X: -732 mm; Bottom elevation: +4.200; Top elevation: +4.365; Part mark: 325; Assembly mark: L7; Phase: 4; Class: 4000; Finish: GALVANISE; Grade: S235JR; Profile: PL6*165; Name: CV; sets with these values: 2
Tekla Quantity - Net weight: 1.36004 kg; Gross weight: 1.85483 kg; Weight: 1.36004 kg; Net volume: 0.000173254 m3; Gross volume: 0.000173254 m3; Gross footprint area: 0.0003 m2; Area per tons: 45.4842 m2; Net surface area: 0.0618605 m2; Gross area: 0.0393808 m2; Height: 165 mm; Width: 6 mm; Length: 238.671 mm; sets with these values: 2

# IfcPlate: PL6*60
In: Undefined
Description: PL6*60; Material: STEEL/E24-2
Tekla Common - Center of gravity Z: 3 mm; Center of gravity Y: 20670 mm; Center of gravity X: 79315 mm; Bottom elevation: +0.000; Top elevation: +0.006; Part mark: 340; Assembly mark: P53; Phase: 7; Class: 7001; Finish: GRENAILLE-PEINT; Grade: E24-2; Profile: PL6*60; sets with these values: 2
Tekla Quantity - Net weight: 0.53694 kg; Gross weight: 0.53694 kg; Weight: 0.53694 kg; Net volume: 0.0000684 m3; Gross volume: 0.0000684 m3; Gross footprint area: 0.0114 m2; Area per tons: 48.0501 m2; Net surface area: 0.0258 m2; Gross area: 0.0114 m2; Height: 60 mm; Width: 6 mm; Length: 190 mm; sets with these values: 2

# IfcPlate: PL6*65 (4)
In: Undefined
Description: PL6*65
Tekla Common - Profile: PL6*65; sets with these values: 2
Tekla Quantity - Width: 6 mm; sets with these values: 2
Name | Material | Center of gravity Z (mm) | Center of gravity Y (mm) | Center of gravity X (mm) | Bottom elevation | Top elevation | Part mark | Assembly mark | Phase | Class | Finish | Grade | Net weight (kg) = Weight (kg) | Gross weight (kg) | Net volume (m3) = Gross volume (m3) | Gross footprint area (m2) | Area per tons (m2) | Net surface area (m2) | Gross area (m2) | Height (mm) | Length (mm)
 | STEEL/E24-2 | 4989.06 | 40.5457 | 71085.2 | +4.946 | +5.034 | 349 | K28 | 1 | 1010 | GRENAILLE-PEINT | E24-2 | 0.267035 | 0.272334 | 0.0000340172 | 0 | 49.1838 | 0.0131338 | 0.00578203 | 65 | 88.9543
 | STEEL/E24-2 | 4989.06 | -40.5457 | 71085.2 | +4.946 | +5.034 | 349 | K28 | 1 | 1010 | GRENAILLE-PEINT | E24-2 | 0.267035 | 0.272334 | 0.0000340172 | 0 | 49.1838 | 0.0131338 | 0.00578203 | 65 | 88.9543
CV | STEEL/S235JR | 4773.64 | 48497.5 | -732 | +4.735 | +4.800 | 324 | L6 | 4 | 4000 | GALVANISE | S235JR | 0.473273 | 0.60966 | 0.0000602895 | 0.00119601 | 48.6356 | 0.0230179 | 0.0129439 | 64.9357 | 199.335 | Tekla Common - Name: CV
CV | STEEL/S235JR | 4773.64 | 40277.5 | -732 | +4.735 | +4.800 | 324 | L6 | 4 | 4000 | GALVANISE | S235JR | 0.473273 | 0.60966 | 0.0000602895 | 0.00119601 | 48.6356 | 0.0230179 | 0.0129439 | 64.9357 | 199.335 | Tekla Common - Name: CV

# IfcPlate: PL6*79 (4)
In: Undefined
Description: PL6*79; Material: STEEL/S235JR
Tekla Common - Center of gravity Z: 4869.75 mm; Center of gravity X: 79081.5 mm; Bottom elevation: +4.828; Top elevation: +4.907; Part mark: 359; Assembly mark: N37; Phase: 1; Class: 1011; Finish: GRENAILLE-PEINT; Grade: S235JR; Profile: PL6*79; Name: TOLE; sets with these values: 2
Tekla Quantity - Net weight: 0.291481 kg; Gross weight: 0.313357 kg; Weight: 0.291481 kg; Net volume: 0.0000371313 m3; Gross volume: 0.0000371313 m3; Gross footprint area: 0.000504 m2; Area per tons: 48.7309 m2; Net surface area: 0.0142041 m2; Gross area: 0.00665301 m2; Height: 79.2025 mm; Width: 6 mm; Length: 84 mm; sets with these values: 2
Name | Center of gravity Y (mm)
TOLE | 34025
TOLE | 33095
TOLE | 34955
TOLE | 32165

# IfcPlate: PL6*86 (19)
In: Undefined
Description: PL6*86; Material: STEEL/E24-2
Tekla Common - Center of gravity Z: 3840 mm; Bottom elevation: +3.654; Top elevation: +4.026; Part mark: 360; Phase: 2; Class: 2006; Finish: GRENAILLE-PEINT; Grade: E24-2; Profile: PL6*86; Name: TOLE; sets with these values: 2
Tekla Quantity - Net weight: 1.47213 kg; Gross weight: 1.50157 kg; Weight: 1.47213 kg; Net volume: 0.000187532 m3; Gross volume: 0.000187532 m3; Gross footprint area: 0.0003642 m2; Area per tons: 46.0744 m2; Net surface area: 0.0678275 m2; Gross area: 0.0318804 m2; Height: 85.7 mm; Width: 6 mm; Length: 372 mm; sets with these values: 2
Name | Center of gravity Y (mm) | Center of gravity X (mm) | Assembly mark
TOLE | 10930 | -47.8402 | N20
TOLE | 13060 | -47.8402 | N20
TOLE | 15190 | -47.8402 | N20
TOLE | 17320 | -47.8402 | N20
TOLE | 19450 | -47.8402 | N19
TOLE | 21981.2 | -47.8402 | N19
TOLE | 24512.5 | -47.8402 | N19
TOLE | 29375 | -47.8402 | N21
TOLE | 27043.8 | -47.8402 | N21
TOLE | 26092 | -47.8402 | N19
TOLE | 26108 | -47.8402 | N21
TOLE | 18552 | -47.8402 | N20
TOLE | 40242 | -47.8402 | N21
TOLE | 40258 | -47.8402 | N22
TOLE | 26092 | 47.8402 | N19
TOLE | 26108 | 47.8402 | N21
TOLE | 18568 | 47.8402 | N19
TOLE | 18568 | -47.8402 | N19
TOLE | 18552 | 47.8402 | N20

# IfcPlate: PL6140*600, MACONNERIE
In: Undefined
Description: PL6140*600; Material: CONCRETE/BETON COURANT
Tekla Common - Center of gravity Z: 3070 mm; Center of gravity Y: 48392.1 mm; Center of gravity X: 20801 mm; Bottom elevation: +0.000; Top elevation: +6.140; Part mark: Z66; Assembly mark: Z66; Phase: 10; Class: 72; Grade: BETON COURANT; Profile: PL6140*600; Name: MACONNERIE; sets with these values: 2
Tekla Quantity - Net weight: 3842.41 kg; Gross weight: 5338.12 kg; Weight: 3842.41 kg; Net volume: 1.82972 m3; Gross volume: 1.82972 m3; Gross footprint area: 0.298 m2; Area per tons: 4.27783 m2; Net surface area: 16.4372 m2; Gross area: 0.414 m2; Height: 600 mm; Width: 6140 mm; Length: 690 mm; sets with these values: 2

# IfcPlate: PL6140*800, MACONNERIE
In: Undefined
Description: PL6140*800; Material: CONCRETE/BETON COURANT
Tekla Common - Center of gravity Z: 3070 mm; Center of gravity Y: 61130 mm; Center of gravity X: 27985 mm; Bottom elevation: -0.000; Top elevation: +6.140; Part mark: Z65; Assembly mark: Z65; Phase: 10; Class: 72; Grade: BETON COURANT; Profile: PL6140*800; Name: MACONNERIE; sets with these values: 2
Tekla Quantity - Net weight: 5157.6 kg; Gross weight: 8252.16 kg; Weight: 5157.6 kg; Net volume: 2.456 m3; Gross volume: 2.456 m3; Gross footprint area: 0.4 m2; Area per tons: 3.96463 m2; Net surface area: 20.448 m2; Gross area: 0.64 m2; Height: 800 mm; Width: 6140 mm; Length: 800 mm; sets with these values: 2

# IfcPlate: PL8*107 (5)
In: Undefined
Description: PL8*107
Tekla Common - Finish: GRENAILLE-PEINT; Profile: PL8*107; Name: GOUSSET; sets with these values: 2
Tekla Quantity - Gross footprint area: 0 m2; Width: 8 mm; sets with these values: 2
Name | Material | Center of gravity Z (mm) | Center of gravity Y (mm) | Center of gravity X (mm) | Bottom elevation | Top elevation | Part mark | Assembly mark | Phase | Class | Grade | Net weight (kg) = Weight (kg) | Gross weight (kg) | Net volume (m3) = Gross volume (m3) | Area per tons (m2) | Net surface area (m2) | Gross area (m2) | Height (mm) | Length (mm)
GOUSSET | STEEL/E24-2 | 5139.02 | 19393.8 | 67544.7 | +5.132 | +5.147 | 715 | P28 | 1 | 1001 | E24-2 | 1.37587 | 1.47681 | 0.000175271 | 35.4648 | 0.0487952 | 0.023516 | 106.767 | 220.257
GOUSSET | STEEL/S235JR | 3296.8 | 13004.1 | 12183.7 | +3.289 | +3.305 | 755 | K72 | 2 | 2005 | S235JR | 1.77226 | 1.79743 | 0.000225766 | 35.1216 | 0.0622447 | 0.0286214 | 107.046 | 267.376
GOUSSET | STEEL/S235JR | 3296.8 | 13115.9 | 12183.8 | +3.289 | +3.305 | 755 | K72 | 2 | 2005 | S235JR | 1.77222 | 1.79736 | 0.00022576 | 35.1216 | 0.0622431 | 0.0286204 | 107.045 | 267.368
GOUSSET | STEEL/S235JR | 3296.8 | 17264.1 | 12183.7 | +3.289 | +3.305 | 755 | K68 | 2 | 2005 | S235JR | 1.77226 | 1.79743 | 0.000225766 | 35.1216 | 0.0622447 | 0.0286214 | 107.046 | 267.376
GOUSSET | STEEL/S235JR | 3294.77 | 17363.6 | 12118.2 | +3.289 | +3.303 | 751 | K68 | 2 | 2005 | S235JR | 0.778119 | 1.34448 | 0.0000991234 | 37.3802 | 0.0290862 | 0.021409 | 107.045 | 200

# IfcPlate: PL8*113, GOUSSET
In: Undefined
Description: PL8*113; Material: STEEL/S235JR
Tekla Common - Center of gravity Z: 3296.8 mm; Center of gravity Y: 43067.3 mm; Center of gravity X: 12183.8 mm; Bottom elevation: +3.289; Top elevation: +3.305; Part mark: 753; Assembly mark: K67; Phase: 2; Class: 2005; Finish: GRENAILLE-PEINT; Grade: S235JR; Profile: PL8*113; Name: GOUSSET; sets with these values: 2
Tekla Quantity - Net weight: 1.68787 kg; Gross weight: 1.71301 kg; Weight: 1.68787 kg; Net volume: 0.000215015 m3; Gross volume: 0.000215015 m3; Gross footprint area: 0 m2; Area per tons: 35.0927 m2; Net surface area: 0.0592318 m2; Gross area: 0.0272772 m2; Height: 113.255 mm; Width: 8 mm; Length: 240.848 mm; sets with these values: 2

# IfcPlate: PL8*114 (3)
In: Undefined
Description: PL8*114; Material: STEEL/E24-2
Tekla Common - Center of gravity Z: 5507.66 mm; Center of gravity Y: 60995 mm; Bottom elevation: +5.481; Top elevation: +5.534; Part mark: 716; Phase: 1; Class: 1001; Finish: GRENAILLE-PEINT; Grade: E24-2; Profile: PL8*114; Name: GOUSSET; sets with these values: 2
Tekla Quantity - Net weight: 2.30384 kg; Gross weight: 2.65692 kg; Weight: 2.30384 kg; Net volume: 0.000293483 m3; Gross volume: 0.000293483 m3; Gross footprint area: 0 m2; Area per tons: 34.958 m2; Net surface area: 0.0805379 m2; Gross area: 0.0423077 m2; Height: 113.792 mm; Width: 8 mm; Length: 371.799 mm; sets with these values: 2
Name | Center of gravity X (mm) | Assembly mark
GOUSSET | 55941.3 | P2
GOUSSET | 44266.3 | P1
GOUSSET | 67616.3 | P37

# IfcPlate: PL8*115 (11)
In: Undefined
Description: PL8*115; Material: STEEL/S235JR
Tekla Common - Phase: 2; Class: 2005; Finish: GRENAILLE-PEINT; Grade: S235JR; Profile: PL8*115; Name: GOUSSET; sets with these values: 2
Tekla Quantity - Gross footprint area: 0 m2; Width: 8 mm; sets with these values: 2
Name | Center of gravity Z (mm) | Center of gravity Y (mm) | Center of gravity X (mm) | Bottom elevation | Top elevation | Part mark | Assembly mark | Net weight (kg) = Weight (kg) | Gross weight (kg) | Net volume (m3) = Gross volume (m3) | Area per tons (m2) | Net surface area (m2) | Gross area (m2) | Height (mm) | Length (mm)
GOUSSET | 3296.8 | 37521.4 | 12183.7 | +3.289 | +3.305 | 752 | K70 | 1.79171 | 1.81688 | 0.000228243 | 35.0167 | 0.0627397 | 0.0289312 | 114.936 | 251.717
GOUSSET | 3296.8 | 37641.1 | 12183.8 | +3.289 | +3.305 | 752 | K70 | 1.79166 | 1.81681 | 0.000228237 | 35.0167 | 0.0627381 | 0.02893 | 114.935 | 251.708
GOUSSET | 3295.2 | 42960.9 | 12132 | +3.289 | +3.303 | 750 | K67 | 0.856662 | 1.44366 | 0.000109129 | 36.997 | 0.0316939 | 0.0229883 | 114.936 | 200.01
GOUSSET | 3296.8 | 32183.9 | 12183.7 | +3.289 | +3.305 | 752 | K69 | 1.79171 | 1.81688 | 0.000228243 | 35.0167 | 0.0627397 | 0.0289312 | 114.936 | 251.717
GOUSSET | 3296.8 | 32303.6 | 12183.8 | +3.289 | +3.305 | 752 | K69 | 1.79166 | 1.81681 | 0.000228237 | 35.0167 | 0.0627381 | 0.02893 | 114.935 | 251.708
GOUSSET | 3475.9 | 32183.9 | 17961.3 | +3.468 | +3.484 | 752 | K69 | 1.79171 | 1.81688 | 0.000228243 | 35.0167 | 0.0627397 | 0.0289312 | 114.936 | 251.717
GOUSSET | 3475.9 | 32303.6 | 17961.3 | +3.468 | +3.484 | 752 | K69 | 1.79166 | 1.81681 | 0.000228237 | 35.0167 | 0.0627381 | 0.02893 | 114.935 | 251.708
GOUSSET | 3296.8 | 26983.9 | 12183.7 | +3.289 | +3.305 | 754 | K71 | 1.79171 | 1.81688 | 0.000228243 | 35.0167 | 0.0627397 | 0.0289312 | 114.936 | 251.717
GOUSSET | 3296.8 | 27103.6 | 12183.8 | +3.289 | +3.305 | 754 | K71 | 1.79166 | 1.81681 | 0.000228237 | 35.0167 | 0.0627381 | 0.02893 | 114.935 | 251.708
GOUSSET | 3296.8 | 21921.4 | 12183.7 | +3.289 | +3.305 | 754 | K71 | 1.79171 | 1.81688 | 0.000228243 | 35.0167 | 0.0627397 | 0.0289312 | 114.936 | 251.717
GOUSSET | 3296.8 | 22041.1 | 12183.8 | +3.289 | +3.305 | 754 | K71 | 1.79166 | 1.81681 | 0.000228237 | 35.0167 | 0.0627381 | 0.02893 | 114.935 | 251.708

# IfcPlate: PL8*120 (35)
In: Undefined
Description: PL8*120; Material: STEEL/E24-2
Tekla Common - Finish: GRENAILLE-PEINT; Grade: E24-2; Profile: PL8*120; Name: GOUSSET; sets with these values: 2
Tekla Quantity - Gross footprint area: 0 m2; Height: 120 mm; Width: 8 mm; sets with these values: 2
Name | Center of gravity Z (mm) | Center of gravity Y (mm) | Center of gravity X (mm) | Bottom elevation | Top elevation | Part mark = Assembly mark | Phase | Class | Net weight (kg) = Weight (kg) | Gross weight (kg) | Net volume (m3) = Gross volume (m3) | Area per tons (m2) | Net surface area (m2) | Gross area (m2) | Length (mm)
GOUSSET | 4770.01 | 53250 | 38358.5 | +4.759 | +4.781 | G20 | 3 | 3004 | 2.63006 | 3.16512 | 0.00033504 | 34.8054 | 0.0915403 | 0.0504 | 420
GOUSSET | 4770.01 | 58450 | 38358.5 | +4.759 | +4.781 | G20 | 3 | 3004 | 2.63006 | 3.16512 | 0.00033504 | 34.8054 | 0.0915403 | 0.0504 | 420
GOUSSET | 4770.01 | 55850 | 38358.5 | +4.759 | +4.781 | G20 | 3 | 3004 | 2.63006 | 3.16512 | 0.00033504 | 34.8054 | 0.0915403 | 0.0504 | 420
GOUSSET | 4770.01 | 66450 | 38358.5 | +4.759 | +4.781 | G19 | 3 | 3004 | 2.63006 | 3.16512 | 0.00033504 | 34.8054 | 0.0915403 | 0.0504 | 420
GOUSSET | 4802.76 | 37650 | 73387.5 | +4.792 | +4.814 | G18 | 1 | 1004 | 2.57354 | 3.08976 | 0.00032784 | 34.8095 | 0.0895839 | 0.0492 | 410
GOUSSET | 4802.76 | 48050 | 73387.5 | +4.792 | +4.814 | G18 | 1 | 1004 | 2.57354 | 3.08976 | 0.00032784 | 34.8095 | 0.0895839 | 0.0492 | 410
GOUSSET | 4802.76 | 58450 | 73387.5 | +4.792 | +4.814 | G18 | 1 | 1004 | 2.57354 | 3.08976 | 0.00032784 | 34.8095 | 0.0895839 | 0.0492 | 410
GOUSSET | 4802.76 | 42850 | 73387.5 | +4.792 | +4.814 | G18 | 1 | 1004 | 2.57354 | 3.08976 | 0.00032784 | 34.8095 | 0.0895839 | 0.0492 | 410
GOUSSET | 4802.76 | 53250 | 73387.5 | +4.792 | +4.814 | G18 | 1 | 1004 | 2.57354 | 3.08976 | 0.00032784 | 34.8095 | 0.0895839 | 0.0492 | 410
GOUSSET | 5011.55 | 22050 | 71678.1 | +5.001 | +5.024 | G27 | 1 | 1009 | 2.57354 | 3.08976 | 0.00032784 | 34.8473 | 0.089681 | 0.0492 | 410
GOUSSET | 5010.88 | 17090 | 71678.1 | +5.005 | +5.017 | G27 | 1 | 1009 | 2.57354 | 3.08976 | 0.00032784 | 34.8473 | 0.089681 | 0.0492 | 410
GOUSSET | 4802.76 | 2550 | 61712.5 | +4.792 | +4.814 | G18 | 1 | 1004 | 2.57354 | 3.08976 | 0.00032784 | 34.8095 | 0.0895839 | 0.0492 | 410
GOUSSET | 4802.76 | 2550 | 38362.5 | +4.792 | +4.814 | G18 | 3 | 3004 | 2.57354 | 3.08976 | 0.00032784 | 34.8095 | 0.0895839 | 0.0492 | 410
GOUSSET | 4802.76 | 66450 | 50037.5 | +4.792 | +4.814 | G18 | 1 | 1004 | 2.57354 | 3.08976 | 0.00032784 | 34.8095 | 0.0895839 | 0.0492 | 410
GOUSSET | 4802.76 | 2550 | 50037.5 | +4.792 | +4.814 | G18 | 1 | 1004 | 2.57354 | 3.08976 | 0.00032784 | 34.8095 | 0.0895839 | 0.0492 | 410
GOUSSET | 4802.76 | 66450 | 61712.5 | +4.792 | +4.814 | G18 | 1 | 1004 | 2.57354 | 3.08976 | 0.00032784 | 34.8095 | 0.0895839 | 0.0492 | 410
GOUSSET | 4802.76 | 2550 | 26687.5 | +4.792 | +4.814 | G18 | 3 | 3004 | 2.57354 | 3.08976 | 0.00032784 | 34.8095 | 0.0895839 | 0.0492 | 410
GOUSSET | 5010.2 | 12370 | 71700.1 | +5.004 | +5.016 | G18 | 1 | 1009 | 2.57354 | 3.08976 | 0.00032784 | 34.8095 | 0.0895839 | 0.0492 | 410
GOUSSET | 5010.2 | 7650 | 71700.1 | +5.004 | +5.016 | G18 | 1 | 1009 | 2.57354 | 3.08976 | 0.00032784 | 34.8095 | 0.0895839 | 0.0492 | 410
GOUSSET | 5010.2 | 2605.47 | 71700.1 | +5.004 | +5.016 | G60 | 1 | 1009 | 1.79922 | 2.05733 | 0.0002292 | 35.1041 | 0.0631599 | 0.03276 | 273
GOUSSET | 4802.76 | 66450 | 73387.5 | +4.792 | +4.814 | G18 | 1 | 1004 | 2.57354 | 3.08976 | 0.00032784 | 34.8095 | 0.0895839 | 0.0492 | 410
GOUSSET | 3576.15 | 32243.8 | 4647.5 | +3.570 | +3.582 | G18 | 2 | 2004 | 2.57354 | 3.08976 | 0.00032784 | 34.8095 | 0.0895839 | 0.0492 | 410
GOUSSET | 3576.15 | 27043.8 | 4647.5 | +3.570 | +3.582 | G18 | 2 | 2004 | 2.57354 | 3.08976 | 0.00032784 | 34.8095 | 0.0895839 | 0.0492 | 410
GOUSSET | 3576.15 | 24512.5 | 4647.5 | +3.570 | +3.582 | G18 | 2 | 2004 | 2.57354 | 3.08976 | 0.00032784 | 34.8095 | 0.0895839 | 0.0492 | 410
GOUSSET | 3576.15 | 21981.2 | 4647.5 | +3.570 | +3.582 | G18 | 2 | 2004 | 2.57354 | 3.08976 | 0.00032784 | 34.8095 | 0.0895839 | 0.0492 | 410
GOUSSET | 3576.15 | 19450 | 4647.5 | +3.570 | +3.582 | G18 | 2 | 2004 | 2.57354 | 3.08976 | 0.00032784 | 34.8095 | 0.0895839 | 0.0492 | 410
GOUSSET | 3576.15 | 17320 | 4647.5 | +3.570 | +3.582 | G18 | 2 | 2004 | 2.57354 | 3.08976 | 0.00032784 | 34.8095 | 0.0895839 | 0.0492 | 410
GOUSSET | 3576.15 | 15190 | 4647.5 | +3.570 | +3.582 | G18 | 2 | 2004 | 2.57354 | 3.08976 | 0.00032784 | 34.8095 | 0.0895839 | 0.0492 | 410
GOUSSET | 3576.15 | 13060 | 4647.5 | +3.570 | +3.582 | G18 | 2 | 2004 | 2.57354 | 3.08976 | 0.00032784 | 34.8095 | 0.0895839 | 0.0492 | 410
GOUSSET | 3576.15 | 48469.5 | 4647.5 | +3.570 | +3.582 | G60 | 2 | 2004 | 1.79922 | 2.05733 | 0.0002292 | 35.1041 | 0.0631599 | 0.03276 | 273
GOUSSET | 3576.15 | 37581.2 | 4647.5 | +3.570 | +3.582 | G18 | 2 | 2004 | 2.57354 | 3.08976 | 0.00032784 | 34.8095 | 0.0895839 | 0.0492 | 410
GOUSSET | 3576.15 | 40250 | 4647.5 | +3.570 | +3.582 | G18 | 2 | 2004 | 2.57354 | 3.08976 | 0.00032784 | 34.8095 | 0.0895839 | 0.0492 | 410
GOUSSET | 3576.15 | 43008.3 | 4647.5 | +3.570 | +3.582 | G18 | 2 | 2004 | 2.57354 | 3.08976 | 0.00032784 | 34.8095 | 0.0895839 | 0.0492 | 410
GOUSSET | 3576.15 | 45766.7 | 4647.5 | +3.570 | +3.582 | G18 | 2 | 2004 | 2.57354 | 3.08976 | 0.00032784 | 34.8095 | 0.0895839 | 0.0492 | 410
GOUSSET | 3576.15 | 10985.5 | 4647.5 | +3.570 | +3.582 | G60 | 2 | 2004 | 1.79922 | 2.05733 | 0.0002292 | 35.1041 | 0.0631599 | 0.03276 | 273

# IfcPlate: PL8*124 (6)
In: Undefined
Description: PL8*124; Material: STEEL/E24-2
Tekla Common - Center of gravity Z: 3544.54 mm; Center of gravity X: 78890.7 mm; Bottom elevation: +3.536; Top elevation: +3.552; Part mark: 802; Phase: 1; Class: 1010; Finish: GRENAILLE-PEINT; Grade: E24-2; Profile: PL8*124; Name: GOUSSET; sets with these values: 2
Tekla Quantity - Net weight: 0.846853 kg; Gross weight: 1.69371 kg; Weight: 0.846853 kg; Net volume: 0.000107879 m3; Gross volume: 0.000107879 m3; Gross footprint area: 0 m2; Area per tons: 37.4333 m2; Net surface area: 0.0317005 m2; Gross area: 0.0269699 m2; Height: 124.298 mm; Width: 8 mm; Length: 216.977 mm; sets with these values: 2
Name | Center of gravity Y (mm) | Assembly mark
GOUSSET | 25954 | K87
GOUSSET | 13645.9 | K57
GOUSSET | 17812.6 | K88
GOUSSET | 17620.7 | K88
GOUSSET | 21787.4 | K89
GOUSSET | 21979.3 | K89

# IfcPlate: PL8*125 (12)
In: Undefined
Description: PL8*125; Material: STEEL/S235JR
Tekla Common - Phase: 2; Class: 2005; Finish: GRENAILLE-PEINT; Grade: S235JR; Profile: PL8*125; Name: GOUSSET; sets with these values: 2
Tekla Quantity - Net weight: 2.83269 kg; Gross weight: 3.67897 kg; Weight: 2.83269 kg; Net volume: 0.000360853 m3; Gross volume: 0.000360853 m3; Gross footprint area: 0 m2; Area per tons: 34.824 m2; Net surface area: 0.0986458 m2; Gross area: 0.0585823 m2; Height: 124.586 mm; Width: 8 mm; Length: 470.215 mm; sets with these values: 2
Name | Center of gravity Z (mm) | Center of gravity Y (mm) | Center of gravity X (mm) | Bottom elevation | Top elevation | Part mark | Assembly mark
GOUSSET | 10128.8 | 52630.2 | 29361.2 | +10.118 | +10.140 | 820 | K35
GOUSSET | 10326.2 | 52630.2 | 22993.7 | +10.315 | +10.338 | 820 | K35
GOUSSET | 10326.2 | 52749.8 | 22993.8 | +10.315 | +10.338 | 731 | K35
GOUSSET | 10326.2 | 63690.2 | 22993.7 | +10.315 | +10.338 | 731 | K36
GOUSSET | 10128.8 | 58279.8 | 29361.3 | +10.118 | +10.140 | 731 | K34
GOUSSET | 10326.2 | 58279.8 | 22993.8 | +10.315 | +10.338 | 731 | K34
GOUSSET | 10326.2 | 58160.2 | 22993.7 | +10.315 | +10.338 | 731 | K34
GOUSSET | 10128.8 | 58160.2 | 29361.2 | +10.118 | +10.140 | 731 | K34
GOUSSET | 10326.2 | 63809.8 | 22993.8 | +10.315 | +10.338 | 820 | K36
GOUSSET | 10128.8 | 63690.2 | 29361.2 | +10.118 | +10.140 | 731 | K36
GOUSSET | 10128.8 | 63809.8 | 29361.3 | +10.118 | +10.140 | 820 | K36
GOUSSET | 10128.8 | 52749.8 | 29361.3 | +10.118 | +10.140 | 731 | K35

# IfcPlate: PL8*127, GOUSSET
In: Undefined
Description: PL8*127; Material: STEEL/E24-2
Tekla Common - Center of gravity Z: 3406.74 mm; Center of gravity Y: 13497.3 mm; Center of gravity X: 79225 mm; Bottom elevation: +3.302; Top elevation: +3.523; Part mark: 796; Assembly mark: P8; Phase: 1; Class: 1011; Finish: GRENAILLE-PEINT; Grade: E24-2; Profile: PL8*127; Name: GOUSSET; sets with these values: 2
Tekla Quantity - Net weight: 1.32065 kg; Gross weight: 1.75444 kg; Weight: 1.32065 kg; Net volume: 0.000168235 m3; Gross volume: 0.000168235 m3; Gross footprint area: 0.00032 m2; Area per tons: 35.4714 m2; Net surface area: 0.0468452 m2; Gross area: 0.0279369 m2; Height: 126.568 mm; Width: 8 mm; Length: 220.727 mm; sets with these values: 2

# IfcPlate: PL8*130 (4)
In: Undefined
Description: PL8*130; Material: STEEL/E24-2
Tekla Common - Center of gravity Z: 4811.74 mm; Center of gravity Y: 19386.7 mm; Bottom elevation: +4.789; Top elevation: +4.837; Part mark: 792; Assembly mark: K21; Finish: GRENAILLE-PEINT; Grade: E24-2; Profile: PL8*130; Name: GOUSSET; sets with these values: 2
Tekla Quantity - Net weight: 2.08981 kg; Gross weight: 2.72225 kg; Weight: 2.08981 kg; Net volume: 0.000266217 m3; Gross volume: 0.000266217 m3; Gross footprint area: 0 m2; Area per tons: 34.9763 m2; Net surface area: 0.0730937 m2; Gross area: 0.043348 m2; Height: 130.3 mm; Width: 8 mm; Length: 332.678 mm; sets with these values: 2
Name | Center of gravity X (mm) | Phase | Class
GOUSSET | 38289 | 3 | 3005
GOUSSET | 49964 | 1 | 1005
GOUSSET | 61639 | 1 | 1005
GOUSSET | 26614 | 3 | 3005

# IfcPlate: PL8*132 (26)
In: Undefined
Description: PL8*132; Material: STEEL/S235JR
Tekla Common - Phase: 2; Class: 2005; Finish: GRENAILLE-PEINT; Grade: S235JR; Profile: PL8*132; Name: GOUSSET; sets with these values: 2
Tekla Quantity - Gross footprint area: 0 m2; Width: 8 mm; sets with these values: 2
Name | Center of gravity Z (mm) | Center of gravity Y (mm) | Center of gravity X (mm) | Bottom elevation | Top elevation | Part mark | Assembly mark | Net weight (kg) = Weight (kg) | Gross weight (kg) | Net volume (m3) = Gross volume (m3) | Area per tons (m2) | Net surface area (m2) | Gross area (m2) | Height (mm) | Length (mm)
GOUSSET | 3386.35 | 32300.9 | 15072.5 | +3.379 | +3.393 | 756 | K69 | 1.07728 | 1.65735 | 0.000137233 | 35.9964 | 0.0387782 | 0.0263909 | 131.955 | 200
GOUSSET | 3386.35 | 37524.1 | 15072.5 | +3.379 | +3.393 | 756 | K70 | 1.07728 | 1.65736 | 0.000137234 | 35.9964 | 0.0387784 | 0.0263911 | 131.956 | 200
GOUSSET | 3386.35 | 37638.4 | 15072.5 | +3.379 | +3.393 | 756 | K70 | 1.07728 | 1.65735 | 0.000137233 | 35.9964 | 0.0387782 | 0.0263909 | 131.955 | 200
GOUSSET | 3385.05 | 34978 | 15030.4 | +3.378 | +3.393 | 746 | K61 | 1.79176 | 2.0818 | 0.00022825 | 35.034 | 0.0627726 | 0.0331497 | 131.955 | 251.22
GOUSSET | 3386.35 | 34843.6 | 15072.5 | +3.378 | +3.395 | 757 | K61 | 2.49998 | 2.50626 | 0.000318469 | 34.5898 | 0.0864738 | 0.0399086 | 131.956 | 302.44
GOUSSET | 3385.05 | 45701.2 | 15030.4 | +3.378 | +3.393 | 747 | K60 | 1.79176 | 2.0818 | 0.00022825 | 35.034 | 0.0627726 | 0.0331497 | 131.955 | 251.22
GOUSSET | 3384.72 | 45829.5 | 15020 | +3.377 | +3.393 | 744 | K60 | 1.92702 | 2.31126 | 0.000245481 | 34.9627 | 0.0673739 | 0.0368035 | 131.955 | 278.91
GOUSSET | 3386.35 | 43065.5 | 15072.5 | +3.379 | +3.393 | 756 | K67 | 1.07728 | 1.65735 | 0.000137233 | 35.9964 | 0.0387782 | 0.0263909 | 131.955 | 200
GOUSSET | 3386.35 | 48467.8 | 15072.5 | +3.379 | +3.393 | 756 | K101 | 1.07728 | 1.65736 | 0.000137234 | 35.9964 | 0.0387784 | 0.0263911 | 131.956 | 200
GOUSSET | 3386.35 | 32186.6 | 15072.5 | +3.379 | +3.393 | 756 | K69 | 1.07728 | 1.65736 | 0.000137234 | 35.9964 | 0.0387784 | 0.0263911 | 131.956 | 200
GOUSSET | 3386.35 | 29643.9 | 15072.5 | +3.378 | +3.395 | 757 | K62 | 2.49998 | 2.50626 | 0.000318469 | 34.5898 | 0.0864738 | 0.0399086 | 131.956 | 302.44
GOUSSET | 3385.05 | 29509.5 | 15030.4 | +3.378 | +3.393 | 749 | K62 | 1.79176 | 2.0818 | 0.00022825 | 35.034 | 0.0627726 | 0.0331497 | 131.955 | 251.22
GOUSSET | 3386.35 | 27100.9 | 15072.5 | +3.379 | +3.393 | 756 | K71 | 1.07728 | 1.65735 | 0.000137233 | 35.9964 | 0.0387782 | 0.0263909 | 131.955 | 200
GOUSSET | 3386.35 | 26986.6 | 15072.5 | +3.379 | +3.393 | 756 | K71 | 1.07728 | 1.65736 | 0.000137234 | 35.9964 | 0.0387784 | 0.0263911 | 131.956 | 200
GOUSSET | 3386.35 | 22038.4 | 15072.5 | +3.379 | +3.393 | 756 | K71 | 1.07728 | 1.65735 | 0.000137233 | 35.9964 | 0.0387782 | 0.0263909 | 131.955 | 200
GOUSSET | 3386.35 | 21924.1 | 15072.5 | +3.379 | +3.393 | 756 | K71 | 1.07728 | 1.65736 | 0.000137234 | 35.9964 | 0.0387784 | 0.0263911 | 131.956 | 200
GOUSSET | 3385.05 | 24447 | 15030.4 | +3.378 | +3.393 | 749 | K65 | 1.79176 | 2.0818 | 0.00022825 | 35.034 | 0.0627726 | 0.0331497 | 131.955 | 251.22
GOUSSET | 3385.05 | 24578 | 15030.4 | +3.378 | +3.393 | 749 | K65 | 1.79176 | 2.0818 | 0.00022825 | 35.034 | 0.0627726 | 0.0331497 | 131.955 | 251.22
GOUSSET | 3385.05 | 19515.5 | 15030.4 | +3.378 | +3.393 | 749 | K66 | 1.79176 | 2.0818 | 0.00022825 | 35.034 | 0.0627726 | 0.0331497 | 131.955 | 251.22
GOUSSET | 3386.35 | 13117.2 | 15072.5 | +3.379 | +3.393 | 756 | K72 | 1.07728 | 1.65735 | 0.000137233 | 35.9964 | 0.0387782 | 0.0263909 | 131.955 | 200
GOUSSET | 3386.35 | 13002.8 | 15072.5 | +3.379 | +3.393 | 756 | K72 | 1.07728 | 1.65736 | 0.000137234 | 35.9964 | 0.0387784 | 0.0263911 | 131.956 | 200
GOUSSET | 3385.05 | 10995.5 | 15030.4 | +3.378 | +3.393 | 748 | K102 | 1.79176 | 2.0818 | 0.00022825 | 35.034 | 0.0627726 | 0.0331497 | 131.955 | 251.22
GOUSSET | 3386.35 | 17262.8 | 15072.5 | +3.379 | +3.393 | 756 | K68 | 1.07728 | 1.65736 | 0.000137234 | 35.9964 | 0.0387784 | 0.0263911 | 131.956 | 200
GOUSSET | 3385.07 | 15255 | 15031.1 | +3.378 | +3.393 | 745 | K63 | 1.7792 | 2.0818 | 0.00022665 | 35.0038 | 0.0622789 | 0.0331497 | 131.955 | 251.22
GOUSSET | 3385.07 | 15125 | 15031.1 | +3.378 | +3.393 | 745 | K63 | 1.7792 | 2.0818 | 0.00022665 | 35.0038 | 0.0622789 | 0.0331497 | 131.955 | 251.22
GOUSSET | 3385.05 | 40184.5 | 15030.4 | +3.378 | +3.393 | 746 | K64 | 1.79176 | 2.0818 | 0.00022825 | 35.034 | 0.0627726 | 0.0331497 | 131.955 | 251.22

# IfcPlate: PL8*135 (12)
In: Undefined
Description: PL8*135; Material: STEEL/E24-2
Tekla Common - Center of gravity Z: 4811.97 mm; Bottom elevation: +4.789; Top elevation: +4.839; Finish: GRENAILLE-PEINT; Grade: E24-2; Profile: PL8*135; Name: GOUSSET; sets with these values: 2
Tekla Quantity - Net weight: 2.19217 kg; Gross weight: 2.91285 kg; Weight: 2.19217 kg; Net volume: 0.000279257 m3; Gross volume: 0.000279257 m3; Gross footprint area: 0 m2; Area per tons: 34.9157 m2; Net surface area: 0.0765411 m2; Gross area: 0.046383 m2; Height: 135.3 mm; Width: 8 mm; Length: 342.816 mm; sets with these values: 2
Name | Center of gravity Y (mm) | Center of gravity X (mm) | Part mark | Assembly mark | Phase | Class
GOUSSET | 40314.9 | 38287.2 | 793 | K22 | 3 | 3005
GOUSSET | 40185.1 | 38287.2 | 793 | K22 | 3 | 3005
GOUSSET | 40185.1 | 61637.2 | 793 | K24 | 1 | 1005
GOUSSET | 40314.9 | 61637.2 | 793 | K24 | 1 | 1005
GOUSSET | 19514.9 | 61637.2 | 793 | K21 | 1 | 1005
GOUSSET | 19514.9 | 38287.2 | 793 | K21 | 3 | 3005
GOUSSET | 19514.9 | 49962.2 | 793 | K21 | 1 | 1005
GOUSSET | 40314.9 | 49962.2 | 793 | K22 | 1 | 1005
GOUSSET | 40185.1 | 49962.2 | 793 | K22 | 1 | 1005
GOUSSET | 40314.9 | 26612.2 | 794 | K23 | 3 | 3005
GOUSSET | 19514.9 | 26612.2 | 793 | K21 | 3 | 3005
GOUSSET | 40185.1 | 26612.2 | 793 | K23 | 3 | 3005

# IfcPlate: PL8*136 (11)
In: Undefined
Description: PL8*136; Material: STEEL/E24-2
Tekla Common - Finish: GRENAILLE-PEINT; Grade: E24-2; Profile: PL8*136; sets with these values: 2
Tekla Quantity - Gross footprint area: 0 m2; Width: 8 mm; sets with these values: 2
Name | Center of gravity Z (mm) | Center of gravity Y (mm) | Center of gravity X (mm) | Bottom elevation | Top elevation | Part mark | Assembly mark | Phase | Class | Name | Net weight (kg) = Weight (kg) | Gross weight (kg) | Net volume (m3) = Gross volume (m3) | Area per tons (m2) | Net surface area (m2) | Gross area (m2) | Height (mm) | Length (mm)
GOUSSET | 5195.51 | 2497.7 | 69675.6 | +5.189 | +5.204 | 813 | K38 | 1 | 1010 | GOUSSET | 1.16586 | 2.04694 | 0.000148517 | 36.1993 | 0.0422032 | 0.0325946 | 135.812 | 239.998
PLAT | 10494.6 | 66433.4 | 20364 | +10.420 | +10.556 | 821 | K103 | 2 | 2005 | PLAT | 1.20895 | 1.5632 | 0.000154006 | 35.5795 | 0.0430138 | 0.0248918 | 136.393 | 182.501
PLAT | 10319.2 | 50006.6 | 26023 | +10.244 | +10.381 | 821 | K104 | 2 | 2005 | PLAT | 1.20895 | 1.5632 | 0.000154006 | 35.5795 | 0.0430138 | 0.0248918 | 136.393 | 182.501
PLAT | 10319.2 | 66433.4 | 26023 | +10.244 | +10.381 | 821 | K103 | 2 | 2005 | PLAT | 1.20895 | 1.5632 | 0.000154006 | 35.5795 | 0.0430138 | 0.0248918 | 136.393 | 182.501
PLAT | 10406.8 | 66433.4 | 23195 | +10.332 | +10.468 | 821 | K103 | 2 | 2005 | PLAT | 1.20895 | 1.5632 | 0.000154006 | 35.5795 | 0.0430138 | 0.0248918 | 136.393 | 182.501
PLAT | 10406.8 | 50056.6 | 23195 | +10.332 | +10.468 | 821 | K105 | 2 | 2005 | PLAT | 1.20895 | 1.5632 | 0.000154006 | 35.5795 | 0.0430138 | 0.0248918 | 136.393 | 182.501
PLAT | 10494.6 | 50056.6 | 20364 | +10.420 | +10.556 | 821 | K105 | 2 | 2005 | PLAT | 1.20895 | 1.5632 | 0.000154006 | 35.5795 | 0.0430138 | 0.0248918 | 136.393 | 182.501
PLAT | 10231.5 | 66433.4 | 28851 | +10.156 | +10.293 | 821 | K103 | 2 | 2005 | PLAT | 1.20895 | 1.5632 | 0.000154006 | 35.5795 | 0.0430138 | 0.0248918 | 136.393 | 182.501
PLAT | 10143.8 | 66433.4 | 31679 | +10.069 | +10.205 | 821 | K103 | 2 | 2005 | PLAT | 1.20895 | 1.5632 | 0.000154006 | 35.5795 | 0.0430138 | 0.0248918 | 136.393 | 182.501
PLAT | 10143.8 | 50006.6 | 31679 | +10.069 | +10.205 | 821 | K104 | 2 | 2005 | PLAT | 1.20895 | 1.5632 | 0.000154006 | 35.5795 | 0.0430138 | 0.0248918 | 136.393 | 182.501
PLAT | 10231.5 | 50006.6 | 28851 | +10.156 | +10.293 | 821 | K104 | 2 | 2005 | PLAT | 1.20895 | 1.5632 | 0.000154006 | 35.5795 | 0.0430138 | 0.0248918 | 136.393 | 182.501

# IfcPlate: PL8*137 (8)
In: Undefined
Description: PL8*137; Material: STEEL/E24-2
Tekla Common - Part mark: 818; Assembly mark: B9; Phase: 2; Class: 2004; Finish: GRENAILLE-PEINT; Grade: E24-2; Profile: PL8*137; Name: GOUSSET; sets with these values: 2
Tekla Quantity - Net weight: 1.33518 kg; Gross weight: 2.27522 kg; Weight: 1.33518 kg; Net volume: 0.000170086 m3; Gross volume: 0.000170086 m3; Gross footprint area: 0 m2; Area per tons: 35.7959 m2; Net surface area: 0.0477938 m2; Gross area: 0.0362296 m2; Height: 137.029 mm; Width: 8 mm; Length: 264.394 mm; sets with these values: 2
Name | Center of gravity Z (mm) | Center of gravity Y (mm) | Center of gravity X (mm) | Bottom elevation | Top elevation
GOUSSET | 10230.4 | 61107.4 | 26083.8 | +10.225 | +10.237
GOUSSET | 10224.6 | 60862.6 | 26271.2 | +10.218 | +10.230
GOUSSET | 10224.6 | 61107.4 | 26271.2 | +10.218 | +10.230
GOUSSET | 10230.4 | 60862.6 | 26083.8 | +10.225 | +10.237
GOUSSET | 10230.4 | 55577.4 | 26083.8 | +10.225 | +10.237
GOUSSET | 10224.6 | 55577.4 | 26271.2 | +10.218 | +10.230
GOUSSET | 10230.4 | 55332.6 | 26083.8 | +10.225 | +10.237
GOUSSET | 10224.6 | 55332.6 | 26271.2 | +10.218 | +10.230

# IfcPlate: PL8*143 (4)
In: Undefined
Description: PL8*143; Material: STEEL/S235JR
Tekla Common - Center of gravity Z: 10421.5 mm; Center of gravity X: 19921.8 mm; Bottom elevation: +10.413; Top elevation: +10.428; Part mark: 817; Assembly mark: K33; Phase: 2; Class: 2005; Finish: GRENAILLE-PEINT; Grade: S235JR; Profile: PL8*143; Name: GOUSSET; sets with these values: 2
Tekla Quantity - Net weight: 1.37076 kg; Gross weight: 2.05597 kg; Weight: 1.37076 kg; Net volume: 0.000174619 m3; Gross volume: 0.000174619 m3; Gross footprint area: 0 m2; Area per tons: 35.5165 m2; Net surface area: 0.0486846 m2; Gross area: 0.0327384 m2; Height: 143.456 mm; Width: 8 mm; Length: 228.212 mm; sets with these values: 2
Name | Center of gravity Y (mm)
GOUSSET | 61045.6
GOUSSET | 60924.4
GOUSSET | 55515.6
GOUSSET | 55394.4

# IfcPlate: PL8*145 (2)
In: Undefined
Description: PL8*145; Material: STEEL/E24-2
Tekla Common - Center of gravity Z: 4791.83 mm; Center of gravity X: 79002.8 mm; Bottom elevation: +4.784; Top elevation: +4.800; Part mark: 795; Phase: 1; Class: 1010; Finish: GRENAILLE-PEINT; Grade: E24-2; Profile: PL8*145; Name: GOUSSET; sets with these values: 2
Tekla Quantity - Net weight: 1.7997 kg; Gross weight: 2.38729 kg; Weight: 1.7997 kg; Net volume: 0.000229262 m3; Gross volume: 0.000229262 m3; Gross footprint area: 0 m2; Area per tons: 35.0534 m2; Net surface area: 0.0630857 m2; Gross area: 0.0380142 m2; Height: 145.013 mm; Width: 8 mm; Length: 262.144 mm; sets with these values: 2
Name | Center of gravity Y (mm) | Assembly mark
GOUSSET | 4963.41 | K3
GOUSSET | 136.589 | K28

# IfcPlate: PL8*148 (2)
In: Undefined
Description: PL8*148; Material: STEEL/S235JR
Tekla Common - Center of gravity Z: 3414.95 mm; Center of gravity X: 9378.61 mm; Bottom elevation: +3.354; Top elevation: +3.502; Part mark: 845; Phase: 2; Class: 2005; Finish: GRENAILLE-PEINT; Grade: S235JR; Profile: PL8*148; Name: GOUSSET; sets with these values: 2
Tekla Quantity - Net weight: 1.06348 kg; Gross weight: 1.83577 kg; Weight: 1.06348 kg; Net volume: 0.000135475 m3; Gross volume: 0.000135475 m3; Gross footprint area: 0.0006792 m2; Area per tons: 36.9391 m2; Net surface area: 0.039284 m2; Gross area: 0.029232 m2; Height: 148.33 mm; Width: 8 mm; Length: 197.075 mm; sets with these values: 2
Name | Center of gravity Y (mm) | Assembly mark
GOUSSET | 10930 | K102
GOUSSET | 48525 | K101

# IfcPlate: PL8*152, ATTACHE
In: Undefined
Description: PL8*152; Material: STEEL/E24-2
Tekla Common - Center of gravity Z: 3943.22 mm; Center of gravity Y: 10022 mm; Center of gravity X: 118.31 mm; Bottom elevation: +3.818; Top elevation: +4.028; Part mark: 681; Assembly mark: L52; Phase: 2; Class: 2003; Finish: GRENAILLE-PEINT; Grade: E24-2; Profile: PL8*152; Name: ATTACHE; sets with these values: 2
Tekla Quantity - Net weight: 1.53296 kg; Gross weight: 2.01179 kg; Weight: 1.53296 kg; Net volume: 0.000195281 m3; Gross volume: 0.000195281 m3; Gross footprint area: 0 m2; Area per tons: 35.2508 m2; Net surface area: 0.054038 m2; Gross area: 0.0320349 m2; Height: 152.498 mm; Width: 8 mm; Length: 210.067 mm; sets with these values: 2

# IfcPlate: PL8*160 (3)
In: Undefined
Description: PL8*160; Material: STEEL/E24-2
Tekla Common - Finish: GRENAILLE-PEINT; Grade: E24-2; Profile: PL8*160; Name: GOUSSET; sets with these values: 2
Tekla Quantity - Gross footprint area: 0 m2; Width: 8 mm; sets with these values: 2
Name | Center of gravity Z (mm) | Center of gravity Y (mm) | Center of gravity X (mm) | Bottom elevation | Top elevation | Part mark = Assembly mark | Phase | Class | Net weight (kg) = Weight (kg) | Gross weight (kg) | Net volume (m3) = Gross volume (m3) | Area per tons (m2) | Net surface area (m2) | Gross area (m2) | Height (mm) | Length (mm)
GOUSSET | 5495.54 | 47990.1 | 21015.6 | +5.482 | +5.509 | G63 | 3 | 3004 | 2.19791 | 2.3895 | 0.000279989 | 34.5229 | 0.0758783 | 0.0380494 | 160.001 | 237.808
GOUSSET | 10223.5 | 50003.2 | 26177.4 | +10.214 | +10.233 | G30 | 2 | 2004 | 3.5599 | 3.65396 | 0.000453491 | 34.1002 | 0.121393 | 0.058184 | 159.819 | 364.063
GOUSSET | 10223.5 | 66436.8 | 26177.4 | +10.214 | +10.233 | G30 | 2 | 2004 | 3.5599 | 3.65396 | 0.000453491 | 34.1002 | 0.121393 | 0.058184 | 159.819 | 364.063

# IfcPlate: PL8*162 (2)
In: Undefined
Description: PL8*162; Material: STEEL/E24-2
Tekla Common - Center of gravity Z: 4618.61 mm; Center of gravity X: 79225 mm; Bottom elevation: +4.508; Top elevation: +4.774; Part mark: 798; Phase: 1; Class: 1011; Finish: GRENAILLE-PEINT; Grade: E24-2; Profile: PL8*162; Name: GOUSSET; sets with these values: 2
Tekla Quantity - Net weight: 1.85709 kg; Gross weight: 2.69724 kg; Weight: 1.85709 kg; Net volume: 0.000236572 m3; Gross volume: 0.000236572 m3; Gross footprint area: 0.00032 m2; Area per tons: 35.0467 m2; Net surface area: 0.0650848 m2; Gross area: 0.0429496 m2; Height: 161.561 mm; Width: 8 mm; Length: 265.842 mm; sets with these values: 2
Name | Center of gravity Y (mm) | Assembly mark
GOUSSET | 7713.51 | P6
GOUSSET | 13486.5 | P8

# IfcPlate: PL8*163, GOUSSET
In: Undefined
Description: PL8*163; Material: STEEL/E24-2
Tekla Common - Center of gravity Z: 5033.66 mm; Center of gravity Y: 33750 mm; Center of gravity X: 71497.1 mm; Bottom elevation: +5.013; Top elevation: +5.054; Part mark: G53; Assembly mark: G53; Phase: 1; Class: 1009; Finish: GRENAILLE-PEINT; Grade: E24-2; Profile: PL8*163; Name: GOUSSET; sets with these values: 2
Tekla Quantity - Net weight: 2.43946 kg; Gross weight: 3.02295 kg; Weight: 2.43946 kg; Net volume: 0.000310759 m3; Gross volume: 0.000310759 m3; Gross footprint area: 0 m2; Area per tons: 34.3851 m2; Net surface area: 0.0838812 m2; Gross area: 0.0481361 m2; Height: 162.713 mm; Width: 8 mm; Length: 295.835 mm; sets with these values: 2

# IfcPlate: PL8*169 (4)
In: Undefined
Description: PL8*169; Material: STEEL/E24-2
Tekla Common - Part mark: G17; Assembly mark: G17; Phase: 2; Class: 2004; Finish: GRENAILLE-PEINT; Grade: E24-2; Profile: PL8*169; Name: GOUSSET; sets with these values: 2
Tekla Quantity - Net weight: 2.41204 kg; Gross weight: 2.97262 kg; Weight: 2.41204 kg; Net volume: 0.000307266 m3; Gross volume: 0.000307266 m3; Gross footprint area: 0 m2; Area per tons: 34.4964 m2; Net surface area: 0.0832066 m2; Gross area: 0.0473347 m2; Height: 169.397 mm; Width: 8 mm; Length: 279.431 mm; sets with these values: 2
Name | Center of gravity Z (mm) | Center of gravity Y (mm) | Center of gravity X (mm) | Bottom elevation | Top elevation
GOUSSET | 3735.1 | 29616.6 | 106.247 | +3.728 | +3.742
GOUSSET | 3735.1 | 34870.9 | 106.247 | +3.728 | +3.742
GOUSSET | 3417.2 | 29616.6 | 9188.75 | +3.410 | +3.424
GOUSSET | 3417.2 | 34870.9 | 9188.75 | +3.410 | +3.424

# IfcPlate: PL8*170 (6)
In: Undefined
Description: PL8*170; Material: STEEL/E24-2
Tekla Common - Phase: 1; Finish: GRENAILLE-PEINT; Grade: E24-2; Profile: PL8*170; Name: GOUSSET; sets with these values: 2
Tekla Quantity - Gross footprint area: 0 m2; Width: 8 mm; sets with these values: 2
Name | Center of gravity Z (mm) | Center of gravity Y (mm) | Center of gravity X (mm) | Bottom elevation | Top elevation | Part mark | Assembly mark | Class | Net weight (kg) = Weight (kg) | Gross weight (kg) | Net volume (m3) = Gross volume (m3) | Area per tons (m2) | Net surface area (m2) | Gross area (m2) | Height (mm) | Length (mm)
GOUSSET | 5136.3 | 5100 | 67632.5 | +5.129 | +5.143 | 839 | N14 | 1006 | 2.67897 | 2.93802 | 0.00034127 | 34.2363 | 0.0917178 | 0.0467837 | 169.752 | 275.6
GOUSSET | 5136.3 | 10010 | 67632.5 | +5.129 | +5.143 | 838 | N12 | 1006 | 2.67897 | 2.93802 | 0.00034127 | 34.2363 | 0.0917178 | 0.0467837 | 169.752 | 275.6
GOUSSET | 5011.91 | 14730 | 71645.1 | +5.005 | +5.019 | G49 | G49 | 1009 | 4.37716 | 4.37716 | 0.0005576 | 33.9672 | 0.14868 | 0.0697 | 170 | 410
GOUSSET | 5136.3 | 14730 | 67632.5 | +5.129 | +5.143 | 711 | N12 | 1006 | 2.67897 | 2.93802 | 0.00034127 | 34.2363 | 0.0917178 | 0.0467837 | 169.752 | 275.6
GOUSSET | 5011.91 | 10010 | 71645.1 | +5.005 | +5.019 | G49 | G49 | 1009 | 4.37716 | 4.37716 | 0.0005576 | 33.9672 | 0.14868 | 0.0697 | 170 | 410
GOUSSET | 5136.18 | 27.569 | 67636.3 | +5.129 | +5.143 | 772 | P24 | 1001 | 2.12487 | 2.24733 | 0.000270684 | 34.5751 | 0.0734676 | 0.0357855 | 169.752 | 210.81

# IfcPlate: PL8*171, GOUSSET
In: Undefined
Description: PL8*171; Material: STEEL/E24-2
Tekla Common - Center of gravity Z: 5009.57 mm; Center of gravity Y: 13550 mm; Center of gravity X: 71720.6 mm; Bottom elevation: +5.003; Top elevation: +5.016; Part mark: 732; Assembly mark: P123; Phase: 1; Class: 1011; Finish: GRENAILLE-PEINT; Grade: E24-2; Profile: PL8*171; Name: GOUSSET; sets with these values: 2
Tekla Quantity - Net weight: 3.99562 kg; Gross weight: 5.16591 kg; Weight: 3.99562 kg; Net volume: 0.000508996 m3; Gross volume: 0.000508996 m3; Gross footprint area: 0 m2; Area per tons: 34.936 m2; Net surface area: 0.139591 m2; Gross area: 0.0822597 m2; Height: 171.374 mm; Width: 8 mm; Length: 480 mm; sets with these values: 2

# IfcPlate: PL8*172, GOUSSET
In: Undefined
Description: PL8*172; Material: STEEL/E24-2
Tekla Common - Center of gravity Z: 5127.05 mm; Center of gravity Y: 25950 mm; Center of gravity X: 70732.4 mm; Bottom elevation: +5.110; Top elevation: +5.144; Part mark: G55; Assembly mark: G55; Phase: 1; Class: 1009; Finish: GRENAILLE-PEINT; Grade: E24-2; Profile: PL8*172; Name: GOUSSET; sets with these values: 2
Tekla Quantity - Net weight: 2.50236 kg; Gross weight: 3.15956 kg; Weight: 2.50236 kg; Net volume: 0.000318772 m3; Gross volume: 0.000318772 m3; Gross footprint area: 0 m2; Area per tons: 34.3336 m2; Net surface area: 0.085915 m2; Gross area: 0.0503115 m2; Height: 171.602 mm; Width: 8 mm; Length: 293.186 mm; sets with these values: 2

# IfcPlate: PL8*173 (4)
In: Undefined
Description: PL8*173
Tekla Common - Finish: GRENAILLE-PEINT; Profile: PL8*173; Name: GOUSSET; sets with these values: 2
Tekla Quantity - Width: 8 mm; sets with these values: 2
Name | Material | Center of gravity Z (mm) | Center of gravity Y (mm) | Center of gravity X (mm) | Bottom elevation | Top elevation | Part mark | Assembly mark | Phase | Class | Grade | Net weight (kg) = Weight (kg) | Gross weight (kg) | Net volume (m3) = Gross volume (m3) | Gross footprint area (m2) | Area per tons (m2) | Net surface area (m2) | Gross area (m2) | Height (mm) | Length (mm)
GOUSSET | STEEL/S235JR | 3559.9 | 34841.3 | 20670.8 | +3.551 | +3.567 | 827 | K61 | 2 | 2005 | S235JR | 1.68951 | 2.73637 | 0.000215224 | 0 | 35.2001 | 0.0594708 | 0.0435728 | 172.846 | 252.09
GOUSSET | STEEL/S235JR | 3559.9 | 29646.2 | 20670.8 | +3.551 | +3.567 | 827 | K62 | 2 | 2005 | S235JR | 1.68951 | 2.73637 | 0.000215224 | 0 | 35.2001 | 0.0594708 | 0.0435728 | 172.846 | 252.09
GOUSSET | STEEL/E24-2 | -290.482 | 7735.59 | 79225 | -0.388 | -0.215 | 797 | P6 | 1 | 1011 | E24-2 | 1.69484 | 2.2487 | 0.000215903 | 0.00139682 | 34.9454 | 0.059227 | 0.0358073 | 172.874 | 207.129
GOUSSET | STEEL/E24-2 | -290.482 | 13464.4 | 79225 | -0.388 | -0.215 | 797 | P8 | 1 | 1011 | E24-2 | 1.69484 | 2.2487 | 0.000215903 | 0.00139682 | 34.9454 | 0.059227 | 0.0358073 | 172.874 | 207.129

# IfcPlate: PL8*174 (2)
In: Undefined
Description: PL8*174; Material: STEEL/E24-2
Tekla Common - Bottom elevation: +5.336; Top elevation: +5.510; Phase: 1; Class: 1001; Finish: GRENAILLE-PEINT; Grade: E24-2; Profile: PL8*174; sets with these values: 2
Tekla Quantity - Gross footprint area: 0 m2; Height: 174.161 mm; Width: 8 mm; sets with these values: 2
Name | Center of gravity Z (mm) | Center of gravity Y (mm) | Center of gravity X (mm) | Part mark | Assembly mark | Net weight (kg) = Weight (kg) | Gross weight (kg) | Net volume (m3) = Gross volume (m3) | Area per tons (m2) | Net surface area (m2) | Gross area (m2) | Length (mm)
 | 5414.09 | -2.36634e-16 | 44335.2 | 857 | P22 | 2.67761 | 3.17152 | 0.000341096 | 34.3468 | 0.0919673 | 0.0505018 | 289.973
 | 5418.06 | 69150 | 44318.6 | 764 | P26 | 2.35393 | 2.68405 | 0.000299864 | 34.4625 | 0.0811223 | 0.0427397 | 245.404

# IfcPlate: PL8*176 (6)
In: Undefined
Description: PL8*176; Material: STEEL/E24-2
Tekla Common - Finish: GRENAILLE-PEINT; Grade: E24-2; Profile: PL8*176; Name: GOUSSET; sets with these values: 2
Tekla Quantity - Gross footprint area: 0 m2; Width: 8 mm; sets with these values: 2
Name | Center of gravity Z (mm) | Center of gravity Y (mm) | Center of gravity X (mm) | Bottom elevation | Top elevation | Part mark = Assembly mark | Phase | Class | Net weight (kg) = Weight (kg) | Gross weight (kg) | Net volume (m3) = Gross volume (m3) | Area per tons (m2) | Net surface area (m2) | Gross area (m2) | Height (mm) | Length (mm)
GOUSSET | 5387.89 | 31173.5 | 68597 | +5.371 | +5.405 | G51 | 1 | 1009 | 2.45814 | 3.10994 | 0.000313139 | 34.3293 | 0.0843863 | 0.0495213 | 176.165 | 281.107
GOUSSET | 5390.16 | 33750 | 68578.4 | +5.373 | +5.407 | G50 | 1 | 1009 | 2.45814 | 3.10994 | 0.000313139 | 34.3293 | 0.0843863 | 0.0495213 | 176.165 | 281.107
GOUSSET | 10033.8 | 66447.8 | 32426.6 | +10.027 | +10.040 | G29 | 2 | 2004 | 1.45892 | 2.03928 | 0.000185849 | 35.229 | 0.0513962 | 0.0324726 | 176.027 | 184.476
GOUSSET | 10419.5 | 50042.2 | 19986 | +10.413 | +10.427 | G29 | 2 | 2004 | 1.45892 | 2.03928 | 0.000185849 | 35.229 | 0.0513962 | 0.0324726 | 176.027 | 184.476
GOUSSET | 10421.3 | 66447.8 | 19928.4 | +10.415 | +10.428 | G29 | 2 | 2004 | 1.45892 | 2.03928 | 0.000185849 | 35.229 | 0.0513962 | 0.0324726 | 176.027 | 184.476
GOUSSET | 10033.8 | 49992.2 | 32426.6 | +10.027 | +10.040 | G29 | 2 | 2004 | 1.45892 | 2.03928 | 0.000185849 | 35.229 | 0.0513962 | 0.0324726 | 176.027 | 184.476

# IfcPlate: PL8*182 (3)
In: Undefined
Description: PL8*182; Material: STEEL/E24-2
Tekla Common - Phase: 1; Finish: GRENAILLE-PEINT; Grade: E24-2; Profile: PL8*182; Name: GOUSSET; sets with these values: 2
Tekla Quantity - Gross footprint area: 0 m2; Width: 8 mm; sets with these values: 2
Name | Center of gravity Z (mm) | Center of gravity Y (mm) | Center of gravity X (mm) | Bottom elevation | Top elevation | Part mark = Assembly mark | Class | Net weight (kg) = Weight (kg) | Gross weight (kg) | Net volume (m3) = Gross volume (m3) | Area per tons (m2) | Net surface area (m2) | Gross area (m2) | Height (mm) | Length (mm)
GOUSSET | 5383.06 | 28574.7 | 68636.5 | +5.365 | +5.401 | G52 | 1009 | 2.55846 | 3.31415 | 0.000325919 | 34.2897 | 0.0877289 | 0.052773 | 182.359 | 289.39
GOUSSET | 2232.4 | 7650 | 50890.8 | +2.108 | +2.356 | G28 | 1002 | 4.00549 | 5.02156 | 0.000510253 | 33.9817 | 0.136113 | 0.0799612 | 182.152 | 438.979
GOUSSET | 2232.4 | 61050 | 50890.8 | +2.108 | +2.356 | G28 | 1002 | 4.00549 | 5.02156 | 0.000510253 | 33.9817 | 0.136113 | 0.0799612 | 182.152 | 438.979

# IfcPlate: PL8*183, GOUSSET
In: Undefined
Description: PL8*183; Material: STEEL/E24-2
Tekla Common - Center of gravity Z: 5016.21 mm; Center of gravity Y: 24649.5 mm; Center of gravity X: 71640 mm; Bottom elevation: +5.001; Top elevation: +5.031; Part mark: G5; Assembly mark: G5; Phase: 1; Class: 1009; Finish: GRENAILLE-PEINT; Grade: E24-2; Profile: PL8*183; Name: GOUSSET; sets with these values: 2
Tekla Quantity - Net weight: 4.63098 kg; Gross weight: 4.71834 kg; Weight: 4.63098 kg; Net volume: 0.000589934 m3; Gross volume: 0.000589934 m3; Gross footprint area: 0 m2; Area per tons: 33.832 m2; Net surface area: 0.156675 m2; Gross area: 0.0751329 m2; Height: 183.251 mm; Width: 8 mm; Length: 410 mm; sets with these values: 2

# IfcPlate: PL8*184, GOUSSET
In: Undefined
Description: PL8*184; Material: STEEL/E24-2
Tekla Common - Center of gravity Z: 5015.63 mm; Center of gravity Y: 19455.7 mm; Center of gravity X: 71644.7 mm; Bottom elevation: +5.001; Top elevation: +5.032; Part mark: G4; Assembly mark: G4; Phase: 1; Class: 1009; Finish: GRENAILLE-PEINT; Grade: E24-2; Profile: PL8*184; Name: GOUSSET; sets with these values: 2
Tekla Quantity - Net weight: 4.37853 kg; Gross weight: 4.74423 kg; Weight: 4.37853 kg; Net volume: 0.000557774 m3; Gross volume: 0.000557774 m3; Gross footprint area: 0 m2; Area per tons: 33.9122 m2; Net surface area: 0.148486 m2; Gross area: 0.0755451 m2; Height: 184.256 mm; Width: 8 mm; Length: 410 mm; sets with these values: 2

# IfcPlate: PL8*189 (4)
In: Undefined
Description: PL8*189; Material: STEEL/E24-2
Tekla Common - Finish: GRENAILLE-PEINT; Grade: E24-2; Profile: PL8*189; Name: GOUSSET; sets with these values: 2
Tekla Quantity - Gross footprint area: 0 m2; Width: 8 mm; sets with these values: 2
Name | Center of gravity Z (mm) | Center of gravity Y (mm) | Center of gravity X (mm) | Bottom elevation | Top elevation | Part mark | Assembly mark | Phase | Class | Net weight (kg) = Weight (kg) | Gross weight (kg) | Net volume (m3) = Gross volume (m3) | Area per tons (m2) | Net surface area (m2) | Gross area (m2) | Height (mm) | Length (mm)
GOUSSET | 4766.04 | 61138.7 | 38358 | +4.750 | +4.782 | 705 | K1 | 3 | 3005 | 1.67933 | 2.81342 | 0.000213928 | 35.1559 | 0.0590386 | 0.0447996 | 189.338 | 236.611
GOUSSET | 4766.04 | 60961.3 | 38358 | +4.750 | +4.782 | 704 | K1 | 3 | 3005 | 1.67933 | 2.81342 | 0.000213928 | 35.1559 | 0.0590386 | 0.0447996 | 189.338 | 236.611
GOUSSET | 5380.49 | 25950 | 68657.5 | +5.362 | +5.399 | G54 | G54 | 1 | 1009 | 2.56961 | 3.40144 | 0.000327339 | 34.2817 | 0.0880908 | 0.054163 | 188.886 | 286.749
GOUSSET | 5273.39 | 32372.4 | 69534.4 | +5.250 | +5.288 | 814 | K99 | 1 | 1010 | 1.7816 | 2.96933 | 0.000226955 | 35.2795 | 0.062854 | 0.0472824 | 189.13 | 250

# IfcPlate: PL8*195 (4)
In: Undefined
Description: PL8*195; Material: STEEL/S235JR
Tekla Common - Center of gravity Z: 10033.4 mm; Center of gravity X: 32438.4 mm; Bottom elevation: +10.025; Top elevation: +10.042; Part mark: 730; Assembly mark: K33; Phase: 2; Class: 2005; Finish: GRENAILLE-PEINT; Grade: S235JR; Profile: PL8*195; Name: GOUSSET; sets with these values: 2
Tekla Quantity - Net weight: 1.37498 kg; Gross weight: 2.74996 kg; Weight: 1.37498 kg; Net volume: 0.000175157 m3; Gross volume: 0.000175157 m3; Gross footprint area: 0 m2; Area per tons: 36.0187 m2; Net surface area: 0.049525 m2; Gross area: 0.0437892 m2; Height: 194.965 mm; Width: 8 mm; Length: 224.6 mm; sets with these values: 2
Name | Center of gravity Y (mm)
GOUSSET | 60932.2
GOUSSET | 55507.8
GOUSSET | 61037.8
GOUSSET | 55402.2

# IfcPlate: PL8*196, GOUSSET
In: Undefined
Description: PL8*196; Material: STEEL/E24-2
Tekla Common - Center of gravity Z: 5017.05 mm; Center of gravity Y: 2492.88 mm; Center of gravity X: 75432.6 mm; Bottom elevation: +5.007; Top elevation: +5.026; Part mark: 733; Assembly mark: K38; Phase: 1; Class: 1010; Finish: GRENAILLE-PEINT; Grade: E24-2; Profile: PL8*196; Name: GOUSSET; sets with these values: 2
Tekla Quantity - Net weight: 1.79339 kg; Gross weight: 3.59305 kg; Weight: 1.79339 kg; Net volume: 0.000228457 m3; Gross volume: 0.000228457 m3; Gross footprint area: 0 m2; Area per tons: 35.5656 m2; Net surface area: 0.0637828 m2; Gross area: 0.0572142 m2; Height: 196.074 mm; Width: 8 mm; Length: 291.799 mm; sets with these values: 2

# IfcPlate: PL8*200 (3)
In: Undefined
Description: PL8*200; Material: STEEL/E24-2
Tekla Common - Bottom elevation: +3.744; Top elevation: +3.758; Phase: 1; Class: 1009; Finish: GRENAILLE-PEINT; Grade: E24-2; Profile: PL8*200; Name: GOUSSET; sets with these values: 2
Tekla Quantity - Gross footprint area: 0 m2; Height: 200 mm; Width: 8 mm; sets with these values: 2
Name | Center of gravity Z (mm) | Center of gravity Y (mm) | Center of gravity X (mm) | Part mark = Assembly mark | Net weight (kg) = Weight (kg) | Gross weight (kg) | Net volume (m3) = Gross volume (m3) | Area per tons (m2) | Net surface area (m2) | Gross area (m2) | Length (mm)
GOUSSET | 3750.88 | 26019.8 | 71976.3 | G14 | 2.20249 | 2.66755 | 0.000280573 | 34.5983 | 0.0762024 | 0.042477 | 212.385
GOUSSET | 3750.73 | 21883.3 | 71981.3 | G64 | 2.89787 | 3.82798 | 0.000369155 | 34.2623 | 0.0992875 | 0.0609551 | 304.775
GOUSSET | 3750.73 | 17716.7 | 71981.3 | G64 | 2.89787 | 3.82798 | 0.000369155 | 34.2623 | 0.0992875 | 0.0609551 | 304.775

# IfcPlate: PL8*203, GOUSSET
In: Undefined
Description: PL8*203; Material: STEEL/E24-2
