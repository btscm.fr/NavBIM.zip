Properties of the parts of a building model (IFC2X3), part 9 of 32

# IfcBeam: L70*7 (412)
Name | Material | Center of gravity Z (mm) | Center of gravity Y (mm) | Center of gravity X (mm) | Bottom elevation | Top elevation | Part mark | Assembly mark | Phase | Class | Finish | Grade | Name | Net weight (kg) = NetWeight (kg) | Gross weight (kg) = Weight (kg) | Net volume (m3) = NetVolume (m3) | Gross volume (m3) | Gross footprint area (m2) | Net surface area (m2) | Gross area (m2) = OuterSurfaceArea (m2) | Tekla Quantity, Length (mm) = BaseQuantities, Length (mm)
STABILITE | STEEL/E24-2 | 927.541 | 69125.9 | 52948 | -0.362 | +2.244 | V15 | V15 | 1 | 1002 | GRENAILLE-PEINT | E24-2 | STABILITE | 45.0727 | 45.4789 | 0.00574174 | 0.00579349 | 0 | 1.7287 | 1.67641 | 6163.29
STABILITE | STEEL/E24-2 | 927.541 | 69174.1 | 52948 | -0.362 | +2.244 | V15 | V15 | 1 | 1002 | GRENAILLE-PEINT | E24-2 | STABILITE | 45.0727 | 45.4789 | 0.00574174 | 0.00579349 | 0 | 1.7287 | 1.67641 | 6163.29
 | STEEL/E24-2 | 4956.47 | 54.9211 | 78355.1 | +4.817 | +5.095 | 615 | K28 | 1 | 1010 | GRENAILLE-PEINT | E24-2 |  | 2.01515 | 2.05064 | 0.000256707 | 0.000261228 | 0 | 0.079068 | 0.0755895 | 277.902
 | STEEL/E24-2 | 5097.06 | 54.9211 | 73820.1 | +4.958 | +5.236 | 615 | K28 | 1 | 1010 | GRENAILLE-PEINT | E24-2 |  | 2.01515 | 2.05064 | 0.000256707 | 0.000261228 | 0 | 0.079068 | 0.0755895 | 277.902
CSV | STEEL/E24-2 | 3411.04 | 11995 | 15091.7 | +3.389 | +3.462 | C134 | C134 | 2 | 2004 | GRENAILLE-PEINT | E24-2 | CSV | 15.3475 | 15.4959 | 0.0019551 | 0.001974 | 0 | 0.589862 | 0.5712 | 2100
CSV | STEEL/E24-2 | 3411.04 | 14125 | 15091.7 | +3.389 | +3.462 | C134 | C134 | 2 | 2004 | GRENAILLE-PEINT | E24-2 | CSV | 15.3475 | 15.4959 | 0.0019551 | 0.001974 | 0 | 0.589862 | 0.5712 | 2100
CSV | STEEL/E24-2 | 3411.04 | 16255 | 15091.7 | +3.389 | +3.462 | C134 | C134 | 2 | 2004 | GRENAILLE-PEINT | E24-2 | CSV | 15.3475 | 15.4959 | 0.0019551 | 0.001974 | 0 | 0.589862 | 0.5712 | 2100
CSV | STEEL/E24-2 | 3411.04 | 20715.6 | 15091.7 | +3.389 | +3.462 | C112 | C112 | 2 | 2004 | GRENAILLE-PEINT | E24-2 | CSV | 18.28 | 18.4567 | 0.00232866 | 0.00235118 | 0 | 0.702212 | 0.68034 | 2501.25
CSV | STEEL/E24-2 | 3362.9 | 20715.6 | 15093.2 | +3.313 | +3.384 | C112 | C112 | 2 | 2004 | GRENAILLE-PEINT | E24-2 | CSV | 18.28 | 18.4567 | 0.00232866 | 0.00235118 | 0 | 0.702212 | 0.68034 | 2501.25
CSV | STEEL/E24-2 | 3411.04 | 23246.9 | 15091.7 | +3.389 | +3.462 | C112 | C112 | 2 | 2004 | GRENAILLE-PEINT | E24-2 | CSV | 18.28 | 18.4567 | 0.00232866 | 0.00235118 | 0 | 0.702212 | 0.68034 | 2501.25
CSV | STEEL/E24-2 | 3362.9 | 23246.9 | 15093.2 | +3.313 | +3.384 | C112 | C112 | 2 | 2004 | GRENAILLE-PEINT | E24-2 | CSV | 18.28 | 18.4567 | 0.00232866 | 0.00235118 | 0 | 0.702212 | 0.68034 | 2501.25
CSV | STEEL/E24-2 | 3411.04 | 25778.1 | 15091.7 | +3.389 | +3.462 | C112 | C112 | 2 | 2004 | GRENAILLE-PEINT | E24-2 | CSV | 18.28 | 18.4567 | 0.00232866 | 0.00235118 | 0 | 0.702212 | 0.68034 | 2501.25
CSV | STEEL/E24-2 | 3362.9 | 25778.1 | 15093.2 | +3.313 | +3.384 | C112 | C112 | 2 | 2004 | GRENAILLE-PEINT | E24-2 | CSV | 18.28 | 18.4567 | 0.00232866 | 0.00235118 | 0 | 0.702212 | 0.68034 | 2501.25
CSV | STEEL/E24-2 | 3411.04 | 28309.4 | 15091.7 | +3.389 | +3.462 | C112 | C112 | 2 | 2004 | GRENAILLE-PEINT | E24-2 | CSV | 18.28 | 18.4567 | 0.00232866 | 0.00235118 | 0 | 0.702212 | 0.68034 | 2501.25
CSV | STEEL/E24-2 | 3362.9 | 28309.4 | 15093.2 | +3.313 | +3.384 | C112 | C112 | 2 | 2004 | GRENAILLE-PEINT | E24-2 | CSV | 18.28 | 18.4567 | 0.00232866 | 0.00235118 | 0 | 0.702212 | 0.68034 | 2501.25
CSV | STEEL/E24-2 | 3411.04 | 30909.4 | 15091.7 | +3.389 | +3.462 | C111 | C111 | 2 | 2004 | GRENAILLE-PEINT | E24-2 | CSV | 19.2849 | 19.4713 | 0.00245668 | 0.00248043 | 0 | 0.740712 | 0.71774 | 2638.75
CSV | STEEL/E24-2 | 3362.9 | 30909.4 | 15093.2 | +3.313 | +3.384 | C111 | C111 | 2 | 2004 | GRENAILLE-PEINT | E24-2 | CSV | 19.2849 | 19.4713 | 0.00245668 | 0.00248043 | 0 | 0.740712 | 0.71774 | 2638.75
CSV | STEEL/E24-2 | 3411.04 | 33578.1 | 15091.7 | +3.389 | +3.462 | C111 | C111 | 2 | 2004 | GRENAILLE-PEINT | E24-2 | CSV | 19.2849 | 19.4713 | 0.00245668 | 0.00248043 | 0 | 0.740712 | 0.71774 | 2638.75
CSV | STEEL/E24-2 | 3362.9 | 33578.1 | 15093.2 | +3.313 | +3.384 | C111 | C111 | 2 | 2004 | GRENAILLE-PEINT | E24-2 | CSV | 19.2849 | 19.4713 | 0.00245668 | 0.00248043 | 0 | 0.740712 | 0.71774 | 2638.75
CSV | STEEL/E24-2 | 3411.04 | 36246.9 | 15091.7 | +3.389 | +3.462 | C111 | C111 | 2 | 2004 | GRENAILLE-PEINT | E24-2 | CSV | 19.2849 | 19.4713 | 0.00245668 | 0.00248043 | 0 | 0.740712 | 0.71774 | 2638.75
CSV | STEEL/E24-2 | 3362.9 | 36246.9 | 15093.2 | +3.313 | +3.384 | C111 | C111 | 2 | 2004 | GRENAILLE-PEINT | E24-2 | CSV | 19.2849 | 19.4713 | 0.00245668 | 0.00248043 | 0 | 0.740712 | 0.71774 | 2638.75
CSV | STEEL/E24-2 | 3411.04 | 38915.6 | 15091.7 | +3.389 | +3.462 | C111 | C111 | 2 | 2004 | GRENAILLE-PEINT | E24-2 | CSV | 19.2849 | 19.4713 | 0.00245668 | 0.00248043 | 0 | 0.740712 | 0.71774 | 2638.75
CSV | STEEL/E24-2 | 3362.9 | 38915.6 | 15093.2 | +3.313 | +3.384 | C111 | C111 | 2 | 2004 | GRENAILLE-PEINT | E24-2 | CSV | 19.2849 | 19.4713 | 0.00245668 | 0.00248043 | 0 | 0.740712 | 0.71774 | 2638.75
CSV | STEEL/E24-2 | 3411.04 | 44387.5 | 15091.7 | +3.389 | +3.462 | C133 | C133 | 2 | 2004 | GRENAILLE-PEINT | E24-2 | CSV | 19.9397 | 20.1324 | 0.00254008 | 0.00256464 | 0 | 0.765797 | 0.742109 | 2728.34
CSV | STEEL/E24-2 | 3411.04 | 47145.8 | 15091.7 | +3.389 | +3.462 | C133 | C133 | 2 | 2004 | GRENAILLE-PEINT | E24-2 | CSV | 19.9396 | 20.1323 | 0.00254008 | 0.00256463 | 0 | 0.765794 | 0.742106 | 2728.33
ATTACHE | STEEL/S235JR | 3588.83 | 37558.1 | 20753.9 | +3.499 | +3.679 | H35 | H35 | 2 | 2005 | GRENAILLE-PEINT | S235JR | ATTACHE | 1.31552 | 1.32824 | 0.000167582 | 0.000169202 | 0.000931 | 0.0522627 | 0.0489607 | 180.003
ATTACHE | STEEL/S235JR | 3588.83 | 21958.1 | 20753.9 | +3.499 | +3.679 | H35 | H35 | 2 | 2005 | GRENAILLE-PEINT | S235JR | ATTACHE | 1.31552 | 1.32824 | 0.000167582 | 0.000169202 | 0.000931 | 0.0522627 | 0.0489607 | 180.003
ATTACHE | STEEL/S235JR | 3588.83 | 24489.4 | 20753.9 | +3.499 | +3.679 | H35 | H35 | 2 | 2005 | GRENAILLE-PEINT | S235JR | ATTACHE | 1.31552 | 1.32824 | 0.000167582 | 0.000169202 | 0.000931 | 0.0522627 | 0.0489607 | 180.003
ATTACHE | STEEL/E24-2 | 3000.08 | 10117.8 | 601.921 | +2.980 | +3.050 | 656 | L52 | 2 | 2003 | GRENAILLE-PEINT | E24-2 | ATTACHE | 2.6712 | 2.69702 | 0.00034028 | 0.00034357 | 0.0025585 | 0.104202 | 0.099416 | 365.5
ATTACHE | STEEL/E24-2 | 3000.08 | 10117.8 | 8928.08 | +2.980 | +3.050 | 658 | L52 | 2 | 2003 | GRENAILLE-PEINT | E24-2 | ATTACHE | 2.6712 | 2.69702 | 0.00034028 | 0.00034357 | 0.0025585 | 0.104202 | 0.099416 | 365.5
ATTACHE | STEEL/E24-2 | 4258.08 | 24040.1 | 54410 | +4.238 | +4.308 | 673 | L19 | 4 | 4001 | GRENAILLE-PEINT | E24-2 | ATTACHE | 0.438501 | 0.44274 | 0.0000558601 | 0.0000564001 | 0.00042 | 0.018662 | 0.01632 | 60.0001
 | STEEL/E24-2 | 3140.08 | 10541.6 | 6304.92 | +3.120 | +3.190 | 668 | L82 | 6 | 6001 | GRENAILLE-PEINT | E24-2 |  | 0.438501 | 0.44274 | 0.00005586 | 0.0000564 | 0.00042 | 0.018662 | 0.01632 | 60
 | STEEL/E24-2 | 3140.08 | 13448.4 | 6304.92 | +3.120 | +3.190 | 668 | L82 | 6 | 6001 | GRENAILLE-PEINT | E24-2 |  | 0.438501 | 0.44274 | 0.00005586 | 0.0000564 | 0.00042 | 0.018662 | 0.01632 | 60
 | STEEL/E24-2 | 3140.08 | 14801.6 | 3294.92 | +3.120 | +3.190 | 668 | L86 | 6 | 6001 | GRENAILLE-PEINT | E24-2 |  | 0.438501 | 0.44274 | 0.00005586 | 0.0000564 | 0.00042 | 0.018662 | 0.01632 | 60
 | STEEL/E24-2 | 3468.43 | 15129.9 | 3294.92 | +3.438 | +3.498 | 668 | S6 | 6 | 6001 | GRENAILLE-PEINT | E24-2 |  | 0.438501 | 0.44274 | 0.00005586 | 0.0000564 | 0.000931 | 0.018662 | 0.01632 | 60
ATTACHE | STEEL/E24-2 | 3209.92 | 15170.1 | 3467.5 | +3.160 | +3.230 | H40 | H40 | 6 | 6001 | GRENAILLE-PEINT | E24-2 | ATTACHE | 1.49821 | 1.51269 | 0.000190855 | 0.0001927 | 0.01435 | 0.059262 | 0.05576 | 205
 | STEEL/E24-2 | 3140.08 | 17708.4 | 3294.92 | +3.120 | +3.190 | 668 | L84 | 6 | 6001 | GRENAILLE-PEINT | E24-2 |  | 0.438501 | 0.44274 | 0.00005586 | 0.0000564 | 0.00042 | 0.018662 | 0.01632 | 60
 | STEEL/E24-2 | 3140.08 | 17708.4 | 629.921 | +3.120 | +3.190 | 668 | L84 | 6 | 6001 | GRENAILLE-PEINT | E24-2 |  | 0.438501 | 0.44274 | 0.00005586 | 0.0000564 | 0.00042 | 0.018662 | 0.01632 | 60
 | STEEL/E24-2 | 3675.64 | 17314.9 | 1116.61 | +3.624 | +3.697 | 669 | H42 | 6 | 6001 | GRENAILLE-PEINT | E24-2 |  | 0.584668 | 0.59032 | 0.00007448 | 0.0000752 | 0 | 0.024262 | 0.02176 | 80
 | STEEL/E24-2 | 3675.64 | 19444.9 | 1116.61 | +3.624 | +3.697 | 669 | H42 | 6 | 6001 | GRENAILLE-PEINT | E24-2 |  | 0.584668 | 0.59032 | 0.00007448 | 0.0000752 | 0 | 0.024262 | 0.02176 | 80
 | STEEL/E24-2 | 3270 | 19444.9 | 710.079 | +3.240 | +3.300 | 668 | S8 | 6 | 6001 | GRENAILLE-PEINT | E24-2 |  | 0.438501 | 0.44274 | 0.00005586 | 0.0000564 | 0.000931 | 0.018662 | 0.01632 | 60
 | STEEL/E24-2 | 3468.43 | 19389.9 | 629.921 | +3.438 | +3.498 | 668 | S8 | 6 | 6001 | GRENAILLE-PEINT | E24-2 |  | 0.438501 | 0.44274 | 0.00005586 | 0.0000564 | 0.000931 | 0.018662 | 0.01632 | 60
 | STEEL/E24-2 | 3140.08 | 19061.6 | 629.921 | +3.120 | +3.190 | 668 | L84 | 6 | 6001 | GRENAILLE-PEINT | E24-2 |  | 0.438501 | 0.44274 | 0.00005586 | 0.0000564 | 0.00042 | 0.018662 | 0.01632 | 60
 | STEEL/E24-2 | 3468.43 | 19389.9 | 3294.92 | +3.438 | +3.498 | 668 | S6 | 6 | 6001 | GRENAILLE-PEINT | E24-2 |  | 0.438501 | 0.44274 | 0.00005586 | 0.0000564 | 0.000931 | 0.018662 | 0.01632 | 60
 | STEEL/E24-2 | 3140.08 | 19061.6 | 3294.92 | +3.120 | +3.190 | 668 | L84 | 6 | 6001 | GRENAILLE-PEINT | E24-2 |  | 0.438501 | 0.44274 | 0.00005586 | 0.0000564 | 0.00042 | 0.018662 | 0.01632 | 60
 | STEEL/E24-2 | 3270 | 17314.9 | 710.079 | +3.240 | +3.300 | 668 | S7 | 6 | 6001 | GRENAILLE-PEINT | E24-2 |  | 0.438501 | 0.44274 | 0.00005586 | 0.0000564 | 0.000931 | 0.018662 | 0.01632 | 60
 | STEEL/E24-2 | 3675.64 | 21976.2 | 1116.61 | +3.624 | +3.697 | 669 | H42 | 6 | 6001 | GRENAILLE-PEINT | E24-2 |  | 0.584668 | 0.59032 | 0.00007448 | 0.0000752 | 0 | 0.024262 | 0.02176 | 80
 | STEEL/E24-2 | 3270 | 21976.2 | 710.079 | +3.240 | +3.300 | 668 | S7 | 6 | 6001 | GRENAILLE-PEINT | E24-2 |  | 0.438501 | 0.44274 | 0.00005586 | 0.0000564 | 0.000931 | 0.018662 | 0.01632 | 60
 | STEEL/E24-2 | 3140.08 | 22369.7 | 629.921 | +3.120 | +3.190 | 668 | L85 | 6 | 6001 | GRENAILLE-PEINT | E24-2 |  | 0.438501 | 0.44274 | 0.00005586 | 0.0000564 | 0.00042 | 0.018662 | 0.01632 | 60
 | STEEL/E24-2 | 3140.08 | 22369.7 | 3294.92 | +3.120 | +3.190 | 668 | L83 | 6 | 6001 | GRENAILLE-PEINT | E24-2 |  | 0.438501 | 0.44274 | 0.00005586 | 0.0000564 | 0.00042 | 0.018662 | 0.01632 | 60
 | STEEL/E24-2 | 3675.64 | 24507.4 | 1116.61 | +3.624 | +3.697 | 669 | H42 | 6 | 6001 | GRENAILLE-PEINT | E24-2 |  | 0.584668 | 0.59032 | 0.00007448 | 0.0000752 | 0 | 0.024262 | 0.02176 | 80
 | STEEL/E24-2 | 3468.43 | 24452.4 | 629.921 | +3.438 | +3.498 | 668 | S8 | 6 | 6001 | GRENAILLE-PEINT | E24-2 |  | 0.438501 | 0.44274 | 0.00005586 | 0.0000564 | 0.000931 | 0.018662 | 0.01632 | 60
 | STEEL/E24-2 | 3270 | 24507.4 | 710.079 | +3.240 | +3.300 | 668 | S8 | 6 | 6001 | GRENAILLE-PEINT | E24-2 |  | 0.438501 | 0.44274 | 0.00005586 | 0.0000564 | 0.000931 | 0.018662 | 0.01632 | 60
 | STEEL/E24-2 | 3140.08 | 24124.1 | 629.921 | +3.120 | +3.190 | 668 | L85 | 6 | 6001 | GRENAILLE-PEINT | E24-2 |  | 0.438501 | 0.44274 | 0.00005586 | 0.0000564 | 0.00042 | 0.018662 | 0.01632 | 60
 | STEEL/E24-2 | 3675.64 | 29569.9 | 1116.61 | +3.624 | +3.697 | 669 | H42 | 6 | 6001 | GRENAILLE-PEINT | E24-2 |  | 0.584668 | 0.59032 | 0.00007448 | 0.0000752 | 0 | 0.024262 | 0.02176 | 80
 | STEEL/E24-2 | 3270 | 29569.9 | 710.079 | +3.240 | +3.300 | 668 | S9 | 6 | 6001 | GRENAILLE-PEINT | E24-2 |  | 0.438501 | 0.44274 | 0.00005586 | 0.0000564 | 0.000931 | 0.018662 | 0.01632 | 60
 | STEEL/E24-2 | 3468.43 | 29514.9 | 629.921 | +3.438 | +3.498 | 668 | S9 | 6 | 6001 | GRENAILLE-PEINT | E24-2 |  | 0.438501 | 0.44274 | 0.00005586 | 0.0000564 | 0.000931 | 0.018662 | 0.01632 | 60
 | STEEL/E24-2 | 3140.08 | 29186.6 | 629.921 | +3.120 | +3.190 | 668 | L85 | 6 | 6001 | GRENAILLE-PEINT | E24-2 |  | 0.438501 | 0.44274 | 0.00005586 | 0.0000564 | 0.00042 | 0.018662 | 0.01632 | 60
 | STEEL/E24-2 | 3270 | 27038.7 | 710.079 | +3.240 | +3.300 | 668 | S10 | 6 | 6001 | GRENAILLE-PEINT | E24-2 |  | 0.438501 | 0.44274 | 0.00005586 | 0.0000564 | 0.000931 | 0.018662 | 0.01632 | 60
 | STEEL/E24-2 | 3140.08 | 27432.2 | 629.921 | +3.120 | +3.190 | 668 | L85 | 6 | 6001 | GRENAILLE-PEINT | E24-2 |  | 0.438501 | 0.44274 | 0.00005586 | 0.0000564 | 0.00042 | 0.018662 | 0.01632 | 60
 | STEEL/E24-2 | 3675.64 | 27038.7 | 1116.61 | +3.624 | +3.697 | 669 | H42 | 6 | 6001 | GRENAILLE-PEINT | E24-2 |  | 0.584668 | 0.59032 | 0.00007448 | 0.0000752 | 0 | 0.024262 | 0.02176 | 80
 | STEEL/E24-2 | 3270 | 32238.7 | 710.079 | +3.240 | +3.300 | 668 | S10 | 6 | 6001 | GRENAILLE-PEINT | E24-2 |  | 0.438501 | 0.44274 | 0.00005586 | 0.0000564 | 0.000931 | 0.018662 | 0.01632 | 60
 | STEEL/E24-2 | 3140.08 | 32632.2 | 629.921 | +3.120 | +3.190 | 668 | L81 | 6 | 6001 | GRENAILLE-PEINT | E24-2 |  | 0.438501 | 0.44274 | 0.00005586 | 0.0000564 | 0.00042 | 0.018662 | 0.01632 | 60
 | STEEL/E24-2 | 3675.64 | 32238.7 | 1116.61 | +3.624 | +3.697 | 669 | H42 | 6 | 6001 | GRENAILLE-PEINT | E24-2 |  | 0.584668 | 0.59032 | 0.00007448 | 0.0000752 | 0 | 0.024262 | 0.02176 | 80
 | STEEL/E24-2 | 3140.08 | 24124.1 | 3214.92 | +3.120 | +3.190 | 668 | S88 | 6 | 6001 | GRENAILLE-PEINT | E24-2 |  | 0.438501 | 0.44274 | 0.00005586 | 0.0000564 | 0.00042 | 0.018662 | 0.01632 | 60
 | STEEL/E24-2 | 3140.08 | 14801.6 | 6224.92 | +3.120 | +3.190 | 668 | S87 | 6 | 6001 | GRENAILLE-PEINT | E24-2 |  | 0.438501 | 0.44274 | 0.00005586 | 0.0000564 | 0.00042 | 0.018662 | 0.01632 | 60
ATTACHE | STEEL/E24-2 | 3640.21 | 20720.1 | 78320 | +3.590 | +3.660 | 671 | L109 | 7 | 7001 | GRENAILLE-PEINT | E24-2 | ATTACHE | 0.877002 | 0.88548 | 0.00011172 | 0.0001128 | 0.0084 | 0.035462 | 0.03264 | 120

# IfcBeam: L80*8 (233)
In: Undefined
Description: L80*8; Material: STEEL/E24-2
Tekla Common - Finish: GRENAILLE-PEINT; Grade: E24-2; Profile: L80*8; sets with these values: 2
Tekla Quantity - Area per tons: 32.2096 m2; sets with these values: 2
Name | Center of gravity Z (mm) | Center of gravity Y (mm) | Center of gravity X (mm) | Bottom elevation | Top elevation | Part mark | Assembly mark | Phase | Class | Name | Net weight (kg) = NetWeight (kg) | Gross weight (kg) = Weight (kg) | Net volume (m3) = NetVolume (m3) | Gross volume (m3) | Gross footprint area (m2) | Net surface area (m2) | Gross area (m2) = OuterSurfaceArea (m2) | Height (mm) | Width (mm) | Tekla Quantity, Length (mm) = BaseQuantities, Length (mm)
ATTACHE | 3361.05 | 19572.9 | 74260 | +3.304 | +3.384 | 1211 | M15 | 7 | 7001 | ATTACHE | 1.43184 | 1.44833 | 0.0001824 | 0.0001845 | 0.012 | 0.050432 | 0.04665 | 80 | 80 | 150
ATTACHE | 3144.05 | 19572.9 | 74260 | +3.087 | +3.167 | 1211 | M15 | 7 | 7001 | ATTACHE | 1.43184 | 1.44833 | 0.0001824 | 0.0001845 | 0.012 | 0.050432 | 0.04665 | 80 | 80 | 150
ATTACHE | 3580.17 | 19873.9 | 78025.4 | +3.566 | +3.587 | H62 | H62 | 7 | 7001 | ATTACHE | 0.56403 | 0.96555 | 0.0000718509 | 0.000123 | 0 | 0.0209997 | 0.0311 | 17.8136 | 80 | 100
ATTACHE | 3580.17 | 19726.1 | 78025.4 | +3.566 | +3.587 | H62 | H62 | 7 | 7001 | ATTACHE | 0.56403 | 0.96555 | 0.0000718509 | 0.000123 | 0 | 0.0209997 | 0.0311 | 17.8136 | 80 | 100
CRAPAUD | 3732.37 | 15268.7 | 650.711 | +3.718 | +3.739 | H56 | H56 | 6 | 6001 | CRAPAUD | 0.616193 | 1.0621 | 0.000078496 | 0.0001353 | 0 | 0.0228112 | 0.03421 | 17.2 | 80 | 110
CRAPAUD | 3716.01 | 15268.7 | 1118.02 | +3.702 | +3.723 | H56 | H56 | 6 | 6001 | CRAPAUD | 0.616193 | 1.0621 | 0.000078496 | 0.0001353 | 0 | 0.0228112 | 0.03421 | 17.2 | 80 | 110
CRAPAUD | 3732.37 | 15111.3 | 650.711 | +3.718 | +3.739 | H56 | H56 | 6 | 6001 | CRAPAUD | 0.616193 | 1.0621 | 0.000078496 | 0.0001353 | 0 | 0.0228112 | 0.03421 | 17.2 | 80 | 110
CRAPAUD | 3716.01 | 15111.3 | 1118.02 | +3.702 | +3.723 | H56 | H56 | 6 | 6001 | CRAPAUD | 0.616193 | 1.0621 | 0.000078496 | 0.0001353 | 0 | 0.0228112 | 0.03421 | 17.2 | 80 | 110
CRAPAUD | 3716.01 | 11008.7 | 1118.02 | +3.702 | +3.723 | H56 | H56 | 6 | 6001 | CRAPAUD | 0.616193 | 1.0621 | 0.000078496 | 0.0001353 | 0 | 0.0228112 | 0.03421 | 17.2 | 80 | 110
CRAPAUD | 3716.01 | 10851.3 | 1118.02 | +3.702 | +3.723 | H56 | H56 | 6 | 6001 | CRAPAUD | 0.616193 | 1.0621 | 0.000078496 | 0.0001353 | 0 | 0.0228112 | 0.03421 | 17.2 | 80 | 110
CRAPAUD | 3716.01 | 13138.7 | 1118.02 | +3.702 | +3.723 | H56 | H56 | 6 | 6001 | CRAPAUD | 0.616193 | 1.0621 | 0.000078496 | 0.0001353 | 0 | 0.0228112 | 0.03421 | 17.2 | 80 | 110
CRAPAUD | 3716.01 | 12981.3 | 1118.02 | +3.702 | +3.723 | H56 | H56 | 6 | 6001 | CRAPAUD | 0.616193 | 1.0621 | 0.000078496 | 0.0001353 | 0 | 0.0228112 | 0.03421 | 17.2 | 80 | 110
CRAPAUD | 3732.37 | 11008.7 | 650.711 | +3.718 | +3.739 | H56 | H56 | 6 | 6001 | CRAPAUD | 0.616193 | 1.0621 | 0.000078496 | 0.0001353 | 0 | 0.0228112 | 0.03421 | 17.2 | 80 | 110
CRAPAUD | 3732.37 | 10851.3 | 650.711 | +3.718 | +3.739 | H56 | H56 | 6 | 6001 | CRAPAUD | 0.616193 | 1.0621 | 0.000078496 | 0.0001353 | 0 | 0.0228112 | 0.03421 | 17.2 | 80 | 110
CRAPAUD | 3639.09 | 11008.7 | 3315.71 | +3.625 | +3.646 | H56 | H56 | 6 | 6001 | CRAPAUD | 0.616193 | 1.0621 | 0.000078496 | 0.0001353 | 0 | 0.0228112 | 0.03421 | 17.2 | 80 | 110
CRAPAUD | 3639.09 | 10851.3 | 3315.71 | +3.625 | +3.646 | H56 | H56 | 6 | 6001 | CRAPAUD | 0.616193 | 1.0621 | 0.000078496 | 0.0001353 | 0 | 0.0228112 | 0.03421 | 17.2 | 80 | 110
CRAPAUD | 3732.37 | 12981.3 | 650.711 | +3.718 | +3.739 | H56 | H56 | 6 | 6001 | CRAPAUD | 0.616194 | 1.0621 | 0.000078496 | 0.0001353 | 0 | 0.0228112 | 0.03421 | 17.2 | 80 | 110
CRAPAUD | 3732.37 | 13138.7 | 650.711 | +3.718 | +3.739 | H56 | H56 | 6 | 6001 | CRAPAUD | 0.616194 | 1.0621 | 0.000078496 | 0.0001353 | 0 | 0.0228112 | 0.03421 | 17.2 | 80 | 110
CRAPAUD | 3639.09 | 12981.3 | 3315.71 | +3.625 | +3.646 | H56 | H56 | 6 | 6001 | CRAPAUD | 0.616194 | 1.0621 | 0.000078496 | 0.0001353 | 0 | 0.0228112 | 0.03421 | 17.2 | 80 | 110
CRAPAUD | 3639.09 | 13138.7 | 3315.71 | +3.625 | +3.646 | H56 | H56 | 6 | 6001 | CRAPAUD | 0.616194 | 1.0621 | 0.000078496 | 0.0001353 | 0 | 0.0228112 | 0.03421 | 17.2 | 80 | 110
CRAPAUD | 3953 | 27850 | 55796 | +3.940 | +3.958 | C136 | C136 | 4 | 4001 | CRAPAUD | 0.508682 | 0.868998 | 0.0000648002 | 0.0001107 | 0.00720003 | 0.0190801 | 0.0279901 | 80 | 18 | 90.0003
ATTACHE | 4224 | 27850 | 55796 | +4.219 | +4.237 | H63 | H63 | 4 | 4001 | ATTACHE | 0.508682 | 0.868998 | 0.0000648002 | 0.0001107 | 0.000720003 | 0.0190801 | 0.0279901 | 80 | 18 | 90.0003
ATTACHE | 5241.61 | 27171 | 58259.8 | +5.221 | +5.254 | H61 | H61 | 4 | 4001 | ATTACHE | 0.67824 | 1.15866 | 0.0000864 | 0.0001476 | 0 | 0.02496 | 0.03732 | 18 | 80 | 120
CRAPAUD | 3953 | 59061.4 | 44279 | +3.940 | +3.958 | C136 | C136 | 4 | 4001 | CRAPAUD | 0.508682 | 0.868998 | 0.0000648002 | 0.0001107 | 0.00720003 | 0.0190801 | 0.0279901 | 80 | 18 | 90.0003
ATTACHE | 4224 | 59061.4 | 44279 | +4.219 | +4.237 | H63 | H63 | 4 | 4001 | ATTACHE | 0.508682 | 0.868998 | 0.0000648002 | 0.0001107 | 0.000720003 | 0.0190801 | 0.0279901 | 80 | 18 | 90.0003
ATTACHE | 4224 | 60835 | 44279 | +4.219 | +4.237 | H63 | H63 | 4 | 4001 | ATTACHE | 0.508682 | 0.868998 | 0.0000648002 | 0.0001107 | 0.000720003 | 0.0190801 | 0.0279901 | 80 | 18 | 90.0003
CRAPAUD | 3953 | 60835 | 44279 | +3.940 | +3.958 | C136 | C136 | 4 | 4001 | CRAPAUD | 0.508682 | 0.868998 | 0.0000648002 | 0.0001107 | 0.00720003 | 0.0190801 | 0.0279901 | 80 | 18 | 90.0003
ATTACHE | 4224 | 43093.5 | 44279 | +4.219 | +4.237 | H63 | H63 | 4 | 4001 | ATTACHE | 0.508682 | 0.868998 | 0.0000648002 | 0.0001107 | 0.000720003 | 0.0190801 | 0.0279901 | 80 | 18 | 90.0003
CRAPAUD | 3953 | 43093.5 | 44279 | +3.940 | +3.958 | C136 | C136 | 4 | 4001 | CRAPAUD | 0.508682 | 0.868998 | 0.0000648002 | 0.0001107 | 0.00720003 | 0.0190801 | 0.0279901 | 80 | 18 | 90.0003
ATTACHE | 4224 | 42238.6 | 44279 | +4.219 | +4.237 | H63 | H63 | 4 | 4001 | ATTACHE | 0.508682 | 0.868998 | 0.0000648002 | 0.0001107 | 0.000720003 | 0.0190801 | 0.0279901 | 80 | 18 | 90.0003
CRAPAUD | 3953 | 42238.6 | 44279 | +3.940 | +3.958 | C136 | C136 | 4 | 4001 | CRAPAUD | 0.508682 | 0.868998 | 0.0000648002 | 0.0001107 | 0.00720003 | 0.0190801 | 0.0279901 | 80 | 18 | 90.0003
ATTACHE | 4224 | 40445 | 44279 | +4.219 | +4.237 | H63 | H63 | 4 | 4001 | ATTACHE | 0.508682 | 0.868998 | 0.0000648002 | 0.0001107 | 0.000720003 | 0.0190801 | 0.0279901 | 80 | 18 | 90.0003
CRAPAUD | 3953 | 40445 | 44279 | +3.940 | +3.958 | C136 | C136 | 4 | 4001 | CRAPAUD | 0.508682 | 0.868998 | 0.0000648002 | 0.0001107 | 0.00720003 | 0.0190801 | 0.0279901 | 80 | 18 | 90.0003
ATTACHE | 4224 | 19645 | 44279 | +4.219 | +4.237 | H63 | H63 | 4 | 4001 | ATTACHE | 0.508682 | 0.868998 | 0.0000648002 | 0.0001107 | 0.000720003 | 0.0190801 | 0.0279901 | 80 | 18 | 90.0003
CRAPAUD | 3953 | 19645 | 44279 | +3.940 | +3.958 | C136 | C136 | 4 | 4001 | CRAPAUD | 0.508682 | 0.868998 | 0.0000648002 | 0.0001107 | 0.00720003 | 0.0190801 | 0.0279901 | 80 | 18 | 90.0003
ATTACHE | 4224 | 21438.6 | 44279 | +4.219 | +4.237 | H63 | H63 | 4 | 4001 | ATTACHE | 0.508682 | 0.868998 | 0.0000648002 | 0.0001107 | 0.000720003 | 0.0190801 | 0.0279901 | 80 | 18 | 90.0003
CRAPAUD | 3953 | 21438.6 | 44279 | +3.940 | +3.958 | C136 | C136 | 4 | 4001 | CRAPAUD | 0.508682 | 0.868998 | 0.0000648002 | 0.0001107 | 0.00720003 | 0.0190801 | 0.0279901 | 80 | 18 | 90.0003
ATTACHE | 4224 | 19240 | 44279 | +4.219 | +4.237 | H63 | H63 | 4 | 4001 | ATTACHE | 0.508682 | 0.868998 | 0.0000648002 | 0.0001107 | 0.000720003 | 0.0190801 | 0.0279901 | 80 | 18 | 90.0003
CRAPAUD | 3953 | 19240 | 44279 | +3.940 | +3.958 | C136 | C136 | 4 | 4001 | CRAPAUD | 0.508682 | 0.868998 | 0.0000648002 | 0.0001107 | 0.00720003 | 0.0190801 | 0.0279901 | 80 | 18 | 90.0003
ATTACHE | 4224 | 38261.4 | 44279 | +4.219 | +4.237 | H63 | H63 | 4 | 4001 | ATTACHE | 0.508682 | 0.868998 | 0.0000648002 | 0.0001107 | 0.000720003 | 0.0190801 | 0.0279901 | 80 | 18 | 90.0003
CRAPAUD | 3953 | 38261.4 | 44279 | +3.940 | +3.958 | C136 | C136 | 4 | 4001 | CRAPAUD | 0.508682 | 0.868998 | 0.0000648002 | 0.0001107 | 0.00720003 | 0.0190801 | 0.0279901 | 80 | 18 | 90.0003
ATTACHE | 4224 | 40040 | 44279 | +4.219 | +4.237 | H63 | H63 | 4 | 4001 | ATTACHE | 0.508682 | 0.868998 | 0.0000648002 | 0.0001107 | 0.000720003 | 0.0190801 | 0.0279901 | 80 | 18 | 90.0003
CRAPAUD | 3953 | 40040 | 44279 | +3.940 | +3.958 | C136 | C136 | 4 | 4001 | CRAPAUD | 0.508682 | 0.868998 | 0.0000648002 | 0.0001107 | 0.00720003 | 0.0190801 | 0.0279901 | 80 | 18 | 90.0003
ATTACHE | 4224 | 37406.5 | 44279 | +4.219 | +4.237 | H63 | H63 | 4 | 4001 | ATTACHE | 0.508682 | 0.868998 | 0.0000648002 | 0.0001107 | 0.000720003 | 0.0190801 | 0.0279901 | 80 | 18 | 90.0003
CRAPAUD | 3953 | 37406.5 | 44279 | +3.940 | +3.958 | C136 | C136 | 4 | 4001 | CRAPAUD | 0.508682 | 0.868998 | 0.0000648002 | 0.0001107 | 0.00720003 | 0.0190801 | 0.0279901 | 80 | 18 | 90.0003
ATTACHE | 4224 | 58206.5 | 44279 | +4.219 | +4.237 | H63 | H63 | 4 | 4001 | ATTACHE | 0.508682 | 0.868998 | 0.0000648002 | 0.0001107 | 0.000720003 | 0.0190801 | 0.0279901 | 80 | 18 | 90.0003
CRAPAUD | 3953 | 58206.5 | 44279 | +3.940 | +3.958 | C136 | C136 | 4 | 4001 | CRAPAUD | 0.508682 | 0.868998 | 0.0000648002 | 0.0001107 | 0.00720003 | 0.0190801 | 0.0279901 | 80 | 18 | 90.0003
ATTACHE | 4224 | 61353.5 | 44279 | +4.219 | +4.237 | H63 | H63 | 4 | 4001 | ATTACHE | 0.508682 | 0.868998 | 0.0000648002 | 0.0001107 | 0.000720003 | 0.0190801 | 0.0279901 | 80 | 18 | 90.0003
CRAPAUD | 3953 | 61353.5 | 44279 | +3.940 | +3.958 | C136 | C136 | 4 | 4001 | CRAPAUD | 0.508682 | 0.868998 | 0.0000648002 | 0.0001107 | 0.00720003 | 0.0190801 | 0.0279901 | 80 | 18 | 90.0003
ATTACHE | 4224 | 68760 | 44279 | +4.219 | +4.237 | H63 | H63 | 4 | 4001 | ATTACHE | 0.508682 | 0.868998 | 0.0000648002 | 0.0001107 | 0.000720003 | 0.0190801 | 0.0279901 | 80 | 18 | 90.0003
CRAPAUD | 3953 | 68760 | 44279 | +3.940 | +3.958 | C136 | C136 | 4 | 4001 | CRAPAUD | 0.508682 | 0.868998 | 0.0000648002 | 0.0001107 | 0.00720003 | 0.0190801 | 0.0279901 | 80 | 18 | 90.0003
CRAPAUD | 3953 | 66693.5 | 44279 | +3.940 | +3.958 | C136 | C136 | 4 | 4001 | CRAPAUD | 0.508682 | 0.868998 | 0.0000648002 | 0.0001107 | 0.00720003 | 0.0190801 | 0.0279901 | 80 | 18 | 90.0003
CRAPAUD | 3953 | 66206.5 | 44279 | +3.940 | +3.958 | C136 | C136 | 4 | 4001 | CRAPAUD | 0.508682 | 0.868998 | 0.0000648002 | 0.0001107 | 0.00720003 | 0.0190801 | 0.0279901 | 80 | 18 | 90.0003
ATTACHE | 4224 | 66206.5 | 44279 | +4.219 | +4.237 | H63 | H63 | 4 | 4001 | ATTACHE | 0.508682 | 0.868998 | 0.0000648002 | 0.0001107 | 0.000720003 | 0.0190801 | 0.0279901 | 80 | 18 | 90.0003
ATTACHE | 4224 | 66693.5 | 44279 | +4.219 | +4.237 | H63 | H63 | 4 | 4001 | ATTACHE | 0.508682 | 0.868998 | 0.0000648002 | 0.0001107 | 0.000720003 | 0.0190801 | 0.0279901 | 80 | 18 | 90.0003
CRAPAUD | 3953 | 63993.5 | 44279 | +3.940 | +3.958 | C136 | C136 | 4 | 4001 | CRAPAUD | 0.508682 | 0.868998 | 0.0000648002 | 0.0001107 | 0.00720003 | 0.0190801 | 0.0279901 | 80 | 18 | 90.0003
CRAPAUD | 3953 | 63506.5 | 44279 | +3.940 | +3.958 | C136 | C136 | 4 | 4001 | CRAPAUD | 0.508682 | 0.868998 | 0.0000648002 | 0.0001107 | 0.00720003 | 0.0190801 | 0.0279901 | 80 | 18 | 90.0003
ATTACHE | 4224 | 63506.5 | 44279 | +4.219 | +4.237 | H63 | H63 | 4 | 4001 | ATTACHE | 0.508682 | 0.868998 | 0.0000648002 | 0.0001107 | 0.000720003 | 0.0190801 | 0.0279901 | 80 | 18 | 90.0003
ATTACHE | 4224 | 63993.5 | 44279 | +4.219 | +4.237 | H63 | H63 | 4 | 4001 | ATTACHE | 0.508682 | 0.868998 | 0.0000648002 | 0.0001107 | 0.000720003 | 0.0190801 | 0.0279901 | 80 | 18 | 90.0003
CRAPAUD | 3953 | 56093.5 | 44279 | +3.940 | +3.958 | C136 | C136 | 4 | 4001 | CRAPAUD | 0.508682 | 0.868998 | 0.0000648002 | 0.0001107 | 0.00720003 | 0.0190801 | 0.0279901 | 80 | 18 | 90.0003
CRAPAUD | 3953 | 55606.5 | 44279 | +3.940 | +3.958 | C136 | C136 | 4 | 4001 | CRAPAUD | 0.508682 | 0.868998 | 0.0000648002 | 0.0001107 | 0.00720003 | 0.0190801 | 0.0279901 | 80 | 18 | 90.0003
ATTACHE | 4224 | 55606.5 | 44279 | +4.219 | +4.237 | H63 | H63 | 4 | 4001 | ATTACHE | 0.508682 | 0.868998 | 0.0000648002 | 0.0001107 | 0.000720003 | 0.0190801 | 0.0279901 | 80 | 18 | 90.0003
ATTACHE | 4224 | 56093.5 | 44279 | +4.219 | +4.237 | H63 | H63 | 4 | 4001 | ATTACHE | 0.508682 | 0.868998 | 0.0000648002 | 0.0001107 | 0.000720003 | 0.0190801 | 0.0279901 | 80 | 18 | 90.0003
CRAPAUD | 3953 | 53493.5 | 44279 | +3.940 | +3.958 | C136 | C136 | 4 | 4001 | CRAPAUD | 0.508682 | 0.868998 | 0.0000648002 | 0.0001107 | 0.00720003 | 0.0190801 | 0.0279901 | 80 | 18 | 90.0003
CRAPAUD | 3953 | 53006.5 | 44279 | +3.940 | +3.958 | C136 | C136 | 4 | 4001 | CRAPAUD | 0.508682 | 0.868998 | 0.0000648002 | 0.0001107 | 0.00720003 | 0.0190801 | 0.0279901 | 80 | 18 | 90.0003
ATTACHE | 4224 | 53006.5 | 44279 | +4.219 | +4.237 | H63 | H63 | 4 | 4001 | ATTACHE | 0.508682 | 0.868998 | 0.0000648002 | 0.0001107 | 0.000720003 | 0.0190801 | 0.0279901 | 80 | 18 | 90.0003
ATTACHE | 4224 | 53493.5 | 44279 | +4.219 | +4.237 | H63 | H63 | 4 | 4001 | ATTACHE | 0.508682 | 0.868998 | 0.0000648002 | 0.0001107 | 0.000720003 | 0.0190801 | 0.0279901 | 80 | 18 | 90.0003
CRAPAUD | 3953 | 50893.5 | 44279 | +3.940 | +3.958 | C136 | C136 | 4 | 4001 | CRAPAUD | 0.508682 | 0.868998 | 0.0000648002 | 0.0001107 | 0.00720003 | 0.0190801 | 0.0279901 | 80 | 18 | 90.0003
CRAPAUD | 3953 | 50406.5 | 44279 | +3.940 | +3.958 | C136 | C136 | 4 | 4001 | CRAPAUD | 0.508682 | 0.868998 | 0.0000648002 | 0.0001107 | 0.00720003 | 0.0190801 | 0.0279901 | 80 | 18 | 90.0003
ATTACHE | 4224 | 50406.5 | 44279 | +4.219 | +4.237 | H63 | H63 | 4 | 4001 | ATTACHE | 0.508682 | 0.868998 | 0.0000648002 | 0.0001107 | 0.000720003 | 0.0190801 | 0.0279901 | 80 | 18 | 90.0003
ATTACHE | 4224 | 50893.5 | 44279 | +4.219 | +4.237 | H63 | H63 | 4 | 4001 | ATTACHE | 0.508682 | 0.868998 | 0.0000648002 | 0.0001107 | 0.000720003 | 0.0190801 | 0.0279901 | 80 | 18 | 90.0003
CRAPAUD | 3953 | 48293.5 | 44279 | +3.940 | +3.958 | C136 | C136 | 4 | 4001 | CRAPAUD | 0.508682 | 0.868998 | 0.0000648002 | 0.0001107 | 0.00720003 | 0.0190801 | 0.0279901 | 80 | 18 | 90.0003
ATTACHE | 4224 | 48293.5 | 44279 | +4.219 | +4.237 | H63 | H63 | 4 | 4001 | ATTACHE | 0.508682 | 0.868998 | 0.0000648002 | 0.0001107 | 0.000720003 | 0.0190801 | 0.0279901 | 80 | 18 | 90.0003
ATTACHE | 4224 | 47806.5 | 44279 | +4.219 | +4.237 | H63 | H63 | 4 | 4001 | ATTACHE | 0.508682 | 0.868998 | 0.0000648002 | 0.0001107 | 0.000720003 | 0.0190801 | 0.0279901 | 80 | 18 | 90.0003
CRAPAUD | 3953 | 47806.5 | 44279 | +3.940 | +3.958 | C136 | C136 | 4 | 4001 | CRAPAUD | 0.508682 | 0.868998 | 0.0000648002 | 0.0001107 | 0.00720003 | 0.0190801 | 0.0279901 | 80 | 18 | 90.0003
CRAPAUD | 3953 | 45693.5 | 44279 | +3.940 | +3.958 | C136 | C136 | 4 | 4001 | CRAPAUD | 0.508682 | 0.868998 | 0.0000648002 | 0.0001107 | 0.00720003 | 0.0190801 | 0.0279901 | 80 | 18 | 90.0003
ATTACHE | 4224 | 45693.5 | 44279 | +4.219 | +4.237 | H63 | H63 | 4 | 4001 | ATTACHE | 0.508682 | 0.868998 | 0.0000648002 | 0.0001107 | 0.000720003 | 0.0190801 | 0.0279901 | 80 | 18 | 90.0003
ATTACHE | 4224 | 45206.5 | 44279 | +4.219 | +4.237 | H63 | H63 | 4 | 4001 | ATTACHE | 0.508682 | 0.868998 | 0.0000648002 | 0.0001107 | 0.000720003 | 0.0190801 | 0.0279901 | 80 | 18 | 90.0003
CRAPAUD | 3953 | 45206.5 | 44279 | +3.940 | +3.958 | C136 | C136 | 4 | 4001 | CRAPAUD | 0.508682 | 0.868998 | 0.0000648002 | 0.0001107 | 0.00720003 | 0.0190801 | 0.0279901 | 80 | 18 | 90.0003
CRAPAUD | 3953 | 35293.5 | 44279 | +3.940 | +3.958 | C136 | C136 | 4 | 4001 | CRAPAUD | 0.508682 | 0.868998 | 0.0000648002 | 0.0001107 | 0.00720003 | 0.0190801 | 0.0279901 | 80 | 18 | 90.0003
ATTACHE | 4224 | 35293.5 | 44279 | +4.219 | +4.237 | H63 | H63 | 4 | 4001 | ATTACHE | 0.508682 | 0.868998 | 0.0000648002 | 0.0001107 | 0.000720003 | 0.0190801 | 0.0279901 | 80 | 18 | 90.0003
ATTACHE | 4224 | 34806.5 | 44279 | +4.219 | +4.237 | H63 | H63 | 4 | 4001 | ATTACHE | 0.508682 | 0.868998 | 0.0000648002 | 0.0001107 | 0.000720003 | 0.0190801 | 0.0279901 | 80 | 18 | 90.0003
CRAPAUD | 3953 | 34806.5 | 44279 | +3.940 | +3.958 | C136 | C136 | 4 | 4001 | CRAPAUD | 0.508682 | 0.868998 | 0.0000648002 | 0.0001107 | 0.00720003 | 0.0190801 | 0.0279901 | 80 | 18 | 90.0003
CRAPAUD | 3953 | 32693.5 | 44279 | +3.940 | +3.958 | C136 | C136 | 4 | 4001 | CRAPAUD | 0.508682 | 0.868998 | 0.0000648002 | 0.0001107 | 0.00720003 | 0.0190801 | 0.0279901 | 80 | 18 | 90.0003
ATTACHE | 4224 | 32693.5 | 44279 | +4.219 | +4.237 | H63 | H63 | 4 | 4001 | ATTACHE | 0.508682 | 0.868998 | 0.0000648002 | 0.0001107 | 0.000720003 | 0.0190801 | 0.0279901 | 80 | 18 | 90.0003
ATTACHE | 4224 | 32206.5 | 44279 | +4.219 | +4.237 | H63 | H63 | 4 | 4001 | ATTACHE | 0.508682 | 0.868998 | 0.0000648002 | 0.0001107 | 0.000720003 | 0.0190801 | 0.0279901 | 80 | 18 | 90.0003
CRAPAUD | 3953 | 32206.5 | 44279 | +3.940 | +3.958 | C136 | C136 | 4 | 4001 | CRAPAUD | 0.508682 | 0.868998 | 0.0000648002 | 0.0001107 | 0.00720003 | 0.0190801 | 0.0279901 | 80 | 18 | 90.0003
CRAPAUD | 3953 | 30093.5 | 44279 | +3.940 | +3.958 | C136 | C136 | 4 | 4001 | CRAPAUD | 0.508682 | 0.868998 | 0.0000648002 | 0.0001107 | 0.00720003 | 0.0190801 | 0.0279901 | 80 | 18 | 90.0003
ATTACHE | 4224 | 30093.5 | 44279 | +4.219 | +4.237 | H63 | H63 | 4 | 4001 | ATTACHE | 0.508682 | 0.868998 | 0.0000648002 | 0.0001107 | 0.000720003 | 0.0190801 | 0.0279901 | 80 | 18 | 90.0003
ATTACHE | 4224 | 29606.5 | 44279 | +4.219 | +4.237 | H63 | H63 | 4 | 4001 | ATTACHE | 0.508682 | 0.868998 | 0.0000648002 | 0.0001107 | 0.000720003 | 0.0190801 | 0.0279901 | 80 | 18 | 90.0003
CRAPAUD | 3953 | 29606.5 | 44279 | +3.940 | +3.958 | C136 | C136 | 4 | 4001 | CRAPAUD | 0.508682 | 0.868998 | 0.0000648002 | 0.0001107 | 0.00720003 | 0.0190801 | 0.0279901 | 80 | 18 | 90.0003
CRAPAUD | 3953 | 27493.5 | 44279 | +3.940 | +3.958 | C136 | C136 | 4 | 4001 | CRAPAUD | 0.508682 | 0.868998 | 0.0000648002 | 0.0001107 | 0.00720003 | 0.0190801 | 0.0279901 | 80 | 18 | 90.0003
ATTACHE | 4224 | 27493.5 | 44279 | +4.219 | +4.237 | H63 | H63 | 4 | 4001 | ATTACHE | 0.508682 | 0.868998 | 0.0000648002 | 0.0001107 | 0.000720003 | 0.0190801 | 0.0279901 | 80 | 18 | 90.0003
ATTACHE | 4224 | 27006.5 | 44279 | +4.219 | +4.237 | H63 | H63 | 4 | 4001 | ATTACHE | 0.508682 | 0.868998 | 0.0000648002 | 0.0001107 | 0.000720003 | 0.0190801 | 0.0279901 | 80 | 18 | 90.0003
CRAPAUD | 3953 | 27006.5 | 44279 | +3.940 | +3.958 | C136 | C136 | 4 | 4001 | CRAPAUD | 0.508682 | 0.868998 | 0.0000648002 | 0.0001107 | 0.00720003 | 0.0190801 | 0.0279901 | 80 | 18 | 90.0003
CRAPAUD | 3953 | 24893.5 | 44279 | +3.940 | +3.958 | C136 | C136 | 4 | 4001 | CRAPAUD | 0.508682 | 0.868998 | 0.0000648002 | 0.0001107 | 0.00720003 | 0.0190801 | 0.0279901 | 80 | 18 | 90.0003
ATTACHE | 4224 | 24893.5 | 44279 | +4.219 | +4.237 | H63 | H63 | 4 | 4001 | ATTACHE | 0.508682 | 0.868998 | 0.0000648002 | 0.0001107 | 0.000720003 | 0.0190801 | 0.0279901 | 80 | 18 | 90.0003
ATTACHE | 4224 | 24406.5 | 44279 | +4.219 | +4.237 | H63 | H63 | 4 | 4001 | ATTACHE | 0.508682 | 0.868998 | 0.0000648002 | 0.0001107 | 0.000720003 | 0.0190801 | 0.0279901 | 80 | 18 | 90.0003
CRAPAUD | 3953 | 24406.5 | 44279 | +3.940 | +3.958 | C136 | C136 | 4 | 4001 | CRAPAUD | 0.508682 | 0.868998 | 0.0000648002 | 0.0001107 | 0.00720003 | 0.0190801 | 0.0279901 | 80 | 18 | 90.0003
CRAPAUD | 3953 | 22293.5 | 44279 | +3.940 | +3.958 | C136 | C136 | 4 | 4001 | CRAPAUD | 0.508682 | 0.868998 | 0.0000648002 | 0.0001107 | 0.00720003 | 0.0190801 | 0.0279901 | 80 | 18 | 90.0003
ATTACHE | 4224 | 22293.5 | 44279 | +4.219 | +4.237 | H63 | H63 | 4 | 4001 | ATTACHE | 0.508682 | 0.868998 | 0.0000648002 | 0.0001107 | 0.000720003 | 0.0190801 | 0.0279901 | 80 | 18 | 90.0003
CRAPAUD | 3953 | 12613.5 | 44279 | +3.940 | +3.958 | C136 | C136 | 4 | 4001 | CRAPAUD | 0.508682 | 0.868998 | 0.0000648002 | 0.0001107 | 0.00720003 | 0.0190801 | 0.0279901 | 80 | 18 | 90.0003
ATTACHE | 4224 | 12613.5 | 44279 | +4.219 | +4.237 | H63 | H63 | 4 | 4001 | ATTACHE | 0.508682 | 0.868998 | 0.0000648002 | 0.0001107 | 0.000720003 | 0.0190801 | 0.0279901 | 80 | 18 | 90.0003
 | 3092.7 | -2084.67 | 24669.4 | +3.068 | +3.149 | 1219 | W7 | 3 | 3003 |  | 0.724398 | 0.77244 | 0.00009228 | 0.0000984 | 0 | 0.0265477 | 0.02488 | 80 | 80 | 80
 | 3063.14 | -601.415 | 20922.8 | +3.038 | +3.120 | 1220 | W7 | 3 | 3003 |  | 0.720473 | 0.77244 | 0.00009178 | 0.0000984 | 0 | 0.0264123 | 0.02488 | 80 | 80 | 80
 | -150 | -202.053 | 22589.9 | -0.200 | -0.100 | 1221 | M16 | 3 | 3003 |  | 0.95456 | 0.96555 | 0.0001216 | 0.000123 | 0.001216 | 0.034432 | 0.0311 | 80 | 80 | 100
ATTACHE | 4103.09 | 26122.1 | 79125 | +4.046 | +4.126 | H58 | H58 | 1 | 1003 | ATTACHE | 1.43184 | 1.44832 | 0.0001824 | 0.0001845 | 0.012 | 0.050432 | 0.04665 | 80 | 80 | 150
ATTACHE | 5777.06 | 69152.1 | 79148.5 | +5.720 | +5.800 | H70 | H70 | 1 | 1003 | ATTACHE | 1.68957 | 1.70902 | 0.000215232 | 0.00021771 | 0.01416 | 0.059072 | 0.055047 | 80 | 80 | 177
 | 4734.15 | 69169.9 | 44128.4 | +4.677 | +4.757 | 1226 | L45 | 3 | 3003 |  | 1.11579 | 1.12864 | 0.000142139 | 0.000143775 | 0.00935124 | 0.039837 | 0.036353 | 80 | 80 | 116.891
 | -150 | -202.053 | 74857.9 | -0.200 | -0.100 | 1221 | P111 | 1 | 1003 |  | 0.95456 | 0.96555 | 0.0001216 | 0.000123 | 0.001216 | 0.034432 | 0.0311 | 80 | 80 | 100
 | -150 | -202.053 | 71022.9 | -0.200 | -0.100 | 1221 | P109 | 1 | 1003 |  | 0.95456 | 0.96555 | 0.0001216 | 0.000123 | 0.001216 | 0.034432 | 0.0311 | 80 | 80 | 100
 | -150 | -202.053 | 57717.9 | -0.200 | -0.100 | 1221 | P44 | 1 | 1003 |  | 0.95456 | 0.96555 | 0.0001216 | 0.000123 | 0.001216 | 0.034432 | 0.0311 | 80 | 80 | 100
 | 4734.15 | 69169.9 | 55803.4 | +4.677 | +4.757 | 1226 | L44 | 1 | 1003 |  | 1.11579 | 1.12864 | 0.000142139 | 0.000143775 | 0.00935124 | 0.039837 | 0.036353 | 80 | 80 | 116.891
 | 4734.15 | 69169.9 | 67478.4 | +4.677 | +4.757 | 1226 | L44 | 1 | 1003 |  | 1.11579 | 1.12864 | 0.000142139 | 0.000143775 | 0.00935124 | 0.039837 | 0.036353 | 80 | 80 | 116.891
 | 4734.15 | -19.9472 | 44128.4 | +4.677 | +4.757 | 1223 | L43 | 3 | 3003 |  | 1.11579 | 1.12864 | 0.000142139 | 0.000143775 | 0.00935124 | 0.039837 | 0.036353 | 80 | 80 | 116.891
 | 4734.15 | -19.9472 | 55803.4 | +4.677 | +4.757 | 1223 | L42 | 1 | 1003 |  | 1.11579 | 1.12864 | 0.000142139 | 0.000143775 | 0.00935124 | 0.039837 | 0.036353 | 80 | 80 | 116.891
 | 4734.15 | -19.9472 | 67478.4 | +4.677 | +4.757 | 1223 | L42 | 1 | 1003 |  | 1.11579 | 1.12864 | 0.000142139 | 0.000143775 | 0.00935124 | 0.039837 | 0.036353 | 80 | 80 | 116.891
 | 4734.15 | -19.9472 | 32458.5 | +4.677 | +4.757 | 1224 | P113 | 3 | 3001 |  | 1.21182 | 1.22577 | 0.000154372 | 0.000156149 | 0.010156 | 0.0430562 | 0.0394816 | 80 | 80 | 126.951
 | 5857.05 | -24.9474 | 67612.5 | +5.800 | +5.880 | 1225 | L55 | 1 | 1003 |  | 0.907691 | 0.918141 | 0.000115629 | 0.000116961 | 0.0076072 | 0.0328608 | 0.029573 | 80 | 80 | 95.09
 | -150 | 30312.9 | 79312.1 | -0.200 | -0.100 | 1221 | P49 | 1 | 1003 |  | 0.95456 | 0.96555 | 0.0001216 | 0.000123 | 0.001216 | 0.034432 | 0.0311 | 80 | 80 | 100
 | 4744.64 | 69231 | 79112.1 | +4.688 | +4.768 | 1227 | P17 | 1 | 1011 |  | 2.65368 | 2.68423 | 0.000338048 | 0.00034194 | 0.02224 | 0.091392 | 0.086458 | 80 | 80 | 278
ATTACHE | 4707.05 | 48102.1 | 20795 | +4.650 | +4.730 | H59 | H59 | 2 | 2006 | ATTACHE | 1.43184 | 1.44832 | 0.0001824 | 0.0001845 | 0.012 | 0.050432 | 0.04665 | 80 | 80 | 150
ATTACHE | 4259.95 | 25427.1 | 55875 | +4.237 | +4.317 | H68 | H68 | 4 | 4001 | ATTACHE | 1.33638 | 1.35177 | 0.00017024 | 0.0001722 | 0.00112 | 0.047232 | 0.04354 | 80 | 80 | 140
ATTACHE | 5570.05 | 25427.1 | 55875 | +5.513 | +5.593 | H69 | H69 | 4 | 4001 | ATTACHE | 1.33638 | 1.35177 | 0.00017024 | 0.0001722 | 0.0112 | 0.047232 | 0.04354 | 80 | 80 | 140
ATTACHE | 5570.05 | 26072.9 | 55875 | +5.513 | +5.593 | H68 | H68 | 4 | 4001 | ATTACHE | 1.33638 | 1.35177 | 0.00017024 | 0.0001722 | 0.0112 | 0.047232 | 0.04354 | 80 | 80 | 140
ATTACHE | 4259.95 | 26072.9 | 55875 | +4.237 | +4.317 | H69 | H69 | 4 | 4001 | ATTACHE | 1.33638 | 1.35177 | 0.00017024 | 0.0001722 | 0.00112 | 0.047232 | 0.04354 | 80 | 80 | 140
ATTACHE | 4259.95 | 26072.9 | 44200 | +4.237 | +4.317 | H69 | H69 | 4 | 4001 | ATTACHE | 1.33638 | 1.35177 | 0.00017024 | 0.0001722 | 0.00112 | 0.047232 | 0.04354 | 80 | 80 | 140
ATTACHE | 4259.95 | 25427.1 | 44200 | +4.237 | +4.317 | H68 | H68 | 4 | 4001 | ATTACHE | 1.33638 | 1.35177 | 0.00017024 | 0.0001722 | 0.00112 | 0.047232 | 0.04354 | 80 | 80 | 140
ATTACHE | 5570.05 | 25427.1 | 44200 | +5.513 | +5.593 | H69 | H69 | 4 | 4001 | ATTACHE | 1.33638 | 1.35177 | 0.00017024 | 0.0001722 | 0.0112 | 0.047232 | 0.04354 | 80 | 80 | 140
ATTACHE | 5570.05 | 26072.9 | 44200 | +5.513 | +5.593 | H68 | H68 | 4 | 4001 | ATTACHE | 1.33638 | 1.35177 | 0.00017024 | 0.0001722 | 0.0112 | 0.047232 | 0.04354 | 80 | 80 | 140
ATTACHE | 4259.95 | 26072.9 | 32525 | +4.237 | +4.317 | H69 | H69 | 4 | 4001 | ATTACHE | 1.33638 | 1.35177 | 0.00017024 | 0.0001722 | 0.00112 | 0.047232 | 0.04354 | 80 | 80 | 140
ATTACHE | 4259.95 | 25427.1 | 32525 | +4.237 | +4.317 | H68 | H68 | 4 | 4001 | ATTACHE | 1.33638 | 1.35177 | 0.00017024 | 0.0001722 | 0.00112 | 0.047232 | 0.04354 | 80 | 80 | 140
ATTACHE | 5570.05 | 25427.1 | 32525 | +5.513 | +5.593 | H69 | H69 | 4 | 4001 | ATTACHE | 1.33638 | 1.35177 | 0.00017024 | 0.0001722 | 0.0112 | 0.047232 | 0.04354 | 80 | 80 | 140
ATTACHE | 5570.05 | 26072.9 | 32525 | +5.513 | +5.593 | H68 | H68 | 4 | 4001 | ATTACHE | 1.33638 | 1.35177 | 0.00017024 | 0.0001722 | 0.0112 | 0.047232 | 0.04354 | 80 | 80 | 140
ATTACHE | 4259.95 | 23172.9 | 67550 | +4.237 | +4.317 | H69 | H69 | 4 | 4001 | ATTACHE | 1.33638 | 1.35177 | 0.00017024 | 0.0001722 | 0.00112 | 0.047232 | 0.04354 | 80 | 80 | 140
ATTACHE | 5570.05 | 23172.9 | 67550 | +5.513 | +5.593 | H68 | H68 | 4 | 4001 | ATTACHE | 1.33638 | 1.35177 | 0.00017024 | 0.0001722 | 0.0112 | 0.047232 | 0.04354 | 80 | 80 | 140
ATTACHE | 5570.05 | 22527.1 | 67550 | +5.513 | +5.593 | H69 | H69 | 4 | 4001 | ATTACHE | 1.33638 | 1.35177 | 0.00017024 | 0.0001722 | 0.0112 | 0.047232 | 0.04354 | 80 | 80 | 140
ATTACHE | 4259.95 | 22527.1 | 67550 | +4.237 | +4.317 | H68 | H68 | 4 | 4001 | ATTACHE | 1.33638 | 1.35177 | 0.00017024 | 0.0001722 | 0.00112 | 0.047232 | 0.04354 | 80 | 80 | 140
ATTACHE | 4021.48 | 18326.4 | 71818.8 | +4.000 | +4.080 | H65 | H65 | 4 | 4001 | ATTACHE | 1.19292 | 1.24556 | 0.000151964 | 0.00015867 | 0.000752 | 0.042323 | 0.040119 | 80 | 80 | 129
ATTACHE | 5869.05 | 18327.1 | 71809.5 | +5.812 | +5.892 | H67 | H67 | 4 | 4001 | ATTACHE | 1.00229 | 1.01383 | 0.00012768 | 0.00012915 | 0.0084 | 0.036032 | 0.032655 | 80 | 80 | 105
ATTACHE | 5869.05 | 18972.9 | 71809.5 | +5.812 | +5.892 | H66 | H66 | 4 | 4001 | ATTACHE | 1.00229 | 1.01383 | 0.00012768 | 0.00012915 | 0.0084 | 0.036032 | 0.032655 | 80 | 80 | 105
ATTACHE | 4021.48 | 18973.6 | 71818.8 | +4.000 | +4.080 | H64 | H64 | 4 | 4001 | ATTACHE | 1.19292 | 1.24556 | 0.000151964 | 0.00015867 | 0.000752 | 0.042323 | 0.040119 | 80 | 80 | 129
ATTACHE | 4224 | 390 | 44279 | +4.219 | +4.237 | H63 | H63 | 4 | 4001 | ATTACHE | 0.508682 | 0.868998 | 0.0000648002 | 0.0001107 | 0.000720003 | 0.0190801 | 0.0279901 | 80 | 18 | 90.0003
CRAPAUD | 3953 | 390 | 44279 | +3.940 | +3.958 | C136 | C136 | 4 | 4001 | CRAPAUD | 0.508682 | 0.868998 | 0.0000648002 | 0.0001107 | 0.00720003 | 0.0190801 | 0.0279901 | 80 | 18 | 90.0003
ATTACHE | 4224 | 2305 | 44279 | +4.219 | +4.237 | H63 | H63 | 4 | 4001 | ATTACHE | 0.508682 | 0.868998 | 0.0000648002 | 0.0001107 | 0.000720003 | 0.0190801 | 0.0279901 | 80 | 18 | 90.0003
CRAPAUD | 3953 | 2305 | 44279 | +3.940 | +3.958 | C136 | C136 | 4 | 4001 | CRAPAUD | 0.508682 | 0.868998 | 0.0000648002 | 0.0001107 | 0.00720003 | 0.0190801 | 0.0279901 | 80 | 18 | 90.0003
CRAPAUD | 3953 | 4856.5 | 44279 | +3.940 | +3.958 | C136 | C136 | 4 | 4001 | CRAPAUD | 0.508682 | 0.868998 | 0.0000648002 | 0.0001107 | 0.00720003 | 0.0190801 | 0.0279901 | 80 | 18 | 90.0003
ATTACHE | 4224 | 4856.5 | 44279 | +4.219 | +4.237 | H63 | H63 | 4 | 4001 | ATTACHE | 0.508682 | 0.868998 | 0.0000648002 | 0.0001107 | 0.000720003 | 0.0190801 | 0.0279901 | 80 | 18 | 90.0003
ATTACHE | 4224 | 2793.5 | 44279 | +4.219 | +4.237 | H63 | H63 | 4 | 4001 | ATTACHE | 0.508682 | 0.868998 | 0.0000648002 | 0.0001107 | 0.000720003 | 0.0190801 | 0.0279901 | 80 | 18 | 90.0003
CRAPAUD | 3953 | 2793.5 | 44279 | +3.940 | +3.958 | C136 | C136 | 4 | 4001 | CRAPAUD | 0.508682 | 0.868998 | 0.0000648002 | 0.0001107 | 0.00720003 | 0.0190801 | 0.0279901 | 80 | 18 | 90.0003
CRAPAUD | 3953 | 7450 | 44279 | +3.940 | +3.958 | C136 | C136 | 4 | 4001 | CRAPAUD | 0.508682 | 0.868998 | 0.0000648002 | 0.0001107 | 0.00720003 | 0.0190801 | 0.0279901 | 80 | 18 | 90.0003
ATTACHE | 4224 | 7450 | 44279 | +4.219 | +4.237 | H63 | H63 | 4 | 4001 | ATTACHE | 0.508682 | 0.868998 | 0.0000648002 | 0.0001107 | 0.000720003 | 0.0190801 | 0.0279901 | 80 | 18 | 90.0003
ATTACHE | 4224 | 5343.5 | 44279 | +4.219 | +4.237 | H63 | H63 | 4 | 4001 | ATTACHE | 0.508682 | 0.868998 | 0.0000648002 | 0.0001107 | 0.000720003 | 0.0190801 | 0.0279901 | 80 | 18 | 90.0003
CRAPAUD | 3953 | 5343.5 | 44279 | +3.940 | +3.958 | C136 | C136 | 4 | 4001 | CRAPAUD | 0.508682 | 0.868998 | 0.0000648002 | 0.0001107 | 0.00720003 | 0.0190801 | 0.0279901 | 80 | 18 | 90.0003
CRAPAUD | 3953 | 12126.5 | 44279 | +3.940 | +3.958 | C136 | C136 | 4 | 4001 | CRAPAUD | 0.508682 | 0.868998 | 0.0000648002 | 0.0001107 | 0.00720003 | 0.0190801 | 0.0279901 | 80 | 18 | 90.0003
ATTACHE | 4224 | 12126.5 | 44279 | +4.219 | +4.237 | H63 | H63 | 4 | 4001 | ATTACHE | 0.508682 | 0.868998 | 0.0000648002 | 0.0001107 | 0.000720003 | 0.0190801 | 0.0279901 | 80 | 18 | 90.0003
ATTACHE | 4224 | 10253.5 | 44279 | +4.219 | +4.237 | H63 | H63 | 4 | 4001 | ATTACHE | 0.508682 | 0.868998 | 0.0000648002 | 0.0001107 | 0.000720003 | 0.0190801 | 0.0279901 | 80 | 18 | 90.0003
CRAPAUD | 3953 | 10253.5 | 44279 | +3.940 | +3.958 | C136 | C136 | 4 | 4001 | CRAPAUD | 0.508682 | 0.868998 | 0.0000648002 | 0.0001107 | 0.00720003 | 0.0190801 | 0.0279901 | 80 | 18 | 90.0003
CRAPAUD | 3953 | 9766.5 | 44279 | +3.940 | +3.958 | C136 | C136 | 4 | 4001 | CRAPAUD | 0.508682 | 0.868998 | 0.0000648002 | 0.0001107 | 0.00720003 | 0.0190801 | 0.0279901 | 80 | 18 | 90.0003
ATTACHE | 4224 | 9766.5 | 44279 | +4.219 | +4.237 | H63 | H63 | 4 | 4001 | ATTACHE | 0.508682 | 0.868998 | 0.0000648002 | 0.0001107 | 0.000720003 | 0.0190801 | 0.0279901 | 80 | 18 | 90.0003
ATTACHE | 4224 | 7835 | 44279 | +4.219 | +4.237 | H63 | H63 | 4 | 4001 | ATTACHE | 0.508682 | 0.868998 | 0.0000648002 | 0.0001107 | 0.000720003 | 0.0190801 | 0.0279901 | 80 | 18 | 90.0003
CRAPAUD | 3953 | 7835 | 44279 | +3.940 | +3.958 | C136 | C136 | 4 | 4001 | CRAPAUD | 0.508682 | 0.868998 | 0.0000648002 | 0.0001107 | 0.00720003 | 0.0190801 | 0.0279901 | 80 | 18 | 90.0003
ATTACHE | 4224 | 14486.5 | 44279 | +4.219 | +4.237 | H63 | H63 | 4 | 4001 | ATTACHE | 0.508682 | 0.868998 | 0.0000648002 | 0.0001107 | 0.000720003 | 0.0190801 | 0.0279901 | 80 | 18 | 90.0003
CRAPAUD | 3953 | 14486.5 | 44279 | +3.940 | +3.958 | C136 | C136 | 4 | 4001 | CRAPAUD | 0.508682 | 0.868998 | 0.0000648002 | 0.0001107 | 0.00720003 | 0.0190801 | 0.0279901 | 80 | 18 | 90.0003
CRAPAUD | 3953 | 14973.5 | 44279 | +3.940 | +3.958 | C136 | C136 | 4 | 4001 | CRAPAUD | 0.508682 | 0.868998 | 0.0000648002 | 0.0001107 | 0.00720003 | 0.0190801 | 0.0279901 | 80 | 18 | 90.0003
ATTACHE | 4224 | 14973.5 | 44279 | +4.219 | +4.237 | H63 | H63 | 4 | 4001 | ATTACHE | 0.508682 | 0.868998 | 0.0000648002 | 0.0001107 | 0.000720003 | 0.0190801 | 0.0279901 | 80 | 18 | 90.0003
ATTACHE | 4224 | 16846.5 | 44279 | +4.219 | +4.237 | H63 | H63 | 4 | 4001 | ATTACHE | 0.508682 | 0.868998 | 0.0000648002 | 0.0001107 | 0.000720003 | 0.0190801 | 0.0279901 | 80 | 18 | 90.0003
CRAPAUD | 3953 | 16846.5 | 44279 | +3.940 | +3.958 | C136 | C136 | 4 | 4001 | CRAPAUD | 0.508682 | 0.868998 | 0.0000648002 | 0.0001107 | 0.00720003 | 0.0190801 | 0.0279901 | 80 | 18 | 90.0003
CRAPAUD | 3953 | 17333.5 | 44279 | +3.940 | +3.958 | C136 | C136 | 4 | 4001 | CRAPAUD | 0.508682 | 0.868998 | 0.0000648002 | 0.0001107 | 0.00720003 | 0.0190801 | 0.0279901 | 80 | 18 | 90.0003
ATTACHE | 4224 | 17333.5 | 44279 | +4.219 | +4.237 | H63 | H63 | 4 | 4001 | ATTACHE | 0.508682 | 0.868998 | 0.0000648002 | 0.0001107 | 0.000720003 | 0.0190801 | 0.0279901 | 80 | 18 | 90.0003
ATTACHE | 4275.35 | 24571 | 54495.8 | +4.255 | +4.288 | H61 | H61 | 4 | 4001 | ATTACHE | 0.67824 | 1.15866 | 0.0000864 | 0.0001476 | 0 | 0.02496 | 0.03732 | 18 | 80 | 120
ATTACHE | 4275.35 | 24729 | 54495.8 | +4.255 | +4.288 | H61 | H61 | 4 | 4001 | ATTACHE | 0.67824 | 1.15866 | 0.0000864 | 0.0001476 | 0 | 0.02496 | 0.03732 | 18 | 80 | 120
ATTACHE | 5241.61 | 24729 | 58259.8 | +5.221 | +5.254 | H61 | H61 | 4 | 4001 | ATTACHE | 0.67824 | 1.15866 | 0.0000864 | 0.0001476 | 0 | 0.02496 | 0.03732 | 18 | 80 | 120
ATTACHE | 5241.61 | 24571 | 58259.8 | +5.221 | +5.254 | H61 | H61 | 4 | 4001 | ATTACHE | 0.67824 | 1.15866 | 0.0000864 | 0.0001476 | 0 | 0.02496 | 0.03732 | 18 | 80 | 120
ATTACHE | 5241.61 | 27329 | 58259.8 | +5.221 | +5.254 | H61 | H61 | 4 | 4001 | ATTACHE | 0.67824 | 1.15866 | 0.0000864 | 0.0001476 | 0 | 0.02496 | 0.03732 | 18 | 80 | 120
ATTACHE | 4275.35 | 27329 | 54495.8 | +4.255 | +4.288 | H61 | H61 | 4 | 4001 | ATTACHE | 0.67824 | 1.15866 | 0.0000864 | 0.0001476 | 0 | 0.02496 | 0.03732 | 18 | 80 | 120
ATTACHE | 4275.35 | 27171 | 54495.8 | +4.255 | +4.288 | H61 | H61 | 4 | 4001 | ATTACHE | 0.67824 | 1.15866 | 0.0000864 | 0.0001476 | 0 | 0.02496 | 0.03732 | 18 | 80 | 120
ATTACHE | 4224 | 26198.6 | 55954 | +4.219 | +4.237 | H63 | H63 | 4 | 4001 | ATTACHE | 0.508682 | 0.868998 | 0.0000648002 | 0.0001107 | 0.000720003 | 0.0190801 | 0.0279901 | 80 | 18 | 90.0003
CRAPAUD | 3953 | 26198.6 | 55954 | +3.940 | +3.958 | C136 | C136 | 4 | 4001 | CRAPAUD | 0.508682 | 0.868998 | 0.0000648002 | 0.0001107 | 0.00720003 | 0.0190801 | 0.0279901 | 80 | 18 | 90.0003
CRAPAUD | 5606 | 26198.6 | 55954 | +5.593 | +5.611 | C136 | C136 | 4 | 4001 | CRAPAUD | 0.508682 | 0.868998 | 0.0000648002 | 0.0001107 | 0.00720003 | 0.0190801 | 0.0279901 | 80 | 18 | 90.0003
ATTACHE | 4224 | 26738.6 | 55954 | +4.219 | +4.237 | H63 | H63 | 4 | 4001 | ATTACHE | 0.508682 | 0.868998 | 0.0000648002 | 0.0001107 | 0.000720003 | 0.0190801 | 0.0279901 | 80 | 18 | 90.0003
CRAPAUD | 3953 | 26738.6 | 55954 | +3.940 | +3.958 | C136 | C136 | 4 | 4001 | CRAPAUD | 0.508682 | 0.868998 | 0.0000648002 | 0.0001107 | 0.00720003 | 0.0190801 | 0.0279901 | 80 | 18 | 90.0003
CRAPAUD | 5606 | 26738.6 | 55954 | +5.593 | +5.611 | C136 | C136 | 4 | 4001 | CRAPAUD | 0.508682 | 0.868998 | 0.0000648002 | 0.0001107 | 0.00720003 | 0.0190801 | 0.0279901 | 80 | 18 | 90.0003
CRAPAUD | 5606 | 24050 | 55796 | +5.593 | +5.611 | C136 | C136 | 4 | 4001 | CRAPAUD | 0.508682 | 0.868998 | 0.0000648002 | 0.0001107 | 0.00720003 | 0.0190801 | 0.0279901 | 80 | 18 | 90.0003
CRAPAUD | 3953 | 24050 | 55796 | +3.940 | +3.958 | C136 | C136 | 4 | 4001 | CRAPAUD | 0.508682 | 0.868998 | 0.0000648002 | 0.0001107 | 0.00720003 | 0.0190801 | 0.0279901 | 80 | 18 | 90.0003
ATTACHE | 4224 | 24050 | 55796 | +4.219 | +4.237 | H63 | H63 | 4 | 4001 | ATTACHE | 0.508682 | 0.868998 | 0.0000648002 | 0.0001107 | 0.000720003 | 0.0190801 | 0.0279901 | 80 | 18 | 90.0003
CRAPAUD | 3533.74 | 12981.3 | 6325.71 | +3.520 | +3.541 | H56 | H56 | 6 | 6001 | CRAPAUD | 0.616194 | 1.0621 | 0.000078496 | 0.0001353 | 0 | 0.0228112 | 0.03421 | 17.2 | 80 | 110
CRAPAUD | 3533.74 | 13138.7 | 6325.71 | +3.520 | +3.541 | H56 | H56 | 6 | 6001 | CRAPAUD | 0.616194 | 1.0621 | 0.000078496 | 0.0001353 | 0 | 0.0228112 | 0.03421 | 17.2 | 80 | 110
CRAPAUD | 3533.74 | 10851.3 | 6325.71 | +3.520 | +3.541 | H56 | H56 | 6 | 6001 | CRAPAUD | 0.616194 | 1.0621 | 0.000078496 | 0.0001353 | 0 | 0.0228112 | 0.03421 | 17.2 | 80 | 110
CRAPAUD | 3533.74 | 11008.7 | 6325.71 | +3.520 | +3.541 | H56 | H56 | 6 | 6001 | CRAPAUD | 0.616194 | 1.0621 | 0.000078496 | 0.0001353 | 0 | 0.0228112 | 0.03421 | 17.2 | 80 | 110
CRAPAUD | 3639.09 | 15268.7 | 3315.71 | +3.625 | +3.646 | H56 | H56 | 6 | 6001 | CRAPAUD | 0.616193 | 1.0621 | 0.000078496 | 0.0001353 | 0 | 0.0228112 | 0.03421 | 17.2 | 80 | 110
CRAPAUD | 3639.09 | 15111.3 | 3315.71 | +3.625 | +3.646 | H56 | H56 | 6 | 6001 | CRAPAUD | 0.616193 | 1.0621 | 0.000078496 | 0.0001353 | 0 | 0.0228112 | 0.03421 | 17.2 | 80 | 110
CRAPAUD | 3639.09 | 17241.3 | 3315.71 | +3.625 | +3.646 | H56 | H56 | 6 | 6001 | CRAPAUD | 0.616193 | 1.0621 | 0.000078496 | 0.0001353 | 0 | 0.0228112 | 0.03421 | 17.2 | 80 | 110
CRAPAUD | 3639.09 | 17398.7 | 3315.71 | +3.625 | +3.646 | H56 | H56 | 6 | 6001 | CRAPAUD | 0.616193 | 1.0621 | 0.000078496 | 0.0001353 | 0 | 0.0228112 | 0.03421 | 17.2 | 80 | 110
CRAPAUD | 3716.01 | 17398.7 | 1118.02 | +3.702 | +3.723 | H56 | H56 | 6 | 6001 | CRAPAUD | 0.616193 | 1.0621 | 0.000078496 | 0.0001353 | 0 | 0.0228112 | 0.03421 | 17.2 | 80 | 110
CRAPAUD | 3716.01 | 17241.3 | 1118.02 | +3.702 | +3.723 | H56 | H56 | 6 | 6001 | CRAPAUD | 0.616193 | 1.0621 | 0.000078496 | 0.0001353 | 0 | 0.0228112 | 0.03421 | 17.2 | 80 | 110
CRAPAUD | 3732.37 | 17241.3 | 650.711 | +3.718 | +3.739 | H56 | H56 | 6 | 6001 | CRAPAUD | 0.616193 | 1.0621 | 0.000078496 | 0.0001353 | 0 | 0.0228112 | 0.03421 | 17.2 | 80 | 110
CRAPAUD | 3732.37 | 17398.7 | 650.711 | +3.718 | +3.739 | H56 | H56 | 6 | 6001 | CRAPAUD | 0.616193 | 1.0621 | 0.000078496 | 0.0001353 | 0 | 0.0228112 | 0.03421 | 17.2 | 80 | 110
CRAPAUD | 3732.37 | 19528.7 | 650.711 | +3.718 | +3.739 | H56 | H56 | 6 | 6001 | CRAPAUD | 0.616193 | 1.0621 | 0.000078496 | 0.0001353 | 0 | 0.0228112 | 0.03421 | 17.2 | 80 | 110
CRAPAUD | 3732.37 | 19371.3 | 650.711 | +3.718 | +3.739 | H56 | H56 | 6 | 6001 | CRAPAUD | 0.616193 | 1.0621 | 0.000078496 | 0.0001353 | 0 | 0.0228112 | 0.03421 | 17.2 | 80 | 110
CRAPAUD | 3716.01 | 19528.7 | 1118.02 | +3.702 | +3.723 | H56 | H56 | 6 | 6001 | CRAPAUD | 0.616193 | 1.0621 | 0.000078496 | 0.0001353 | 0 | 0.0228112 | 0.03421 | 17.2 | 80 | 110
CRAPAUD | 3716.01 | 19371.3 | 1118.02 | +3.702 | +3.723 | H56 | H56 | 6 | 6001 | CRAPAUD | 0.616193 | 1.0621 | 0.000078496 | 0.0001353 | 0 | 0.0228112 | 0.03421 | 17.2 | 80 | 110
CRAPAUD | 3639.09 | 19528.7 | 3315.71 | +3.625 | +3.646 | H56 | H56 | 6 | 6001 | CRAPAUD | 0.616193 | 1.0621 | 0.000078496 | 0.0001353 | 0 | 0.0228112 | 0.03421 | 17.2 | 80 | 110
CRAPAUD | 3639.09 | 19371.3 | 3315.71 | +3.625 | +3.646 | H56 | H56 | 6 | 6001 | CRAPAUD | 0.616193 | 1.0621 | 0.000078496 | 0.0001353 | 0 | 0.0228112 | 0.03421 | 17.2 | 80 | 110
CRAPAUD | 3732.37 | 22060 | 650.711 | +3.718 | +3.739 | H56 | H56 | 6 | 6001 | CRAPAUD | 0.616193 | 1.0621 | 0.000078496 | 0.0001353 | 0 | 0.0228112 | 0.03421 | 17.2 | 80 | 110
CRAPAUD | 3732.37 | 21902.5 | 650.711 | +3.718 | +3.739 | H56 | H56 | 6 | 6001 | CRAPAUD | 0.616193 | 1.0621 | 0.000078496 | 0.0001353 | 0 | 0.0228112 | 0.03421 | 17.2 | 80 | 110
CRAPAUD | 3716.01 | 21902.5 | 1118.02 | +3.702 | +3.723 | H56 | H56 | 6 | 6001 | CRAPAUD | 0.616193 | 1.0621 | 0.000078496 | 0.0001353 | 0 | 0.0228112 | 0.03421 | 17.2 | 80 | 110
CRAPAUD | 3716.01 | 22060 | 1118.02 | +3.702 | +3.723 | H56 | H56 | 6 | 6001 | CRAPAUD | 0.616193 | 1.0621 | 0.000078496 | 0.0001353 | 0 | 0.0228112 | 0.03421 | 17.2 | 80 | 110
CRAPAUD | 3639.09 | 22060 | 3315.71 | +3.625 | +3.646 | H56 | H56 | 6 | 6001 | CRAPAUD | 0.616193 | 1.0621 | 0.000078496 | 0.0001353 | 0 | 0.0228112 | 0.03421 | 17.2 | 80 | 110
CRAPAUD | 3639.09 | 21902.5 | 3315.71 | +3.625 | +3.646 | H56 | H56 | 6 | 6001 | CRAPAUD | 0.616193 | 1.0621 | 0.000078496 | 0.0001353 | 0 | 0.0228112 | 0.03421 | 17.2 | 80 | 110
CRAPAUD | 3732.37 | 24433.8 | 650.711 | +3.718 | +3.739 | H56 | H56 | 6 | 6001 | CRAPAUD | 0.616193 | 1.0621 | 0.000078496 | 0.0001353 | 0 | 0.0228112 | 0.03421 | 17.2 | 80 | 110
CRAPAUD | 3732.37 | 24591.2 | 650.711 | +3.718 | +3.739 | H56 | H56 | 6 | 6001 | CRAPAUD | 0.616193 | 1.0621 | 0.000078496 | 0.0001353 | 0 | 0.0228112 | 0.03421 | 17.2 | 80 | 110
CRAPAUD | 3716.01 | 24433.8 | 1118.02 | +3.702 | +3.723 | H56 | H56 | 6 | 6001 | CRAPAUD | 0.616193 | 1.0621 | 0.000078496 | 0.0001353 | 0 | 0.0228112 | 0.03421 | 17.2 | 80 | 110
CRAPAUD | 3716.01 | 24591.2 | 1118.02 | +3.702 | +3.723 | H56 | H56 | 6 | 6001 | CRAPAUD | 0.616193 | 1.0621 | 0.000078496 | 0.0001353 | 0 | 0.0228112 | 0.03421 | 17.2 | 80 | 110
CRAPAUD | 3732.37 | 29496.3 | 650.711 | +3.718 | +3.739 | H56 | H56 | 6 | 6001 | CRAPAUD | 0.616193 | 1.0621 | 0.000078496 | 0.0001353 | 0 | 0.0228112 | 0.03421 | 17.2 | 80 | 110
CRAPAUD | 3732.37 | 29653.7 | 650.711 | +3.718 | +3.739 | H56 | H56 | 6 | 6001 | CRAPAUD | 0.616193 | 1.0621 | 0.000078496 | 0.0001353 | 0 | 0.0228112 | 0.03421 | 17.2 | 80 | 110
CRAPAUD | 3716.01 | 29496.3 | 1118.02 | +3.702 | +3.723 | H56 | H56 | 6 | 6001 | CRAPAUD | 0.616193 | 1.0621 | 0.000078496 | 0.0001353 | 0 | 0.0228112 | 0.03421 | 17.2 | 80 | 110
CRAPAUD | 3716.01 | 29653.7 | 1118.02 | +3.702 | +3.723 | H56 | H56 | 6 | 6001 | CRAPAUD | 0.616193 | 1.0621 | 0.000078496 | 0.0001353 | 0 | 0.0228112 | 0.03421 | 17.2 | 80 | 110
CRAPAUD | 3732.37 | 26965 | 650.711 | +3.718 | +3.739 | H56 | H56 | 6 | 6001 | CRAPAUD | 0.616193 | 1.0621 | 0.000078496 | 0.0001353 | 0 | 0.0228112 | 0.03421 | 17.2 | 80 | 110
CRAPAUD | 3732.37 | 27122.5 | 650.711 | +3.718 | +3.739 | H56 | H56 | 6 | 6001 | CRAPAUD | 0.616193 | 1.0621 | 0.000078496 | 0.0001353 | 0 | 0.0228112 | 0.03421 | 17.2 | 80 | 110
CRAPAUD | 3716.01 | 27122.5 | 1118.02 | +3.702 | +3.723 | H56 | H56 | 6 | 6001 | CRAPAUD | 0.616193 | 1.0621 | 0.000078496 | 0.0001353 | 0 | 0.0228112 | 0.03421 | 17.2 | 80 | 110
CRAPAUD | 3716.01 | 26965 | 1118.02 | +3.702 | +3.723 | H56 | H56 | 6 | 6001 | CRAPAUD | 0.616193 | 1.0621 | 0.000078496 | 0.0001353 | 0 | 0.0228112 | 0.03421 | 17.2 | 80 | 110
CRAPAUD | 3732.37 | 32165 | 650.711 | +3.718 | +3.739 | H56 | H56 | 6 | 6001 | CRAPAUD | 0.616193 | 1.0621 | 0.000078496 | 0.0001353 | 0 | 0.0228112 | 0.03421 | 17.2 | 80 | 110
CRAPAUD | 3732.37 | 32322.5 | 650.711 | +3.718 | +3.739 | H56 | H56 | 6 | 6001 | CRAPAUD | 0.616193 | 1.0621 | 0.000078496 | 0.0001353 | 0 | 0.0228112 | 0.03421 | 17.2 | 80 | 110
CRAPAUD | 3716.01 | 32322.5 | 1118.02 | +3.702 | +3.723 | H56 | H56 | 6 | 6001 | CRAPAUD | 0.616193 | 1.0621 | 0.000078496 | 0.0001353 | 0 | 0.0228112 | 0.03421 | 17.2 | 80 | 110
CRAPAUD | 3716.01 | 32165 | 1118.02 | +3.702 | +3.723 | H56 | H56 | 6 | 6001 | CRAPAUD | 0.616193 | 1.0621 | 0.000078496 | 0.0001353 | 0 | 0.0228112 | 0.03421 | 17.2 | 80 | 110
CRAPAUD | 3537.06 | 15268.7 | 6230.74 | +3.523 | +3.544 | H56 | H56 | 6 | 6001 | CRAPAUD | 0.616193 | 1.0621 | 0.000078496 | 0.0001353 | 0 | 0.0228112 | 0.03421 | 17.2 | 80 | 110
CRAPAUD | 3537.06 | 15111.3 | 6230.74 | +3.523 | +3.544 | H56 | H56 | 6 | 6001 | CRAPAUD | 0.616193 | 1.0621 | 0.000078496 | 0.0001353 | 0 | 0.0228112 | 0.03421 | 17.2 | 80 | 110
CRAPAUD | 3537.06 | 24433.8 | 3220.74 | +3.523 | +3.544 | H56 | H56 | 6 | 6001 | CRAPAUD | 0.616193 | 1.0621 | 0.000078496 | 0.0001353 | 0 | 0.0228112 | 0.03421 | 17.2 | 80 | 110
CRAPAUD | 3537.06 | 24591.2 | 3220.74 | +3.523 | +3.544 | H56 | H56 | 6 | 6001 | CRAPAUD | 0.616193 | 1.0621 | 0.000078496 | 0.0001353 | 0 | 0.0228112 | 0.03421 | 17.2 | 80 | 110
ATTACHE | 3145.98 | 20722.9 | 79332.1 | +3.096 | +3.196 | H57 | H57 | 7 | 7001 | ATTACHE | 0.95456 | 0.96555 | 0.0001216 | 0.000123 | 0.001216 | 0.034432 | 0.0311 | 80 | 80 | 100
ATTACHE | 2155 | 20722.9 | 79332.1 | +2.105 | +2.205 | H57 | H57 | 7 | 7001 | ATTACHE | 0.95456 | 0.96555 | 0.0001216 | 0.000123 | 0.001216 | 0.034432 | 0.0311 | 80 | 80 | 100
ATTACHE | 3695.29 | 19826 | 78232.1 | +3.645 | +3.745 | H60 | H60 | 7 | 7001 | ATTACHE | 0.95456 | 0.96555 | 0.0001216 | 0.000123 | 0.001216 | 0.034432 | 0.0311 | 80 | 80 | 100

# IfcBeam: L90*9 (2)
In: Undefined
Description: L90*9; Material: STEEL/E24-2
Tekla Common - Phase: 1; Class: 1011; Finish: GRENAILLE-PEINT; Grade: E24-2; Profile: L90*9; sets with these values: 2
Tekla Quantity - Gross footprint area: 0.001539 m2; Area per tons: 28.8473 m2; Height: 90 mm; Width: 90 mm; sets with these values: 2
Name | Center of gravity Z (mm) | Center of gravity Y (mm) | Center of gravity X (mm) | Bottom elevation | Top elevation | Part mark | Assembly mark | Name | Net weight (kg) = NetWeight (kg) | Gross weight (kg) = Weight (kg) | Net volume (m3) = NetVolume (m3) | Gross volume (m3) | Net surface area (m2) | Gross area (m2) = OuterSurfaceArea (m2) | Tekla Quantity, Length (mm) = BaseQuantities, Length (mm)
PLATINE | 3974.78 | 69149.2 | 79160.8 | +3.867 | +4.083 | 1236 | P17 | PLATINE | 2.60953 | 2.62818 | 0.000332424 | 0.0003348 | 0.080838 | 0.075816 | 216
ATTACHE | 3820 | 13680.8 | 71784.1 | +3.685 | +3.955 | H74 | H74 | ATTACHE | 3.26191 | 3.28523 | 0.00041553 | 0.0004185 | 0.100278 | 0.09477 | 270

# IfcBeam: PL10*120 (17)
In: Undefined
Description: PL10*120
Tekla Common - Phase: 1; Profile: PL10*120; Name: PLAT; sets with these values: 2
Tekla Quantity - Height: 120 mm; Width: 10 mm; sets with these values: 2
Name | Material | Center of gravity Z (mm) | Center of gravity Y (mm) | Center of gravity X (mm) | Bottom elevation | Top elevation | Part mark | Assembly mark | Class | Finish | Grade | Net weight (kg) = Gross weight (kg) = Weight (kg) = NetWeight (kg) | Net volume (m3) = Gross volume (m3) = NetVolume (m3) | Gross footprint area (m2) | Area per tons (m2) | Net surface area (m2) = Gross area (m2) = OuterSurfaceArea (m2) | Tekla Quantity, Length (mm) = BaseQuantities, Length (mm)
PLAT | STEEL/S235JR | 3846.16 | 18227 | 77003.8 | +3.839 | +3.853 | 234 | P56 | 1008 | GALVANISE | S235JR | 2.0724 | 0.000264 | 0 | 28.7589 | 0.0596 | 220
PLAT | STEEL/S235JR | 3816.99 | 18227 | 77944.8 | +3.810 | +3.824 | 234 | P57 | 1008 | GALVANISE | S235JR | 2.0724 | 0.000264 | 0 | 28.7589 | 0.0596 | 220
PLAT | STEEL/E24-2 | 3861.92 | 26050 | 71825.1 | +3.764 | +3.959 | 280 | K87 | 1010 | GRENAILLE-PEINT | E24-2 | 1.8369 | 0.000234 | 0.0012 | 28.9074 | 0.0531 | 195
PLAT | STEEL/E24-2 | 3861.92 | 17716.7 | 71825.1 | +3.764 | +3.959 | 280 | K88 | 1010 | GRENAILLE-PEINT | E24-2 | 1.8369 | 0.000234 | 0.0012 | 28.9074 | 0.0531 | 195
