Properties of the parts of a building model (IFC2X3), part 32 of 32

# IfcPlate: PL8*69 (10)
Tekla Quantity - Net weight: 0.736098 kg; Gross weight: 0.736098 kg; Weight: 0.736098 kg; Net volume: 0.0000937705 m3; Gross volume: 0.0000937705 m3; Gross footprint area: 0.0005516 m2; Area per tons: 37.0409 m2; Net surface area: 0.0272658 m2; Gross area: 0.0117213 m2; Height: 68.95 mm; Width: 8 mm; Length: 169.997 mm; sets with these values: 2
Name | Material | Center of gravity Z (mm) | Center of gravity Y (mm) | Center of gravity X (mm) | Bottom elevation | Top elevation | Part mark | Assembly mark | Phase | Class | Grade
ATTACHE | STEEL/S235JR | 4956.4 | 69197.5 | 50037.5 | +4.871 | +5.041 | 738 | H6 | 1 | 1001 | S235JR
ATTACHE | STEEL/S235JR | 4956.4 | 69197.5 | 61712.5 | +4.871 | +5.041 | 738 | H6 | 1 | 1001 | S235JR
ATTACHE | STEEL/S235JR | 4718.77 | -47.525 | 28633 | +4.634 | +4.804 | 724 | H5 | 3 | 3001 | S235JR
ATTACHE | STEEL/S235JR | 4956.4 | -47.525 | 38362.5 | +4.871 | +5.041 | 724 | H5 | 3 | 3001 | S235JR
ATTACHE | STEEL/S235JR | 4956.4 | -47.525 | 61712.5 | +4.871 | +5.041 | 738 | H6 | 1 | 1001 | S235JR
ATTACHE | STEEL/S235JR | 5048.46 | -47.525 | 74420 | +4.963 | +5.133 | 738 | H6 | 1 | 1001 | S235JR
ATTACHE | STEEL/S235JR | 4956.4 | -47.525 | 50037.5 | +4.871 | +5.041 | 738 | H6 | 1 | 1001 | S235JR
ATTACHE | STEEL/S235JR | 5194.03 | -47.525 | 24742 | +5.109 | +5.279 | 724 | H5 | 3 | 3001 | S235JR
ATTACHE | STEEL/S235JR | 4956.4 | 69197.5 | 73387.5 | +4.871 | +5.041 | 738 | H6 | 1 | 1001 | S235JR
ATTACHE | STEEL/E24-2 | 4956.4 | 69197.5 | 38362.5 | +4.871 | +5.041 | 713 | H1 | 3 | 3001 | E24-2

# IfcPlate: PL8*79 (2)
In: Undefined
Description: PL8*79; Material: STEEL/S235JR
Tekla Common - Center of gravity Y: 9985.92 mm; Part mark: 679; Assembly mark: L52; Phase: 2; Class: 2003; Finish: GRENAILLE-PEINT; Grade: S235JR; Profile: PL8*79; Name: TOLE; sets with these values: 2
Tekla Quantity - Net weight: 0.69551 kg; Gross weight: 0.99224 kg; Weight: 0.69551 kg; Net volume: 0.0000886 m3; Gross volume: 0.0000886 m3; Gross footprint area: 0.011075 m2; Area per tons: 37.5061 m2; Net surface area: 0.0260859 m2; Gross area: 0.0158 m2; Height: 79 mm; Width: 8 mm; Length: 200 mm; sets with these values: 2
Name | Center of gravity Z (mm) | Center of gravity X (mm) | Bottom elevation | Top elevation
TOLE | 3609.67 | 9150.49 | +3.606 | +3.614
TOLE | 3920 | 84.114 | +3.916 | +3.924

# IfcPlate: PL8*80 (24)
In: Undefined
Description: PL8*80
Tekla Common - Finish: GRENAILLE-PEINT; Profile: PL8*80; sets with these values: 2
Tekla Quantity - Width: 8 mm; sets with these values: 2
Name | Material | Center of gravity Z (mm) | Center of gravity Y (mm) | Center of gravity X (mm) | Bottom elevation | Top elevation | Part mark | Assembly mark | Phase | Class | Grade | Name | Net weight (kg) = Weight (kg) | Gross weight (kg) | Net volume (m3) = Gross volume (m3) | Gross footprint area (m2) | Area per tons (m2) | Net surface area (m2) | Gross area (m2) | Height (mm) | Length (mm)
GOUSSET | STEEL/S235JR | 3426.61 | 45766.7 | 9349.28 | +3.354 | +3.502 | 758 | K60 | 2 | 2005 | S235JR | GOUSSET | 0.716573 | 0.74401 | 0.0000912832 | 0.00044 | 36.6884 | 0.0262899 | 0.0118473 | 80 | 148.091
GOUSSET | STEEL/S235JR | 3426.61 | 43008.3 | 9349.28 | +3.354 | +3.502 | 758 | K67 | 2 | 2005 | S235JR | GOUSSET | 0.716573 | 0.74401 | 0.0000912832 | 0.00044 | 36.6884 | 0.0262899 | 0.0118473 | 80 | 148.091
GOUSSET | STEEL/S235JR | 3426.61 | 40250 | 9349.28 | +3.354 | +3.502 | 758 | K64 | 2 | 2005 | S235JR | GOUSSET | 0.716573 | 0.74401 | 0.0000912832 | 0.00044 | 36.6884 | 0.0262899 | 0.0118473 | 80 | 148.091
GOUSSET | STEEL/S235JR | 3426.61 | 13060 | 9349.28 | +3.354 | +3.502 | 758 | K72 | 2 | 2005 | S235JR | GOUSSET | 0.716573 | 0.74401 | 0.0000912832 | 0.00044 | 36.6884 | 0.0262899 | 0.0118473 | 80 | 148.091
GOUSSET | STEEL/S235JR | 3426.61 | 15190 | 9349.28 | +3.354 | +3.502 | 758 | K63 | 2 | 2005 | S235JR | GOUSSET | 0.716573 | 0.74401 | 0.0000912832 | 0.00044 | 36.6884 | 0.0262899 | 0.0118473 | 80 | 148.091
GOUSSET | STEEL/S235JR | 3426.61 | 17320 | 9349.28 | +3.354 | +3.502 | 758 | K68 | 2 | 2005 | S235JR | GOUSSET | 0.716573 | 0.74401 | 0.0000912832 | 0.00044 | 36.6884 | 0.0262899 | 0.0118473 | 80 | 148.091
GOUSSET | STEEL/S235JR | 3426.61 | 19450 | 9349.28 | +3.354 | +3.502 | 758 | K66 | 2 | 2005 | S235JR | GOUSSET | 0.716573 | 0.74401 | 0.0000912832 | 0.00044 | 36.6884 | 0.0262899 | 0.0118473 | 80 | 148.091
GOUSSET | STEEL/S235JR | 3426.61 | 21981.2 | 9349.28 | +3.354 | +3.502 | 758 | K71 | 2 | 2005 | S235JR | GOUSSET | 0.716573 | 0.74401 | 0.0000912832 | 0.00044 | 36.6884 | 0.0262899 | 0.0118473 | 80 | 148.091
GOUSSET | STEEL/S235JR | 3426.61 | 27043.8 | 9349.28 | +3.354 | +3.502 | 758 | K71 | 2 | 2005 | S235JR | GOUSSET | 0.716573 | 0.74401 | 0.0000912832 | 0.00044 | 36.6884 | 0.0262899 | 0.0118473 | 80 | 148.091
 | STEEL/E24-2 | 4123.5 | -68.0608 | 20975.2 | +4.099 | +4.139 | 723 | B7 | 3 | 3001 | E24-2 |  | 0.542939 | 0.807485 | 0.0000691642 | 0 | 37.8236 | 0.0205359 | 0.012858 | 79.9039 | 160.919
 | STEEL/E24-2 | 4988.64 | -68.0608 | 24186.4 | +4.973 | +5.013 | 723 | B7 | 3 | 3001 | E24-2 |  | 0.542937 | 0.807476 | 0.000069164 | 0 | 37.8236 | 0.0205358 | 0.0128579 | 79.903 | 160.919
 | STEEL/E24-2 | 4988.64 | -68.0608 | 35861.4 | +4.973 | +5.013 | 723 | B7 | 3 | 3001 | E24-2 |  | 0.542937 | 0.807476 | 0.000069164 | 0 | 37.8236 | 0.0205358 | 0.0128579 | 79.903 | 160.919
 | STEEL/E24-2 | 4123.5 | -68.0608 | 32650.2 | +4.099 | +4.139 | 723 | B7 | 3 | 3001 | E24-2 |  | 0.542939 | 0.807485 | 0.0000691642 | 0 | 37.8236 | 0.0205359 | 0.012858 | 79.9039 | 160.919
 | STEEL/E24-2 | 4988.64 | -68.0608 | 59211.4 | +4.973 | +5.013 | 723 | B7 | 1 | 1002 | E24-2 |  | 0.542937 | 0.807476 | 0.000069164 | 0 | 37.8236 | 0.0205358 | 0.0128579 | 79.903 | 160.919
 | STEEL/E24-2 | 4123.5 | -68.0608 | 56000.2 | +4.099 | +4.139 | 723 | B7 | 1 | 1002 | E24-2 |  | 0.542939 | 0.807485 | 0.0000691642 | 0 | 37.8236 | 0.0205359 | 0.012858 | 79.9039 | 160.919
 | STEEL/E24-2 | 4928.76 | -68.0608 | 70664.2 | +4.913 | +4.953 | 723 | B8 | 1 | 1002 | E24-2 |  | 0.542937 | 0.807476 | 0.000069164 | 0 | 37.8236 | 0.0205358 | 0.0128579 | 79.903 | 160.919
 | STEEL/E24-2 | 4123.5 | -68.0608 | 67675.2 | +4.099 | +4.139 | 723 | B8 | 1 | 1002 | E24-2 |  | 0.542939 | 0.807485 | 0.0000691642 | 0 | 37.8236 | 0.0205359 | 0.012858 | 79.9039 | 160.919
 | STEEL/E24-2 | 2291.66 | -68.0608 | 49795.5 | +2.264 | +2.309 | 723 | B5 | 1 | 1002 | E24-2 |  | 0.542939 | 0.807485 | 0.0000691642 | 0 | 37.8236 | 0.0205359 | 0.012858 | 79.9039 | 160.919
 | STEEL/E24-2 | 4048.08 | -68.0608 | 44329.7 | +4.030 | +4.076 | 723 | B5 | 1 | 1002 | E24-2 |  | 0.542939 | 0.807485 | 0.0000691642 | 0 | 37.8236 | 0.0205359 | 0.012858 | 79.9039 | 160.919
GOUSSET | STEEL/S235JR | 3426.61 | 32243.8 | 9349.28 | +3.354 | +3.502 | 758 | K69 | 2 | 2005 | S235JR | GOUSSET | 0.716573 | 0.74401 | 0.0000912832 | 0.00044 | 36.6884 | 0.0262899 | 0.0118473 | 80 | 148.091
GOUSSET | STEEL/S235JR | 3426.61 | 29575 | 9349.28 | +3.354 | +3.502 | 758 | K62 | 2 | 2005 | S235JR | GOUSSET | 0.716573 | 0.74401 | 0.0000912832 | 0.00044 | 36.6884 | 0.0262899 | 0.0118473 | 80 | 148.091
GOUSSET | STEEL/S235JR | 3426.61 | 34912.5 | 9349.28 | +3.354 | +3.502 | 758 | K61 | 2 | 2005 | S235JR | GOUSSET | 0.716573 | 0.74401 | 0.0000912832 | 0.00044 | 36.6884 | 0.0262899 | 0.0118473 | 80 | 148.091
GOUSSET | STEEL/S235JR | 3426.61 | 37581.2 | 9349.28 | +3.354 | +3.502 | 758 | K70 | 2 | 2005 | S235JR | GOUSSET | 0.716573 | 0.74401 | 0.0000912832 | 0.00044 | 36.6884 | 0.0262899 | 0.0118473 | 80 | 148.091
GOUSSET | STEEL/S235JR | 3426.61 | 24512.5 | 9349.28 | +3.354 | +3.502 | 758 | K65 | 2 | 2005 | S235JR | GOUSSET | 0.716573 | 0.74401 | 0.0000912832 | 0.00044 | 36.6884 | 0.0262899 | 0.0118473 | 80 | 148.091

# IfcPlate: PL8*90 (3)
In: Undefined
Description: PL8*90; Material: STEEL/E24-2
Tekla Common - Center of gravity Z: 5507.82 mm; Center of gravity Y: 61099.8 mm; Bottom elevation: +5.481; Top elevation: +5.534; Part mark: 714; Phase: 1; Class: 1001; Finish: GRENAILLE-PEINT; Grade: E24-2; Profile: PL8*90; Name: GOUSSET; sets with these values: 2
Tekla Quantity - Net weight: 2.07634 kg; Gross weight: 2.10163 kg; Weight: 2.07634 kg; Net volume: 0.000264502 m3; Gross volume: 0.000264502 m3; Gross footprint area: 0 m2; Area per tons: 35.3154 m2; Net surface area: 0.0733269 m2; Gross area: 0.0334654 m2; Height: 90.0093 mm; Width: 8 mm; Length: 371.799 mm; sets with these values: 2
Name | Center of gravity X (mm) | Assembly mark
GOUSSET | 55940 | P2
GOUSSET | 44265 | P1
GOUSSET | 67615 | P37

# IfcPlate: PL8*95 (10)
In: Undefined
Description: PL8*95; Material: STEEL/S235JR
Tekla Common - Center of gravity Z: 3314.67 mm; Center of gravity X: 9242.5 mm; Bottom elevation: +3.231; Top elevation: +3.399; Part mark: 829; Phase: 2; Class: 2006; Finish: GRENAILLE-PEINT; Grade: S235JR; Profile: PL8*95; Name: TOLE; sets with these values: 2
Tekla Quantity - Net weight: 0.963038 kg; Gross weight: 1.00229 kg; Weight: 0.963038 kg; Net volume: 0.00012268 m3; Gross volume: 0.00012268 m3; Gross footprint area: 0.00056 m2; Area per tons: 35.9733 m2; Net surface area: 0.0346437 m2; Gross area: 0.01596 m2; Height: 95 mm; Width: 8 mm; Length: 168 mm; sets with these values: 2
Name | Center of gravity Y (mm) | Assembly mark
TOLE | 19541 | N3
TOLE | 19359 | N4
TOLE | 29484 | N3
TOLE | 29666 | N2
TOLE | 11011.5 | N4
TOLE | 10829.5 | N4
TOLE | 40341 | N1
TOLE | 40159 | N2
TOLE | 48606.5 | N1
TOLE | 48424.5 | N1
