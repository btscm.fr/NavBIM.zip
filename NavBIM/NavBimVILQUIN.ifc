Properties of the parts of a building model (IFC2X3), part 5 of 32

# IfcBeam: L60*6 (913)
Name | Material | Center of gravity Z (mm) | Center of gravity Y (mm) | Center of gravity X (mm) | Bottom elevation | Top elevation | Part mark | Assembly mark | Phase | Class | Finish | Grade | Name | Net weight (kg) = NetWeight (kg) | Gross weight (kg) = Weight (kg) | Net volume (m3) = NetVolume (m3) | Gross volume (m3) | Gross footprint area (m2) | Net surface area (m2) | Gross area (m2) = OuterSurfaceArea (m2) | Tekla Quantity, Length (mm) = BaseQuantities, Length (mm)
ATTACHE | STEEL/E24-2 | 4254.21 | 45219.3 | 44202.5 | +4.237 | +4.297 | H17 | H17 | 4 | 4001 | GRENAILLE-PEINT | E24-2 | ATTACHE | 1.42289 | 1.43745 | 0.00018126 | 0.000183115 | 0.00159 | 0.064968 | 0.061745 | 265
MONTANT | STEEL/E24-2 | 3993.5 | 45253.7 | 44082.2 | +3.605 | +4.382 | M7 | M7 | 4 | 4001 | GRENAILLE-PEINT | E24-2 | MONTANT | 4.17202 | 4.21472 | 0.000531468 | 0.000536907 | 0.000684 | 0.187848 | 0.181041 | 777
ATTACHE | STEEL/E24-2 | 3922.79 | 45219.3 | 44202.5 | +3.880 | +3.940 | H18 | H18 | 4 | 4001 | GRENAILLE-PEINT | E24-2 | ATTACHE | 1.42289 | 1.43745 | 0.00018126 | 0.000183115 | 0.0159 | 0.064968 | 0.061745 | 265
MONTANT | STEEL/E24-2 | 3993.5 | 35340.7 | 44082.2 | +3.605 | +4.382 | M7 | M7 | 4 | 4001 | GRENAILLE-PEINT | E24-2 | MONTANT | 4.17202 | 4.21472 | 0.000531468 | 0.000536907 | 0.000684 | 0.187848 | 0.181041 | 777
ATTACHE | STEEL/E24-2 | 3922.79 | 35306.3 | 44202.5 | +3.880 | +3.940 | H18 | H18 | 4 | 4001 | GRENAILLE-PEINT | E24-2 | ATTACHE | 1.42289 | 1.43745 | 0.00018126 | 0.000183115 | 0.0159 | 0.064968 | 0.061745 | 265
ATTACHE | STEEL/E24-2 | 4254.21 | 35306.3 | 44202.5 | +4.237 | +4.297 | H17 | H17 | 4 | 4001 | GRENAILLE-PEINT | E24-2 | ATTACHE | 1.42289 | 1.43745 | 0.00018126 | 0.000183115 | 0.00159 | 0.064968 | 0.061745 | 265
ATTACHE | STEEL/E24-2 | 4254.21 | 34819.3 | 44202.5 | +4.237 | +4.297 | H17 | H17 | 4 | 4001 | GRENAILLE-PEINT | E24-2 | ATTACHE | 1.42289 | 1.43745 | 0.00018126 | 0.000183115 | 0.00159 | 0.064968 | 0.061745 | 265
MONTANT | STEEL/E24-2 | 3993.5 | 34853.7 | 44082.2 | +3.605 | +4.382 | M7 | M7 | 4 | 4001 | GRENAILLE-PEINT | E24-2 | MONTANT | 4.17202 | 4.21472 | 0.000531468 | 0.000536907 | 0.000684 | 0.187848 | 0.181041 | 777
ATTACHE | STEEL/E24-2 | 3922.79 | 34819.3 | 44202.5 | +3.880 | +3.940 | H18 | H18 | 4 | 4001 | GRENAILLE-PEINT | E24-2 | ATTACHE | 1.42289 | 1.43745 | 0.00018126 | 0.000183115 | 0.0159 | 0.064968 | 0.061745 | 265
MONTANT | STEEL/E24-2 | 3993.5 | 32740.7 | 44082.2 | +3.605 | +4.382 | M11 | M11 | 4 | 4001 | GRENAILLE-PEINT | E24-2 | MONTANT | 4.17202 | 4.21472 | 0.000531468 | 0.000536907 | 0.000684 | 0.187848 | 0.181041 | 777
ATTACHE | STEEL/E24-2 | 3922.79 | 32706.3 | 44202.5 | +3.880 | +3.940 | H18 | H18 | 4 | 4001 | GRENAILLE-PEINT | E24-2 | ATTACHE | 1.42289 | 1.43745 | 0.00018126 | 0.000183115 | 0.0159 | 0.064968 | 0.061745 | 265
ATTACHE | STEEL/E24-2 | 4254.21 | 32706.3 | 44202.5 | +4.237 | +4.297 | H17 | H17 | 4 | 4001 | GRENAILLE-PEINT | E24-2 | ATTACHE | 1.42289 | 1.43745 | 0.00018126 | 0.000183115 | 0.00159 | 0.064968 | 0.061745 | 265
ATTACHE | STEEL/E24-2 | 4254.21 | 32219.3 | 44202.5 | +4.237 | +4.297 | H17 | H17 | 4 | 4001 | GRENAILLE-PEINT | E24-2 | ATTACHE | 1.42289 | 1.43745 | 0.00018126 | 0.000183115 | 0.00159 | 0.064968 | 0.061745 | 265
MONTANT | STEEL/E24-2 | 3993.5 | 32253.7 | 44082.2 | +3.605 | +4.382 | M7 | M7 | 4 | 4001 | GRENAILLE-PEINT | E24-2 | MONTANT | 4.17202 | 4.21472 | 0.000531468 | 0.000536907 | 0.000684 | 0.187848 | 0.181041 | 777
ATTACHE | STEEL/E24-2 | 3922.79 | 32219.3 | 44202.5 | +3.880 | +3.940 | H18 | H18 | 4 | 4001 | GRENAILLE-PEINT | E24-2 | ATTACHE | 1.42289 | 1.43745 | 0.00018126 | 0.000183115 | 0.0159 | 0.064968 | 0.061745 | 265
MONTANT | STEEL/E24-2 | 3993.5 | 30140.7 | 44082.2 | +3.605 | +4.382 | M7 | M7 | 4 | 4001 | GRENAILLE-PEINT | E24-2 | MONTANT | 4.17202 | 4.21472 | 0.000531468 | 0.000536907 | 0.000684 | 0.187848 | 0.181041 | 777
ATTACHE | STEEL/E24-2 | 3922.79 | 30106.3 | 44202.5 | +3.880 | +3.940 | H18 | H18 | 4 | 4001 | GRENAILLE-PEINT | E24-2 | ATTACHE | 1.42289 | 1.43745 | 0.00018126 | 0.000183115 | 0.0159 | 0.064968 | 0.061745 | 265
ATTACHE | STEEL/E24-2 | 4254.21 | 30106.3 | 44202.5 | +4.237 | +4.297 | H17 | H17 | 4 | 4001 | GRENAILLE-PEINT | E24-2 | ATTACHE | 1.42289 | 1.43745 | 0.00018126 | 0.000183115 | 0.00159 | 0.064968 | 0.061745 | 265
ATTACHE | STEEL/E24-2 | 4254.21 | 29619.3 | 44202.5 | +4.237 | +4.297 | H17 | H17 | 4 | 4001 | GRENAILLE-PEINT | E24-2 | ATTACHE | 1.42289 | 1.43745 | 0.00018126 | 0.000183115 | 0.00159 | 0.064968 | 0.061745 | 265
MONTANT | STEEL/E24-2 | 3993.5 | 29653.7 | 44082.2 | +3.605 | +4.382 | M7 | M7 | 4 | 4001 | GRENAILLE-PEINT | E24-2 | MONTANT | 4.17202 | 4.21472 | 0.000531468 | 0.000536907 | 0.000684 | 0.187848 | 0.181041 | 777
ATTACHE | STEEL/E24-2 | 3922.79 | 29619.3 | 44202.5 | +3.880 | +3.940 | H18 | H18 | 4 | 4001 | GRENAILLE-PEINT | E24-2 | ATTACHE | 1.42289 | 1.43745 | 0.00018126 | 0.000183115 | 0.0159 | 0.064968 | 0.061745 | 265
MONTANT | STEEL/E24-2 | 3993.5 | 27540.7 | 44082.2 | +3.605 | +4.382 | M11 | M11 | 4 | 4001 | GRENAILLE-PEINT | E24-2 | MONTANT | 4.17202 | 4.21472 | 0.000531468 | 0.000536907 | 0.000684 | 0.187848 | 0.181041 | 777
ATTACHE | STEEL/E24-2 | 3922.79 | 27506.3 | 44202.5 | +3.880 | +3.940 | H18 | H18 | 4 | 4001 | GRENAILLE-PEINT | E24-2 | ATTACHE | 1.42289 | 1.43745 | 0.00018126 | 0.000183115 | 0.0159 | 0.064968 | 0.061745 | 265
ATTACHE | STEEL/E24-2 | 4254.21 | 27506.3 | 44202.5 | +4.237 | +4.297 | H17 | H17 | 4 | 4001 | GRENAILLE-PEINT | E24-2 | ATTACHE | 1.42289 | 1.43745 | 0.00018126 | 0.000183115 | 0.00159 | 0.064968 | 0.061745 | 265
ATTACHE | STEEL/E24-2 | 4254.21 | 27019.3 | 44202.5 | +4.237 | +4.297 | H17 | H17 | 4 | 4001 | GRENAILLE-PEINT | E24-2 | ATTACHE | 1.42289 | 1.43745 | 0.00018126 | 0.000183115 | 0.00159 | 0.064968 | 0.061745 | 265
MONTANT | STEEL/E24-2 | 3993.5 | 27053.7 | 44082.2 | +3.605 | +4.382 | M7 | M7 | 4 | 4001 | GRENAILLE-PEINT | E24-2 | MONTANT | 4.17202 | 4.21472 | 0.000531468 | 0.000536907 | 0.000684 | 0.187848 | 0.181041 | 777
ATTACHE | STEEL/E24-2 | 3922.79 | 27019.3 | 44202.5 | +3.880 | +3.940 | H18 | H18 | 4 | 4001 | GRENAILLE-PEINT | E24-2 | ATTACHE | 1.42289 | 1.43745 | 0.00018126 | 0.000183115 | 0.0159 | 0.064968 | 0.061745 | 265
MONTANT | STEEL/E24-2 | 3993.5 | 24940.7 | 44082.2 | +3.605 | +4.382 | M7 | M7 | 4 | 4001 | GRENAILLE-PEINT | E24-2 | MONTANT | 4.17202 | 4.21472 | 0.000531468 | 0.000536907 | 0.000684 | 0.187848 | 0.181041 | 777
ATTACHE | STEEL/E24-2 | 3922.79 | 24906.3 | 44202.5 | +3.880 | +3.940 | H18 | H18 | 4 | 4001 | GRENAILLE-PEINT | E24-2 | ATTACHE | 1.42289 | 1.43745 | 0.00018126 | 0.000183115 | 0.0159 | 0.064968 | 0.061745 | 265
ATTACHE | STEEL/E24-2 | 4254.21 | 24906.3 | 44202.5 | +4.237 | +4.297 | H17 | H17 | 4 | 4001 | GRENAILLE-PEINT | E24-2 | ATTACHE | 1.42289 | 1.43745 | 0.00018126 | 0.000183115 | 0.00159 | 0.064968 | 0.061745 | 265
ATTACHE | STEEL/E24-2 | 4254.21 | 24419.3 | 44202.5 | +4.237 | +4.297 | H17 | H17 | 4 | 4001 | GRENAILLE-PEINT | E24-2 | ATTACHE | 1.42289 | 1.43745 | 0.00018126 | 0.000183115 | 0.00159 | 0.064968 | 0.061745 | 265
MONTANT | STEEL/E24-2 | 3993.5 | 24453.7 | 44082.2 | +3.605 | +4.382 | M7 | M7 | 4 | 4001 | GRENAILLE-PEINT | E24-2 | MONTANT | 4.17202 | 4.21472 | 0.000531468 | 0.000536907 | 0.000684 | 0.187848 | 0.181041 | 777
ATTACHE | STEEL/E24-2 | 3922.79 | 24419.3 | 44202.5 | +3.880 | +3.940 | H18 | H18 | 4 | 4001 | GRENAILLE-PEINT | E24-2 | ATTACHE | 1.42289 | 1.43745 | 0.00018126 | 0.000183115 | 0.0159 | 0.064968 | 0.061745 | 265
MONTANT | STEEL/E24-2 | 3993.5 | 22340.7 | 44082.2 | +3.605 | +4.382 | M11 | M11 | 4 | 4001 | GRENAILLE-PEINT | E24-2 | MONTANT | 4.17202 | 4.21472 | 0.000531468 | 0.000536907 | 0.000684 | 0.187848 | 0.181041 | 777
ATTACHE | STEEL/E24-2 | 3922.79 | 22306.3 | 44202.5 | +3.880 | +3.940 | H18 | H18 | 4 | 4001 | GRENAILLE-PEINT | E24-2 | ATTACHE | 1.42289 | 1.43745 | 0.00018126 | 0.000183115 | 0.0159 | 0.064968 | 0.061745 | 265
ATTACHE | STEEL/E24-2 | 4254.21 | 22306.3 | 44202.5 | +4.237 | +4.297 | H17 | H17 | 4 | 4001 | GRENAILLE-PEINT | E24-2 | ATTACHE | 1.42289 | 1.43745 | 0.00018126 | 0.000183115 | 0.00159 | 0.064968 | 0.061745 | 265
MONTANT | STEEL/E24-2 | 3993.5 | 12660.7 | 44082.2 | +3.605 | +4.382 | M11 | M11 | 4 | 4001 | GRENAILLE-PEINT | E24-2 | MONTANT | 4.17202 | 4.21472 | 0.000531468 | 0.000536907 | 0.000684 | 0.187848 | 0.181041 | 777
ATTACHE | STEEL/E24-2 | 3922.79 | 12626.3 | 44202.5 | +3.880 | +3.940 | H18 | H18 | 4 | 4001 | GRENAILLE-PEINT | E24-2 | ATTACHE | 1.42289 | 1.43745 | 0.00018126 | 0.000183115 | 0.0159 | 0.064968 | 0.061745 | 265
ATTACHE | STEEL/E24-2 | 4254.21 | 12626.3 | 44202.5 | +4.237 | +4.297 | H17 | H17 | 4 | 4001 | GRENAILLE-PEINT | E24-2 | ATTACHE | 1.42289 | 1.43745 | 0.00018126 | 0.000183115 | 0.00159 | 0.064968 | 0.061745 | 265
MONTANT | STEEL/E24-2 | 3687.21 | 7857 | 44047.8 | +3.670 | +3.730 | M9 | M9 | 4 | 4001 | GRENAILLE-PEINT | E24-2 | MONTANT | 0.730237 | 0.73771 | 0.0000930238 | 0.0000939758 | 0.000815998 | 0.0340079 | 0.0316879 | 136
ATTACHE | STEEL/E24-2 | 3922.79 | 402.789 | 44202.5 | +3.880 | +3.940 | H18 | H18 | 4 | 4001 | GRENAILLE-PEINT | E24-2 | ATTACHE | 1.42289 | 1.43745 | 0.00018126 | 0.000183115 | 0.0159 | 0.064968 | 0.061745 | 265
ATTACHE | STEEL/E24-2 | 4254.21 | 402.789 | 44202.5 | +4.237 | +4.297 | H17 | H17 | 4 | 4001 | GRENAILLE-PEINT | E24-2 | ATTACHE | 1.42289 | 1.43745 | 0.00018126 | 0.000183115 | 0.00159 | 0.064968 | 0.061745 | 265
MONTANT | STEEL/E24-2 | 3993.5 | 437.211 | 44082.2 | +3.605 | +4.382 | M7 | M7 | 4 | 4001 | GRENAILLE-PEINT | E24-2 | MONTANT | 4.17202 | 4.21472 | 0.000531468 | 0.000536907 | 0.000684 | 0.187848 | 0.181041 | 777
 | STEEL/E24-2 | 4210.59 | 49590 | 32467.2 | +4.168 | +4.228 | 414 | L46 | 3 | 3003 | GRENAILLE-PEINT | E24-2 |  | 0.644328 | 0.650922 | 0.00008208 | 0.00008292 | 0.0072 | 0.030168 | 0.02796 | 120
 | STEEL/E24-2 | 5575.79 | 49590 | 32467.2 | +5.533 | +5.593 | 414 | L46 | 3 | 3003 | GRENAILLE-PEINT | E24-2 |  | 0.644328 | 0.650922 | 0.00008208 | 0.00008292 | 0.0072 | 0.030168 | 0.02796 | 120
ATTACHE | STEEL/E24-2 | 3261.98 | -605.675 | 44179.7 | +3.220 | +3.305 | H19 | H19 | 3 | 3003 | GRENAILLE-PEINT | E24-2 | ATTACHE | 0.451029 | 0.455645 | 0.000057456 | 0.000058044 | 0 | 0.021528 | 0.019572 | 84
ATTACHE | STEEL/E24-2 | 3261.21 | -566.865 | 44179.7 | +3.218 | +3.304 | H19 | H19 | 3 | 3003 | GRENAILLE-PEINT | E24-2 | ATTACHE | 0.451029 | 0.455645 | 0.000057456 | 0.000058044 | 0 | 0.021528 | 0.019572 | 83.9999
ATTACHE | STEEL/E24-2 | 3261.98 | -605.675 | 38382.8 | +3.220 | +3.305 | H19 | H19 | 3 | 3003 | GRENAILLE-PEINT | E24-2 | ATTACHE | 0.451029 | 0.455645 | 0.000057456 | 0.000058044 | 0 | 0.021528 | 0.019572 | 84
ATTACHE | STEEL/E24-2 | 3261.98 | -605.675 | 38342.2 | +3.220 | +3.305 | H19 | H19 | 3 | 3003 | GRENAILLE-PEINT | E24-2 | ATTACHE | 0.451029 | 0.455645 | 0.000057456 | 0.000058044 | 0 | 0.021528 | 0.019572 | 84
ATTACHE | STEEL/E24-2 | 3261.21 | -566.865 | 38342.2 | +3.218 | +3.304 | H19 | H19 | 3 | 3003 | GRENAILLE-PEINT | E24-2 | ATTACHE | 0.451029 | 0.455645 | 0.000057456 | 0.000058044 | 0 | 0.021528 | 0.019572 | 83.9999
ATTACHE | STEEL/E24-2 | 3261.21 | -566.865 | 38382.8 | +3.218 | +3.304 | H19 | H19 | 3 | 3003 | GRENAILLE-PEINT | E24-2 | ATTACHE | 0.451029 | 0.455645 | 0.000057456 | 0.000058044 | 0 | 0.021528 | 0.019572 | 84
ATTACHE | STEEL/E24-2 | 3261.21 | -566.865 | 32545.3 | +3.218 | +3.304 | H19 | H19 | 3 | 3003 | GRENAILLE-PEINT | E24-2 | ATTACHE | 0.451029 | 0.455645 | 0.000057456 | 0.000058044 | 0 | 0.021528 | 0.019572 | 84
ATTACHE | STEEL/E24-2 | 3261.98 | -605.675 | 32545.3 | +3.220 | +3.305 | H19 | H19 | 3 | 3003 | GRENAILLE-PEINT | E24-2 | ATTACHE | 0.451029 | 0.455645 | 0.000057456 | 0.000058044 | 0 | 0.021528 | 0.019572 | 84
ATTACHE | STEEL/E24-2 | 3261.98 | -605.675 | 32504.7 | +3.220 | +3.305 | H19 | H19 | 3 | 3003 | GRENAILLE-PEINT | E24-2 | ATTACHE | 0.451029 | 0.455645 | 0.000057456 | 0.000058044 | 0 | 0.021528 | 0.019572 | 84
ATTACHE | STEEL/E24-2 | 3261.21 | -566.865 | 32504.7 | +3.218 | +3.304 | H19 | H19 | 3 | 3003 | GRENAILLE-PEINT | E24-2 | ATTACHE | 0.451029 | 0.455645 | 0.000057456 | 0.000058044 | 0 | 0.021528 | 0.019572 | 84
ATTACHE | STEEL/E24-2 | 3261.98 | -605.675 | 28653.3 | +3.220 | +3.305 | H19 | H19 | 3 | 3003 | GRENAILLE-PEINT | E24-2 | ATTACHE | 0.451029 | 0.455645 | 0.000057456 | 0.000058044 | 0 | 0.021528 | 0.019572 | 84
ATTACHE | STEEL/E24-2 | 3261.21 | -566.865 | 28653.3 | +3.218 | +3.304 | H19 | H19 | 3 | 3003 | GRENAILLE-PEINT | E24-2 | ATTACHE | 0.451029 | 0.455645 | 0.000057456 | 0.000058044 | 0 | 0.021528 | 0.019572 | 84
ATTACHE | STEEL/E24-2 | 3261.21 | -566.865 | 28612.7 | +3.218 | +3.304 | H19 | H19 | 3 | 3003 | GRENAILLE-PEINT | E24-2 | ATTACHE | 0.451029 | 0.455645 | 0.000057456 | 0.000058044 | 0 | 0.021528 | 0.019572 | 84
ATTACHE | STEEL/E24-2 | 3261.98 | -605.675 | 24721.7 | +3.220 | +3.305 | H19 | H19 | 3 | 3003 | GRENAILLE-PEINT | E24-2 | ATTACHE | 0.451029 | 0.455645 | 0.000057456 | 0.000058044 | 0 | 0.021528 | 0.019572 | 84
ATTACHE | STEEL/E24-2 | 3261.21 | -566.865 | 24721.7 | +3.218 | +3.304 | H19 | H19 | 3 | 3003 | GRENAILLE-PEINT | E24-2 | ATTACHE | 0.451029 | 0.455645 | 0.000057456 | 0.000058044 | 0 | 0.021528 | 0.019572 | 84
ATTACHE | STEEL/E24-2 | 3261.21 | -566.865 | 24762.3 | +3.218 | +3.304 | H19 | H19 | 3 | 3003 | GRENAILLE-PEINT | E24-2 | ATTACHE | 0.451029 | 0.455645 | 0.000057456 | 0.000058044 | 0 | 0.021528 | 0.019572 | 84
ATTACHE | STEEL/E24-2 | 3261.98 | -605.675 | 24762.3 | +3.220 | +3.305 | H19 | H19 | 3 | 3003 | GRENAILLE-PEINT | E24-2 | ATTACHE | 0.45103 | 0.455645 | 0.000057456 | 0.000058044 | 0 | 0.021528 | 0.019572 | 84
ATTACHE | STEEL/E24-2 | 3261.98 | -605.675 | 20870.3 | +3.220 | +3.305 | H19 | H19 | 3 | 3003 | GRENAILLE-PEINT | E24-2 | ATTACHE | 0.45103 | 0.455645 | 0.000057456 | 0.000058044 | 0 | 0.021528 | 0.019572 | 84
ATTACHE | STEEL/E24-2 | 3261.21 | -566.865 | 20870.3 | +3.218 | +3.304 | H19 | H19 | 3 | 3003 | GRENAILLE-PEINT | E24-2 | ATTACHE | 0.45103 | 0.455645 | 0.000057456 | 0.000058044 | 0 | 0.021528 | 0.019572 | 84
ATTACHE | STEEL/E24-2 | 3261.98 | -605.675 | 28612.7 | +3.220 | +3.305 | H19 | H19 | 3 | 3003 | GRENAILLE-PEINT | E24-2 | ATTACHE | 0.451029 | 0.455645 | 0.000057456 | 0.000058044 | 0 | 0.021528 | 0.019572 | 84
ATTACHE | STEEL/S235JR | 7255 | 68017.3 | 23672.3 | +7.170 | +7.340 | H28 | H28 | 2 | 2007 | GALVANISE | S235JR | ATTACHE | 0.912798 | 0.92214 | 0.00011628 | 0.00011747 | 0.000684 | 0.042168 | 0.03961 | 170
ATTACHE | STEEL/S235JR | 7255 | 68017.3 | 27549.8 | +7.170 | +7.340 | H28 | H28 | 2 | 2007 | GALVANISE | S235JR | ATTACHE | 0.912798 | 0.92214 | 0.00011628 | 0.00011747 | 0.000684 | 0.042168 | 0.03961 | 170
ATTACHE | STEEL/S235JR | 7255 | 68057.7 | 23712.7 | +7.170 | +7.340 | H28 | H28 | 2 | 2007 | GALVANISE | S235JR | ATTACHE | 0.912798 | 0.92214 | 0.00011628 | 0.00011747 | 0.000684 | 0.042168 | 0.03961 | 170
ATTACHE | STEEL/S235JR | 7615 | 68057.7 | 27700.2 | +7.530 | +7.700 | H28 | H28 | 2 | 2007 | GALVANISE | S235JR | ATTACHE | 0.912798 | 0.92214 | 0.00011628 | 0.00011747 | 0.000684 | 0.042168 | 0.03961 | 170
ATTACHE | STEEL/S235JR | 3235.49 | 48504.7 | 9521.38 | +3.215 | +3.281 | H30 | H30 | 2 | 2005 | GRENAILLE-PEINT | S235JR | ATTACHE | 1.02019 | 1.03063 | 0.00012996 | 0.00013129 | 0 | 0.046968 | 0.04427 | 190
ATTACHE | STEEL/S235JR | 3233.89 | 45746.4 | 9469.68 | +3.215 | +3.278 | H31 | H31 | 2 | 2005 | GRENAILLE-PEINT | S235JR | ATTACHE | 0.590634 | 0.596678 | 0.00007524 | 0.00007601 | 0 | 0.027768 | 0.02563 | 110
ATTACHE | STEEL/S235JR | 3233.89 | 40270.3 | 9469.68 | +3.215 | +3.278 | H31 | H31 | 2 | 2005 | GRENAILLE-PEINT | S235JR | ATTACHE | 0.590634 | 0.596678 | 0.00007524 | 0.00007601 | 0 | 0.027768 | 0.02563 | 110
ATTACHE | STEEL/S235JR | 3233.89 | 40229.7 | 9469.68 | +3.215 | +3.278 | H31 | H31 | 2 | 2005 | GRENAILLE-PEINT | S235JR | ATTACHE | 0.590634 | 0.596678 | 0.00007524 | 0.00007601 | 0 | 0.027768 | 0.02563 | 110
ATTACHE | STEEL/S235JR | 3233.89 | 10950.3 | 9469.68 | +3.215 | +3.278 | H31 | H31 | 2 | 2005 | GRENAILLE-PEINT | S235JR | ATTACHE | 0.590634 | 0.596678 | 0.00007524 | 0.00007601 | 0 | 0.027768 | 0.02563 | 110
ATTACHE | STEEL/S235JR | 3233.89 | 15169.7 | 9469.68 | +3.215 | +3.278 | H31 | H31 | 2 | 2005 | GRENAILLE-PEINT | S235JR | ATTACHE | 0.590634 | 0.596678 | 0.00007524 | 0.00007601 | 0 | 0.027768 | 0.02563 | 110
ATTACHE | STEEL/S235JR | 3233.89 | 15210.3 | 9469.68 | +3.215 | +3.278 | H31 | H31 | 2 | 2005 | GRENAILLE-PEINT | S235JR | ATTACHE | 0.590634 | 0.596678 | 0.00007524 | 0.00007601 | 0 | 0.027768 | 0.02563 | 110
ATTACHE | STEEL/S235JR | 3233.89 | 19470.3 | 9469.68 | +3.215 | +3.278 | H31 | H31 | 2 | 2005 | GRENAILLE-PEINT | S235JR | ATTACHE | 0.590634 | 0.596678 | 0.00007524 | 0.00007601 | 0 | 0.027768 | 0.02563 | 110
ATTACHE | STEEL/S235JR | 3233.89 | 19429.7 | 9469.68 | +3.215 | +3.278 | H31 | H31 | 2 | 2005 | GRENAILLE-PEINT | S235JR | ATTACHE | 0.590634 | 0.596678 | 0.00007524 | 0.00007601 | 0 | 0.027768 | 0.02563 | 110
ATTACHE | STEEL/S235JR | 3233.89 | 34892.2 | 9469.68 | +3.215 | +3.278 | H31 | H31 | 2 | 2005 | GRENAILLE-PEINT | S235JR | ATTACHE | 0.590634 | 0.596679 | 0.00007524 | 0.00007601 | 0 | 0.027768 | 0.02563 | 110
ATTACHE | STEEL/S235JR | 3233.89 | 24532.8 | 9469.68 | +3.215 | +3.278 | H31 | H31 | 2 | 2005 | GRENAILLE-PEINT | S235JR | ATTACHE | 0.590634 | 0.596678 | 0.00007524 | 0.00007601 | 0 | 0.027768 | 0.02563 | 110
ATTACHE | STEEL/S235JR | 3233.89 | 34932.8 | 9469.68 | +3.215 | +3.278 | H31 | H31 | 2 | 2005 | GRENAILLE-PEINT | S235JR | ATTACHE | 0.590634 | 0.596678 | 0.00007524 | 0.00007601 | 0 | 0.027768 | 0.02563 | 110
ATTACHE | STEEL/S235JR | 3233.89 | 24492.2 | 9469.68 | +3.215 | +3.278 | H31 | H31 | 2 | 2005 | GRENAILLE-PEINT | S235JR | ATTACHE | 0.590634 | 0.596678 | 0.00007524 | 0.00007601 | 0 | 0.027768 | 0.02563 | 110
ATTACHE | STEEL/S235JR | 3233.89 | 29554.7 | 9469.68 | +3.215 | +3.278 | H31 | H31 | 2 | 2005 | GRENAILLE-PEINT | S235JR | ATTACHE | 0.590634 | 0.596679 | 0.00007524 | 0.00007601 | 0 | 0.027768 | 0.02563 | 110
ATTACHE | STEEL/S235JR | 3233.89 | 29595.3 | 9469.68 | +3.215 | +3.278 | H31 | H31 | 2 | 2005 | GRENAILLE-PEINT | S235JR | ATTACHE | 0.590634 | 0.596679 | 0.00007524 | 0.00007601 | 0 | 0.027768 | 0.02563 | 110
ATTACHE | STEEL/S235JR | 4365 | 11077.2 | 602.211 | +4.269 | +4.461 | H25 | H25 | 2 | 2007 | GALVANISE | S235JR | ATTACHE | 1.03092 | 1.04148 | 0.000131328 | 0.000132672 | 0.000684 | 0.047448 | 0.044736 | 192
ATTACHE | STEEL/S235JR | 4365 | 10147.2 | 602.211 | +4.269 | +4.461 | H25 | H25 | 2 | 2007 | GALVANISE | S235JR | ATTACHE | 1.03092 | 1.04148 | 0.000131328 | 0.000132672 | 0.000684 | 0.047448 | 0.044736 | 192
ATTACHE | STEEL/S235JR | 4365 | 12077.2 | 602.211 | +4.269 | +4.461 | H25 | H25 | 2 | 2007 | GALVANISE | S235JR | ATTACHE | 1.03092 | 1.04148 | 0.000131328 | 0.000132672 | 0.000684 | 0.047448 | 0.044736 | 192
ATTACHE | STEEL/S235JR | 4365 | 13077.2 | 602.211 | +4.269 | +4.461 | H25 | H25 | 2 | 2007 | GALVANISE | S235JR | ATTACHE | 1.03092 | 1.04148 | 0.000131328 | 0.000132672 | 0.000684 | 0.047448 | 0.044736 | 192
ATTACHE | STEEL/S235JR | 4365 | 14142.2 | 602.211 | +4.269 | +4.461 | H25 | H25 | 2 | 2007 | GALVANISE | S235JR | ATTACHE | 1.03092 | 1.04148 | 0.000131328 | 0.000132672 | 0.000684 | 0.047448 | 0.044736 | 192
ATTACHE | STEEL/S235JR | 4365 | 18402.2 | 602.211 | +4.269 | +4.461 | H25 | H25 | 2 | 2007 | GALVANISE | S235JR | ATTACHE | 1.03092 | 1.04148 | 0.000131328 | 0.000132672 | 0.000684 | 0.047448 | 0.044736 | 192
ATTACHE | STEEL/S235JR | 4365 | 17337.2 | 602.211 | +4.269 | +4.461 | H25 | H25 | 2 | 2007 | GALVANISE | S235JR | ATTACHE | 1.03092 | 1.04148 | 0.000131328 | 0.000132672 | 0.000684 | 0.047448 | 0.044736 | 192
ATTACHE | STEEL/S235JR | 4365 | 16272.2 | 602.211 | +4.269 | +4.461 | H25 | H25 | 2 | 2007 | GALVANISE | S235JR | ATTACHE | 1.03092 | 1.04148 | 0.000131328 | 0.000132672 | 0.000684 | 0.047448 | 0.044736 | 192
ATTACHE | STEEL/S235JR | 4365 | 23264.1 | 602.211 | +4.269 | +4.461 | H25 | H25 | 2 | 2007 | GALVANISE | S235JR | ATTACHE | 1.03092 | 1.04148 | 0.000131328 | 0.000132672 | 0.000684 | 0.047448 | 0.044736 | 192
ATTACHE | STEEL/S235JR | 4365 | 21998.5 | 602.211 | +4.269 | +4.461 | H25 | H25 | 2 | 2007 | GALVANISE | S235JR | ATTACHE | 1.03092 | 1.04148 | 0.000131328 | 0.000132672 | 0.000684 | 0.047448 | 0.044736 | 192
ATTACHE | STEEL/S235JR | 4365 | 20732.8 | 602.211 | +4.269 | +4.461 | H25 | H25 | 2 | 2007 | GALVANISE | S235JR | ATTACHE | 1.03092 | 1.04148 | 0.000131328 | 0.000132672 | 0.000684 | 0.047448 | 0.044736 | 192
ATTACHE | STEEL/S235JR | 4365 | 28326.6 | 602.211 | +4.269 | +4.461 | H25 | H25 | 2 | 2007 | GALVANISE | S235JR | ATTACHE | 1.03092 | 1.04148 | 0.000131328 | 0.000132672 | 0.000684 | 0.047448 | 0.044736 | 192
ATTACHE | STEEL/S235JR | 4365 | 27061 | 602.211 | +4.269 | +4.461 | H25 | H25 | 2 | 2007 | GALVANISE | S235JR | ATTACHE | 1.03092 | 1.04148 | 0.000131328 | 0.000132672 | 0.000684 | 0.047448 | 0.044736 | 192
ATTACHE | STEEL/S235JR | 4365 | 25795.3 | 602.211 | +4.269 | +4.461 | H25 | H25 | 2 | 2007 | GALVANISE | S235JR | ATTACHE | 1.03092 | 1.04148 | 0.000131328 | 0.000132672 | 0.000684 | 0.047448 | 0.044736 | 192
ATTACHE | STEEL/S235JR | 4365 | 43025.5 | 602.211 | +4.269 | +4.461 | H25 | H25 | 2 | 2007 | GALVANISE | S235JR | ATTACHE | 1.03092 | 1.04148 | 0.000131328 | 0.000132672 | 0.000684 | 0.047448 | 0.044736 | 192
ATTACHE | STEEL/S235JR | 10882.2 | 50502.8 | 20360 | +10.865 | +10.925 | 428 | P108 | 2 | 2007 | GALVANISE | S235JR | ATTACHE | 1.12757 | 1.13911 | 0.00014364 | 0.00014511 | 0.00126 | 0.051768 | 0.04893 | 210
ATTACHE | STEEL/S235JR | 10782.2 | 50630 | 23173.8 | +10.765 | +10.825 | 428 | P107 | 2 | 2007 | GALVANISE | S235JR | ATTACHE | 1.12757 | 1.13911 | 0.00014364 | 0.00014511 | 0.00126 | 0.051768 | 0.04893 | 210
ATTACHE | STEEL/S235JR | 10865 | 50502.8 | 23173.8 | +10.769 | +10.961 | H25 | H25 | 2 | 2007 | GALVANISE | S235JR | ATTACHE | 1.03092 | 1.04148 | 0.000131328 | 0.000132672 | 0.000684 | 0.047448 | 0.044736 | 192
ATTACHE | STEEL/S235JR | 10865 | 50062.8 | 23173.8 | +10.769 | +10.961 | H25 | H25 | 2 | 2007 | GALVANISE | S235JR | ATTACHE | 1.03092 | 1.04148 | 0.000131328 | 0.000132672 | 0.000684 | 0.047448 | 0.044736 | 192
ATTACHE | STEEL/S235JR | 10865 | 54089.7 | 20652.2 | +10.769 | +10.961 | H25 | H25 | 2 | 2007 | GALVANISE | S235JR | ATTACHE | 1.03092 | 1.04148 | 0.000131328 | 0.000132672 | 0.000684 | 0.047448 | 0.044736 | 192
ATTACHE | STEEL/S235JR | 10915 | 54089.7 | 26001.8 | +10.869 | +10.961 | H26 | H26 | 2 | 2007 | GALVANISE | S235JR | ATTACHE | 0.493985 | 0.49904 | 0.000062928 | 0.000063572 | 0.000684 | 0.023448 | 0.021436 | 92
ATTACHE | STEEL/S235JR | 10865 | 54089.7 | 26036.2 | +10.769 | +10.961 | H21 | H21 | 2 | 2007 | GALVANISE | S235JR | ATTACHE | 1.03092 | 1.04148 | 0.000131328 | 0.000132672 | 0.000684 | 0.047448 | 0.044736 | 192
ATTACHE | STEEL/S235JR | 10865 | 54089.7 | 28864.2 | +10.769 | +10.961 | H25 | H25 | 2 | 2007 | GALVANISE | S235JR | ATTACHE | 1.03092 | 1.04148 | 0.000131328 | 0.000132672 | 0.000684 | 0.047448 | 0.044736 | 192
ATTACHE | STEEL/S235JR | 10865 | 54089.7 | 31692.2 | +10.769 | +10.961 | H25 | H25 | 2 | 2007 | GALVANISE | S235JR | ATTACHE | 1.03092 | 1.04148 | 0.000131328 | 0.000132672 | 0.000684 | 0.047448 | 0.044736 | 192
ATTACHE | STEEL/S235JR | 10865 | 56854.7 | 20652.2 | +10.769 | +10.961 | H25 | H25 | 2 | 2007 | GALVANISE | S235JR | ATTACHE | 1.03092 | 1.04148 | 0.000131328 | 0.000132672 | 0.000684 | 0.047448 | 0.044736 | 192
ATTACHE | STEEL/S235JR | 10915 | 56854.7 | 26001.8 | +10.869 | +10.961 | H26 | H26 | 2 | 2007 | GALVANISE | S235JR | ATTACHE | 0.493985 | 0.49904 | 0.000062928 | 0.000063572 | 0.000684 | 0.023448 | 0.021436 | 92
ATTACHE | STEEL/S235JR | 10865 | 56854.7 | 26036.2 | +10.769 | +10.961 | H21 | H21 | 2 | 2007 | GALVANISE | S235JR | ATTACHE | 1.03092 | 1.04148 | 0.000131328 | 0.000132672 | 0.000684 | 0.047448 | 0.044736 | 192
ATTACHE | STEEL/S235JR | 10782.2 | 50520 | 26036.2 | +10.765 | +10.825 | H24 | H24 | 2 | 2007 | GALVANISE | S235JR | ATTACHE | 1.12757 | 1.13911 | 0.00014364 | 0.00014511 | 0.00126 | 0.051768 | 0.04893 | 210
ATTACHE | STEEL/S235JR | 10865 | 52707.2 | 20652.2 | +10.769 | +10.961 | H25 | H25 | 2 | 2007 | GALVANISE | S235JR | ATTACHE | 1.03092 | 1.04148 | 0.000131328 | 0.000132672 | 0.000684 | 0.047448 | 0.044736 | 192
ATTACHE | STEEL/S235JR | 10865 | 58237.2 | 20652.2 | +10.769 | +10.961 | H25 | H25 | 2 | 2007 | GALVANISE | S235JR | ATTACHE | 1.03092 | 1.04148 | 0.000131328 | 0.000132672 | 0.000684 | 0.047448 | 0.044736 | 192
ATTACHE | STEEL/S235JR | 10865 | 63767.2 | 20652.2 | +10.769 | +10.961 | H25 | H25 | 2 | 2007 | GALVANISE | S235JR | ATTACHE | 1.03092 | 1.04148 | 0.000131328 | 0.000132672 | 0.000684 | 0.047448 | 0.044736 | 192
ATTACHE | STEEL/S235JR | 10865 | 65097.2 | 20652.2 | +10.769 | +10.961 | H25 | H25 | 2 | 2007 | GALVANISE | S235JR | ATTACHE | 1.03092 | 1.04148 | 0.000131328 | 0.000132672 | 0.000684 | 0.047448 | 0.044736 | 192
ATTACHE | STEEL/S235JR | 10865 | 65987.2 | 20652.2 | +10.769 | +10.961 | H25 | H25 | 2 | 2007 | GALVANISE | S235JR | ATTACHE | 1.03092 | 1.04148 | 0.000131328 | 0.000132672 | 0.000684 | 0.047448 | 0.044736 | 192
ATTACHE | STEEL/S235JR | 10865 | 66427.2 | 20652.2 | +10.769 | +10.961 | H25 | H25 | 2 | 2007 | GALVANISE | S235JR | ATTACHE | 1.03092 | 1.04148 | 0.000131328 | 0.000132672 | 0.000684 | 0.047448 | 0.044736 | 192
ATTACHE | STEEL/S235JR | 10865 | 59619.7 | 28864.2 | +10.769 | +10.961 | H25 | H25 | 2 | 2007 | GALVANISE | S235JR | ATTACHE | 1.03092 | 1.04148 | 0.000131328 | 0.000132672 | 0.000684 | 0.047448 | 0.044736 | 192
ATTACHE | STEEL/S235JR | 10865 | 59619.7 | 31692.2 | +10.769 | +10.961 | H25 | H25 | 2 | 2007 | GALVANISE | S235JR | ATTACHE | 1.03092 | 1.04148 | 0.000131328 | 0.000132672 | 0.000684 | 0.047448 | 0.044736 | 192
ATTACHE | STEEL/S235JR | 10882.2 | 52707.2 | 20360 | +10.865 | +10.925 | 428 | P95 | 2 | 2007 | GALVANISE | S235JR | ATTACHE | 1.12757 | 1.13911 | 0.00014364 | 0.00014511 | 0.00126 | 0.051768 | 0.04893 | 210
ATTACHE | STEEL/S235JR | 10882.2 | 55472.2 | 20360 | +10.865 | +10.925 | 428 | P95 | 2 | 2007 | GALVANISE | S235JR | ATTACHE | 1.12757 | 1.13911 | 0.00014364 | 0.00014511 | 0.00126 | 0.051768 | 0.04893 | 210
ATTACHE | STEEL/S235JR | 10882.2 | 58237.2 | 20360 | +10.865 | +10.925 | 428 | P95 | 2 | 2007 | GALVANISE | S235JR | ATTACHE | 1.12757 | 1.13911 | 0.00014364 | 0.00014511 | 0.00126 | 0.051768 | 0.04893 | 210
ATTACHE | STEEL/S235JR | 10882.2 | 61002.2 | 20360 | +10.865 | +10.925 | 428 | P95 | 2 | 2007 | GALVANISE | S235JR | ATTACHE | 1.12757 | 1.13911 | 0.00014364 | 0.00014511 | 0.00126 | 0.051768 | 0.04893 | 210
ATTACHE | STEEL/S235JR | 10865 | 59619.7 | 20652.2 | +10.769 | +10.961 | H25 | H25 | 2 | 2007 | GALVANISE | S235JR | ATTACHE | 1.03092 | 1.04148 | 0.000131328 | 0.000132672 | 0.000684 | 0.047448 | 0.044736 | 192
ATTACHE | STEEL/S235JR | 10915 | 59619.7 | 26001.8 | +10.869 | +10.961 | H26 | H26 | 2 | 2007 | GALVANISE | S235JR | ATTACHE | 0.493985 | 0.49904 | 0.000062928 | 0.000063572 | 0.000684 | 0.023448 | 0.021436 | 92
ATTACHE | STEEL/S235JR | 10865 | 59619.7 | 26036.2 | +10.769 | +10.961 | H21 | H21 | 2 | 2007 | GALVANISE | S235JR | ATTACHE | 1.03092 | 1.04148 | 0.000131328 | 0.000132672 | 0.000684 | 0.047448 | 0.044736 | 192
ATTACHE | STEEL/S235JR | 4382.21 | 40267.2 | 8340 | +4.365 | +4.425 | H24 | H24 | 2 | 2007 | GALVANISE | S235JR | ATTACHE | 1.12757 | 1.13911 | 0.00014364 | 0.00014511 | 0.00126 | 0.051768 | 0.04893 | 210
ATTACHE | STEEL/S235JR | 4382.21 | 40267.2 | 5691.67 | +4.365 | +4.425 | H20 | H20 | 2 | 2007 | GALVANISE | S235JR | ATTACHE | 1.12757 | 1.13911 | 0.00014364 | 0.00014511 | 0.00126 | 0.051768 | 0.04893 | 210
ATTACHE | STEEL/S235JR | 4382.21 | 40267.2 | 395 | +4.365 | +4.425 | 428 | P96 | 2 | 2007 | GALVANISE | S235JR | ATTACHE | 1.12757 | 1.13911 | 0.00014364 | 0.00014511 | 0.00126 | 0.051768 | 0.04893 | 210
ATTACHE | STEEL/S235JR | 4365 | 37598.5 | 602.211 | +4.269 | +4.461 | H25 | H25 | 2 | 2007 | GALVANISE | S235JR | ATTACHE | 1.03092 | 1.04148 | 0.000131328 | 0.000132672 | 0.000684 | 0.047448 | 0.044736 | 192
ATTACHE | STEEL/S235JR | 4382.21 | 37598.5 | 8340 | +4.365 | +4.425 | H24 | H24 | 2 | 2007 | GALVANISE | S235JR | ATTACHE | 1.12757 | 1.13911 | 0.00014364 | 0.00014511 | 0.00126 | 0.051768 | 0.04893 | 210
ATTACHE | STEEL/S235JR | 4382.21 | 37598.5 | 5691.67 | +4.365 | +4.425 | H20 | H20 | 2 | 2007 | GALVANISE | S235JR | ATTACHE | 1.12757 | 1.13911 | 0.00014364 | 0.00014511 | 0.00126 | 0.051768 | 0.04893 | 210
ATTACHE | STEEL/S235JR | 4382.21 | 37598.5 | 395 | +4.365 | +4.425 | 428 | P96 | 2 | 2007 | GALVANISE | S235JR | ATTACHE | 1.12757 | 1.13911 | 0.00014364 | 0.00014511 | 0.00126 | 0.051768 | 0.04893 | 210
ATTACHE | STEEL/S235JR | 4382.21 | 34929.7 | 8340 | +4.365 | +4.425 | H24 | H24 | 2 | 2007 | GALVANISE | S235JR | ATTACHE | 1.12757 | 1.13911 | 0.00014364 | 0.00014511 | 0.00126 | 0.051768 | 0.04893 | 210
ATTACHE | STEEL/S235JR | 4382.21 | 34929.7 | 5691.67 | +4.365 | +4.425 | H20 | H20 | 2 | 2007 | GALVANISE | S235JR | ATTACHE | 1.12757 | 1.13911 | 0.00014364 | 0.00014511 | 0.00126 | 0.051768 | 0.04893 | 210
ATTACHE | STEEL/S235JR | 4382.21 | 34929.7 | 395 | +4.365 | +4.425 | 428 | P96 | 2 | 2007 | GALVANISE | S235JR | ATTACHE | 1.12757 | 1.13911 | 0.00014364 | 0.00014511 | 0.00126 | 0.051768 | 0.04893 | 210
ATTACHE | STEEL/S235JR | 4382.21 | 32261 | 395 | +4.365 | +4.425 | 428 | P96 | 2 | 2007 | GALVANISE | S235JR | ATTACHE | 1.12757 | 1.13911 | 0.00014364 | 0.00014511 | 0.00126 | 0.051768 | 0.04893 | 210
ATTACHE | STEEL/S235JR | 4382.21 | 32261 | 5691.67 | +4.365 | +4.425 | H20 | H20 | 2 | 2007 | GALVANISE | S235JR | ATTACHE | 1.12757 | 1.13911 | 0.00014364 | 0.00014511 | 0.00126 | 0.051768 | 0.04893 | 210
ATTACHE | STEEL/S235JR | 4382.21 | 32261 | 8340 | +4.365 | +4.425 | H24 | H24 | 2 | 2007 | GALVANISE | S235JR | ATTACHE | 1.12757 | 1.13911 | 0.00014364 | 0.00014511 | 0.00126 | 0.051768 | 0.04893 | 210
ATTACHE | STEEL/S235JR | 4382.21 | 29592.2 | 395 | +4.365 | +4.425 | 428 | P96 | 2 | 2007 | GALVANISE | S235JR | ATTACHE | 1.12757 | 1.13911 | 0.00014364 | 0.00014511 | 0.00126 | 0.051768 | 0.04893 | 210
ATTACHE | STEEL/S235JR | 4382.21 | 29592.2 | 8340 | +4.365 | +4.425 | H24 | H24 | 2 | 2007 | GALVANISE | S235JR | ATTACHE | 1.12757 | 1.13911 | 0.00014364 | 0.00014511 | 0.00126 | 0.051768 | 0.04893 | 210
ATTACHE | STEEL/S235JR | 4382.21 | 29592.2 | 5691.67 | +4.365 | +4.425 | H20 | H20 | 2 | 2007 | GALVANISE | S235JR | ATTACHE | 1.12757 | 1.13911 | 0.00014364 | 0.00014511 | 0.00126 | 0.051768 | 0.04893 | 210
ATTACHE | STEEL/S235JR | 4365 | 33595.3 | 602.211 | +4.269 | +4.461 | H25 | H25 | 2 | 2007 | GALVANISE | S235JR | ATTACHE | 1.03092 | 1.04148 | 0.000131328 | 0.000132672 | 0.000684 | 0.047448 | 0.044736 | 192
ATTACHE | STEEL/S235JR | 4382.21 | 27061 | 395 | +4.365 | +4.425 | 428 | P96 | 2 | 2007 | GALVANISE | S235JR | ATTACHE | 1.12757 | 1.13911 | 0.00014364 | 0.00014511 | 0.00126 | 0.051768 | 0.04893 | 210
ATTACHE | STEEL/S235JR | 4382.21 | 27061 | 8340 | +4.365 | +4.425 | H24 | H24 | 2 | 2007 | GALVANISE | S235JR | ATTACHE | 1.12757 | 1.13911 | 0.00014364 | 0.00014511 | 0.00126 | 0.051768 | 0.04893 | 210
ATTACHE | STEEL/S235JR | 4382.21 | 27061 | 5691.67 | +4.365 | +4.425 | H20 | H20 | 2 | 2007 | GALVANISE | S235JR | ATTACHE | 1.12757 | 1.13911 | 0.00014364 | 0.00014511 | 0.00126 | 0.051768 | 0.04893 | 210
ATTACHE | STEEL/S235JR | 4382.21 | 24529.7 | 395 | +4.365 | +4.425 | 428 | P96 | 2 | 2007 | GALVANISE | S235JR | ATTACHE | 1.12757 | 1.13911 | 0.00014364 | 0.00014511 | 0.00126 | 0.051768 | 0.04893 | 210
ATTACHE | STEEL/S235JR | 4382.21 | 24529.7 | 8340 | +4.365 | +4.425 | H24 | H24 | 2 | 2007 | GALVANISE | S235JR | ATTACHE | 1.12757 | 1.13911 | 0.00014364 | 0.00014511 | 0.00126 | 0.051768 | 0.04893 | 210
ATTACHE | STEEL/S235JR | 4382.21 | 24529.7 | 5691.67 | +4.365 | +4.425 | H20 | H20 | 2 | 2007 | GALVANISE | S235JR | ATTACHE | 1.12757 | 1.13911 | 0.00014364 | 0.00014511 | 0.00126 | 0.051768 | 0.04893 | 210
ATTACHE | STEEL/S235JR | 4382.21 | 21998.5 | 395 | +4.365 | +4.425 | 428 | P96 | 2 | 2007 | GALVANISE | S235JR | ATTACHE | 1.12757 | 1.13911 | 0.00014364 | 0.00014511 | 0.00126 | 0.051768 | 0.04893 | 210
ATTACHE | STEEL/S235JR | 4282.21 | 11385 | 10422.2 | +4.265 | +4.325 | H24 | H24 | 2 | 2007 | GALVANISE | S235JR | ATTACHE | 1.12757 | 1.13911 | 0.00014364 | 0.00014511 | 0.00126 | 0.051768 | 0.04893 | 210
ATTACHE | STEEL/S235JR | 4382.21 | 21998.5 | 5691.67 | +4.365 | +4.425 | H20 | H20 | 2 | 2007 | GALVANISE | S235JR | ATTACHE | 1.12757 | 1.13911 | 0.00014364 | 0.00014511 | 0.00126 | 0.051768 | 0.04893 | 210
ATTACHE | STEEL/S235JR | 4382.21 | 21998.5 | 8340 | +4.365 | +4.425 | H24 | H24 | 2 | 2007 | GALVANISE | S235JR | ATTACHE | 1.12757 | 1.13911 | 0.00014364 | 0.00014511 | 0.00126 | 0.051768 | 0.04893 | 210
ATTACHE | STEEL/S235JR | 4365 | 11077.2 | 10422.2 | +4.269 | +4.461 | H25 | H25 | 2 | 2007 | GALVANISE | S235JR | ATTACHE | 1.03092 | 1.04148 | 0.000131328 | 0.000132672 | 0.000684 | 0.047448 | 0.044736 | 192
ATTACHE | STEEL/S235JR | 4382.21 | 19467.2 | 395 | +4.365 | +4.425 | 428 | P96 | 2 | 2007 | GALVANISE | S235JR | ATTACHE | 1.12757 | 1.13911 | 0.00014364 | 0.00014511 | 0.00126 | 0.051768 | 0.04893 | 210
ATTACHE | STEEL/S235JR | 4382.21 | 19467.2 | 5691.67 | +4.365 | +4.425 | H20 | H20 | 2 | 2007 | GALVANISE | S235JR | ATTACHE | 1.12757 | 1.13911 | 0.00014364 | 0.00014511 | 0.00126 | 0.051768 | 0.04893 | 210
ATTACHE | STEEL/S235JR | 4382.21 | 19467.2 | 8340 | +4.365 | +4.425 | H24 | H24 | 2 | 2007 | GALVANISE | S235JR | ATTACHE | 1.12757 | 1.13911 | 0.00014364 | 0.00014511 | 0.00126 | 0.051768 | 0.04893 | 210
ATTACHE | STEEL/S235JR | 4365 | 12077.2 | 10422.2 | +4.269 | +4.461 | H25 | H25 | 2 | 2007 | GALVANISE | S235JR | ATTACHE | 1.03092 | 1.04148 | 0.000131328 | 0.000132672 | 0.000684 | 0.047448 | 0.044736 | 192
ATTACHE | STEEL/S235JR | 4382.21 | 17337.2 | 395 | +4.365 | +4.425 | 428 | P96 | 2 | 2007 | GALVANISE | S235JR | ATTACHE | 1.12757 | 1.13911 | 0.00014364 | 0.00014511 | 0.00126 | 0.051768 | 0.04893 | 210
ATTACHE | STEEL/S235JR | 4382.21 | 17337.2 | 5691.67 | +4.365 | +4.425 | H20 | H20 | 2 | 2007 | GALVANISE | S235JR | ATTACHE | 1.12757 | 1.13911 | 0.00014364 | 0.00014511 | 0.00126 | 0.051768 | 0.04893 | 210
ATTACHE | STEEL/S235JR | 4382.21 | 17337.2 | 8340 | +4.365 | +4.425 | H24 | H24 | 2 | 2007 | GALVANISE | S235JR | ATTACHE | 1.12757 | 1.13911 | 0.00014364 | 0.00014511 | 0.00126 | 0.051768 | 0.04893 | 210
ATTACHE | STEEL/S235JR | 4282.21 | 13060 | 10422.2 | +4.265 | +4.325 | H24 | H24 | 2 | 2007 | GALVANISE | S235JR | ATTACHE | 1.12757 | 1.13911 | 0.00014364 | 0.00014511 | 0.00126 | 0.051768 | 0.04893 | 210
ATTACHE | STEEL/S235JR | 4382.21 | 15207.2 | 395 | +4.365 | +4.425 | 428 | P96 | 2 | 2007 | GALVANISE | S235JR | ATTACHE | 1.12757 | 1.13911 | 0.00014364 | 0.00014511 | 0.00126 | 0.051768 | 0.04893 | 210
ATTACHE | STEEL/S235JR | 4382.21 | 15207.2 | 5691.67 | +4.365 | +4.425 | H20 | H20 | 2 | 2007 | GALVANISE | S235JR | ATTACHE | 1.12757 | 1.13911 | 0.00014364 | 0.00014511 | 0.00126 | 0.051768 | 0.04893 | 210
ATTACHE | STEEL/S235JR | 4382.21 | 15207.2 | 8340 | +4.365 | +4.425 | H24 | H24 | 2 | 2007 | GALVANISE | S235JR | ATTACHE | 1.12757 | 1.13911 | 0.00014364 | 0.00014511 | 0.00126 | 0.051768 | 0.04893 | 210
ATTACHE | STEEL/S235JR | 4382.21 | 13077.2 | 5691.67 | +4.365 | +4.425 | H20 | H20 | 2 | 2007 | GALVANISE | S235JR | ATTACHE | 1.12757 | 1.13911 | 0.00014364 | 0.00014511 | 0.00126 | 0.051768 | 0.04893 | 210
ATTACHE | STEEL/S235JR | 4282.21 | 10930 | 5708.88 | +4.265 | +4.325 | H24 | H24 | 2 | 2007 | GALVANISE | S235JR | ATTACHE | 1.12757 | 1.13911 | 0.00014364 | 0.00014511 | 0.00126 | 0.051768 | 0.04893 | 210
ATTACHE | STEEL/S235JR | 4415 | 12077.2 | 5674.46 | +4.369 | +4.461 | H26 | H26 | 2 | 2007 | GALVANISE | S235JR | ATTACHE | 0.493985 | 0.49904 | 0.000062928 | 0.000063572 | 0.000684 | 0.023448 | 0.021436 | 92
ATTACHE | STEEL/S235JR | 4365 | 12077.2 | 5708.88 | +4.269 | +4.461 | H21 | H21 | 2 | 2007 | GALVANISE | S235JR | ATTACHE | 1.03092 | 1.04148 | 0.000131328 | 0.000132672 | 0.000684 | 0.047448 | 0.044736 | 192
ATTACHE | STEEL/S235JR | 4415 | 10147.2 | 5674.46 | +4.369 | +4.461 | H26 | H26 | 2 | 2007 | GALVANISE | S235JR | ATTACHE | 0.493985 | 0.49904 | 0.000062928 | 0.000063572 | 0.000684 | 0.023448 | 0.021436 | 92
ATTACHE | STEEL/S235JR | 4365 | 10147.2 | 5708.88 | +4.269 | +4.461 | H21 | H21 | 2 | 2007 | GALVANISE | S235JR | ATTACHE | 1.03092 | 1.04148 | 0.000131328 | 0.000132672 | 0.000684 | 0.047448 | 0.044736 | 192
ATTACHE | STEEL/S235JR | 4415 | 11077.2 | 5674.46 | +4.369 | +4.461 | H26 | H26 | 2 | 2007 | GALVANISE | S235JR | ATTACHE | 0.493985 | 0.49904 | 0.000062928 | 0.000063572 | 0.000684 | 0.023448 | 0.021436 | 92
ATTACHE | STEEL/S235JR | 4365 | 11077.2 | 5708.88 | +4.269 | +4.461 | H21 | H21 | 2 | 2007 | GALVANISE | S235JR | ATTACHE | 1.03092 | 1.04148 | 0.000131328 | 0.000132672 | 0.000684 | 0.047448 | 0.044736 | 192
ATTACHE | STEEL/S235JR | 4365 | 12077.2 | 8357.21 | +4.269 | +4.461 | H25 | H25 | 2 | 2007 | GALVANISE | S235JR | ATTACHE | 1.03092 | 1.04148 | 0.000131328 | 0.000132672 | 0.000684 | 0.047448 | 0.044736 | 192
ATTACHE | STEEL/S235JR | 4365 | 10147.2 | 8357.21 | +4.269 | +4.461 | H25 | H25 | 2 | 2007 | GALVANISE | S235JR | ATTACHE | 1.03092 | 1.04148 | 0.000131328 | 0.000132672 | 0.000684 | 0.047448 | 0.044736 | 192
ATTACHE | STEEL/S235JR | 4365 | 11077.2 | 8357.21 | +4.269 | +4.461 | H25 | H25 | 2 | 2007 | GALVANISE | S235JR | ATTACHE | 1.03092 | 1.04148 | 0.000131328 | 0.000132672 | 0.000684 | 0.047448 | 0.044736 | 192
ATTACHE | STEEL/S235JR | 4382.21 | 13077.2 | 8340 | +4.365 | +4.425 | H24 | H24 | 2 | 2007 | GALVANISE | S235JR | ATTACHE | 1.12757 | 1.13911 | 0.00014364 | 0.00014511 | 0.00126 | 0.051768 | 0.04893 | 210
ATTACHE | STEEL/S235JR | 4282.21 | 10930 | 602.211 | +4.265 | +4.325 | 428 | P94 | 2 | 2007 | GALVANISE | S235JR | ATTACHE | 1.12757 | 1.13911 | 0.00014364 | 0.00014511 | 0.00126 | 0.051768 | 0.04893 | 210
ATTACHE | STEEL/S235JR | 4382.21 | 13077.2 | 395 | +4.365 | +4.425 | 428 | P96 | 2 | 2007 | GALVANISE | S235JR | ATTACHE | 1.12757 | 1.13911 | 0.00014364 | 0.00014511 | 0.00126 | 0.051768 | 0.04893 | 210
ATTACHE | STEEL/S235JR | 4282.21 | 10930 | 8357.21 | +4.265 | +4.325 | H24 | H24 | 2 | 2007 | GALVANISE | S235JR | ATTACHE | 1.12757 | 1.13911 | 0.00014364 | 0.00014511 | 0.00126 | 0.051768 | 0.04893 | 210
ATTACHE | STEEL/E24-2 | 5782.78 | 13519 | 79062.2 | +5.740 | +5.800 | 399 | L90 | 1 | 1003 | GRENAILLE-PEINT | E24-2 | ATTACHE | 0.26847 | 0.271217 | 0.0000342 | 0.00003455 | 0.003 | 0.013368 | 0.01165 | 50
ATTACHE | STEEL/S235JR | 5767.21 | 32660 | 70919.2 | +5.750 | +5.810 | 428 | P103 | 1 | 1008 | GALVANISE | S235JR | ATTACHE | 1.12757 | 1.13911 | 0.00014364 | 0.00014511 | 0.00126 | 0.051768 | 0.04893 | 210
ATTACHE | STEEL/S235JR | 5900 | 26562.2 | 72675.9 | +5.854 | +5.946 | H26 | H26 | 1 | 1008 | GALVANISE | S235JR | ATTACHE | 0.493985 | 0.49904 | 0.000062928 | 0.000063572 | 0.000684 | 0.023448 | 0.021436 | 92
ATTACHE | STEEL/S235JR | 5900 | 26562.2 | 75375.9 | +5.854 | +5.946 | H26 | H26 | 1 | 1008 | GALVANISE | S235JR | ATTACHE | 0.493985 | 0.49904 | 0.000062928 | 0.000063572 | 0.000684 | 0.023448 | 0.021436 | 92
ATTACHE | STEEL/S235JR | 5900 | 27417.2 | 72675.9 | +5.854 | +5.946 | H26 | H26 | 1 | 1008 | GALVANISE | S235JR | ATTACHE | 0.493985 | 0.49904 | 0.000062928 | 0.000063572 | 0.000684 | 0.023448 | 0.021436 | 92
ATTACHE | STEEL/S235JR | 5900 | 27417.2 | 75375.9 | +5.854 | +5.946 | H26 | H26 | 1 | 1008 | GALVANISE | S235JR | ATTACHE | 0.493985 | 0.49904 | 0.000062928 | 0.000063572 | 0.000684 | 0.023448 | 0.021436 | 92
ATTACHE | STEEL/S235JR | 5900 | 28667.2 | 72675.9 | +5.854 | +5.946 | H26 | H26 | 1 | 1008 | GALVANISE | S235JR | ATTACHE | 0.493985 | 0.49904 | 0.000062928 | 0.000063572 | 0.000684 | 0.023448 | 0.021436 | 92
ATTACHE | STEEL/S235JR | 5900 | 28667.2 | 75375.9 | +5.854 | +5.946 | H26 | H26 | 1 | 1008 | GALVANISE | S235JR | ATTACHE | 0.493985 | 0.49904 | 0.000062928 | 0.000063572 | 0.000684 | 0.023448 | 0.021436 | 92
ATTACHE | STEEL/S235JR | 5900 | 29917.2 | 72675.9 | +5.854 | +5.946 | H26 | H26 | 1 | 1008 | GALVANISE | S235JR | ATTACHE | 0.493985 | 0.49904 | 0.000062928 | 0.000063572 | 0.000684 | 0.023448 | 0.021436 | 92
ATTACHE | STEEL/S235JR | 5900 | 29917.2 | 75375.9 | +5.854 | +5.946 | H26 | H26 | 1 | 1008 | GALVANISE | S235JR | ATTACHE | 0.493985 | 0.49904 | 0.000062928 | 0.000063572 | 0.000684 | 0.023448 | 0.021436 | 92
ATTACHE | STEEL/S235JR | 5900 | 32382.8 | 72675.9 | +5.854 | +5.946 | H26 | H26 | 1 | 1008 | GALVANISE | S235JR | ATTACHE | 0.493985 | 0.49904 | 0.000062928 | 0.000063572 | 0.000684 | 0.023448 | 0.021436 | 92
ATTACHE | STEEL/S235JR | 5900 | 31167.2 | 72675.9 | +5.854 | +5.946 | H26 | H26 | 1 | 1008 | GALVANISE | S235JR | ATTACHE | 0.493985 | 0.49904 | 0.000062928 | 0.000063572 | 0.000684 | 0.023448 | 0.021436 | 92
ATTACHE | STEEL/S235JR | 5900 | 32382.8 | 75375.9 | +5.854 | +5.946 | H26 | H26 | 1 | 1008 | GALVANISE | S235JR | ATTACHE | 0.493985 | 0.49904 | 0.000062928 | 0.000063572 | 0.000684 | 0.023448 | 0.021436 | 92
ATTACHE | STEEL/S235JR | 5900 | 31167.2 | 75375.9 | +5.854 | +5.946 | H26 | H26 | 1 | 1008 | GALVANISE | S235JR | ATTACHE | 0.493985 | 0.49904 | 0.000062928 | 0.000063572 | 0.000684 | 0.023448 | 0.021436 | 92
ATTACHE | STEEL/S235JR | 5850 | 31167.2 | 78062.2 | +5.754 | +5.946 | H25 | H25 | 1 | 1008 | GALVANISE | S235JR | ATTACHE | 1.03092 | 1.04148 | 0.000131328 | 0.000132672 | 0.000684 | 0.047448 | 0.044736 | 192
ATTACHE | STEEL/S235JR | 5850 | 29917.2 | 78062.2 | +5.754 | +5.946 | H25 | H25 | 1 | 1008 | GALVANISE | S235JR | ATTACHE | 1.03092 | 1.04148 | 0.000131328 | 0.000132672 | 0.000684 | 0.047448 | 0.044736 | 192
ATTACHE | STEEL/S235JR | 5850 | 28667.2 | 78062.2 | +5.754 | +5.946 | H25 | H25 | 1 | 1008 | GALVANISE | S235JR | ATTACHE | 1.03092 | 1.04148 | 0.000131328 | 0.000132672 | 0.000684 | 0.047448 | 0.044736 | 192
ATTACHE | STEEL/S235JR | 5850 | 27417.2 | 78062.2 | +5.754 | +5.946 | H25 | H25 | 1 | 1008 | GALVANISE | S235JR | ATTACHE | 1.03092 | 1.04148 | 0.000131328 | 0.000132672 | 0.000684 | 0.047448 | 0.044736 | 192
ATTACHE | STEEL/S235JR | 5850 | 26562.2 | 78062.2 | +5.754 | +5.946 | H25 | H25 | 1 | 1008 | GALVANISE | S235JR | ATTACHE | 1.03092 | 1.04148 | 0.000131328 | 0.000132672 | 0.000684 | 0.047448 | 0.044736 | 192
ATTACHE | STEEL/S235JR | 5850 | 31167.2 | 70919.2 | +5.754 | +5.946 | H25 | H25 | 1 | 1008 | GALVANISE | S235JR | ATTACHE | 1.03092 | 1.04148 | 0.000131328 | 0.000132672 | 0.000684 | 0.047448 | 0.044736 | 192
ATTACHE | STEEL/S235JR | 5850 | 29917.2 | 70919.2 | +5.754 | +5.946 | H25 | H25 | 1 | 1008 | GALVANISE | S235JR | ATTACHE | 1.03092 | 1.04148 | 0.000131328 | 0.000132672 | 0.000684 | 0.047448 | 0.044736 | 192
ATTACHE | STEEL/S235JR | 5850 | 28667.2 | 70919.2 | +5.754 | +5.946 | H25 | H25 | 1 | 1008 | GALVANISE | S235JR | ATTACHE | 1.03092 | 1.04148 | 0.000131328 | 0.000132672 | 0.000684 | 0.047448 | 0.044736 | 192
ATTACHE | STEEL/S235JR | 5833 | 26562.2 | 71669.2 | +5.720 | +5.946 | H29 | H29 | 1 | 1008 | GALVANISE | S235JR | ATTACHE | 1.21348 | 1.2259 | 0.000154584 | 0.000156166 | 0.000684 | 0.055608 | 0.052658 | 226
ATTACHE | STEEL/S235JR | 5833 | 25564.7 | 71669.2 | +5.720 | +5.946 | H29 | H29 | 1 | 1008 | GALVANISE | S235JR | ATTACHE | 1.21348 | 1.2259 | 0.000154584 | 0.000156166 | 0.000684 | 0.055608 | 0.052658 | 226
ATTACHE | STEEL/S235JR | 5833 | 24667.2 | 71669.2 | +5.720 | +5.946 | H29 | H29 | 1 | 1008 | GALVANISE | S235JR | ATTACHE | 1.21348 | 1.2259 | 0.000154584 | 0.000156166 | 0.000684 | 0.055608 | 0.052658 | 226
ATTACHE | STEEL/S235JR | 5833 | 23367.2 | 71669.2 | +5.720 | +5.946 | H29 | H29 | 1 | 1008 | GALVANISE | S235JR | ATTACHE | 1.21348 | 1.2259 | 0.000154584 | 0.000156166 | 0.000684 | 0.055608 | 0.052658 | 226
ATTACHE | STEEL/S235JR | 5833 | 22067.2 | 71669.2 | +5.720 | +5.946 | H23 | H23 | 1 | 1008 | GALVANISE | S235JR | ATTACHE | 1.21348 | 1.2259 | 0.000154584 | 0.000156166 | 0.000684 | 0.055608 | 0.052658 | 226
ATTACHE | STEEL/S235JR | 5850 | 27417.2 | 70919.2 | +5.754 | +5.946 | H25 | H25 | 1 | 1008 | GALVANISE | S235JR | ATTACHE | 1.03092 | 1.04148 | 0.000131328 | 0.000132672 | 0.000684 | 0.047448 | 0.044736 | 192
ATTACHE | STEEL/S235JR | 5833 | 19187.2 | 71669.2 | +5.720 | +5.946 | H29 | H29 | 1 | 1008 | GALVANISE | S235JR | ATTACHE | 1.21348 | 1.2259 | 0.000154584 | 0.000156166 | 0.000684 | 0.055608 | 0.052658 | 226
ATTACHE | STEEL/S235JR | 5850 | 32382.8 | 70919.2 | +5.754 | +5.946 | H27 | H27 | 1 | 1008 | GALVANISE | S235JR | ATTACHE | 1.03092 | 1.04148 | 0.000131328 | 0.000132672 | 0.000684 | 0.047448 | 0.044736 | 192
ATTACHE | STEEL/S235JR | 5850 | 32382.8 | 78062.2 | +5.754 | +5.946 | H27 | H27 | 1 | 1008 | GALVANISE | S235JR | ATTACHE | 1.03092 | 1.04148 | 0.000131328 | 0.000132672 | 0.000684 | 0.047448 | 0.044736 | 192
 | STEEL/E24-2 | 5153.5 | 35181.3 | 32407.2 | +4.417 | +5.890 | 436 | N40 | 3 | 3006 | GRENAILLE-PEINT | E24-2 |  | 7.90913 | 7.99007 | 0.00100753 | 0.00101784 | 0.000684 | 0.354888 | 0.343209 | 1473
 | STEEL/E24-2 | 5153.5 | 21918.7 | 32407.2 | +4.417 | +5.890 | 436 | N9 | 3 | 3006 | GRENAILLE-PEINT | E24-2 |  | 7.90913 | 7.99007 | 0.00100753 | 0.00101784 | 0.000684 | 0.354888 | 0.343209 | 1473
 | STEEL/E24-2 | 5153.5 | 27381.3 | 55757.2 | +4.417 | +5.890 | 436 | N10 | 1 | 1006 | GRENAILLE-PEINT | E24-2 |  | 7.90913 | 7.99007 | 0.00100753 | 0.00101784 | 0.000684 | 0.354888 | 0.343209 | 1473
 | STEEL/E24-2 | 4712.79 | 27415.7 | 55770 | +4.670 | +4.730 | 442 | N10 | 1 | 1006 | GRENAILLE-PEINT | E24-2 |  | 0.26847 | 0.271218 | 0.0000342 | 0.00003455 | 0.003 | 0.013368 | 0.01165 | 50
 | STEEL/E24-2 | 5667.21 | 27415.7 | 55770 | +5.650 | +5.710 | 442 | N10 | 1 | 1006 | GRENAILLE-PEINT | E24-2 |  | 0.26847 | 0.271218 | 0.0000342 | 0.00003455 | 0.0003 | 0.013368 | 0.01165 | 50
 | STEEL/E24-2 | 5153.5 | 29718.7 | 55757.2 | +4.417 | +5.890 | 436 | N8 | 1 | 1006 | GRENAILLE-PEINT | E24-2 |  | 7.90913 | 7.99007 | 0.00100753 | 0.00101784 | 0.000684 | 0.354888 | 0.343209 | 1473
 | STEEL/E24-2 | 4712.79 | 29684.3 | 55770 | +4.670 | +4.730 | 442 | N8 | 1 | 1006 | GRENAILLE-PEINT | E24-2 |  | 0.26847 | 0.271218 | 0.0000342 | 0.00003455 | 0.003 | 0.013368 | 0.01165 | 50
 | STEEL/E24-2 | 5667.21 | 19615.7 | 55770 | +5.650 | +5.710 | 442 | P36 | 1 | 1001 | GRENAILLE-PEINT | E24-2 |  | 0.26847 | 0.271218 | 0.0000342 | 0.00003455 | 0.0003 | 0.013368 | 0.01165 | 50
 | STEEL/E24-2 | 4712.79 | 19615.7 | 55770 | +4.670 | +4.730 | 442 | P36 | 1 | 1001 | GRENAILLE-PEINT | E24-2 |  | 0.26847 | 0.271218 | 0.0000342 | 0.00003455 | 0.003 | 0.013368 | 0.01165 | 50
 | STEEL/E24-2 | 5667.21 | 21884.3 | 55770 | +5.650 | +5.710 | 442 | N10 | 1 | 1006 | GRENAILLE-PEINT | E24-2 |  | 0.26847 | 0.271218 | 0.0000342 | 0.00003455 | 0.0003 | 0.013368 | 0.01165 | 50
 | STEEL/E24-2 | 4712.79 | 21884.3 | 55770 | +4.670 | +4.730 | 442 | N10 | 1 | 1006 | GRENAILLE-PEINT | E24-2 |  | 0.26847 | 0.271218 | 0.0000342 | 0.00003455 | 0.003 | 0.013368 | 0.01165 | 50
 | STEEL/E24-2 | 5153.5 | 21918.7 | 55757.2 | +4.417 | +5.890 | 436 | N10 | 1 | 1006 | GRENAILLE-PEINT | E24-2 |  | 7.90913 | 7.99007 | 0.00100753 | 0.00101784 | 0.000684 | 0.354888 | 0.343209 | 1473
 | STEEL/E24-2 | 5575.79 | 61268.5 | 55817.2 | +5.533 | +5.593 | 440 | N38 | 1 | 1006 | GRENAILLE-PEINT | E24-2 |  | 0.26847 | 0.271218 | 0.0000342 | 0.00003455 | 0.003 | 0.013368 | 0.01165 | 50
 | STEEL/E24-2 | 5153.5 | 12501.3 | 55757.2 | +4.417 | +5.890 | 436 | N47 | 1 | 1006 | GRENAILLE-PEINT | E24-2 |  | 7.90913 | 7.99007 | 0.00100753 | 0.00101784 | 0.000684 | 0.354888 | 0.343209 | 1473
ATTACHE | STEEL/S235JR | 5867.21 | 31395 | 72675.9 | +5.850 | +5.910 | 428 | P104 | 1 | 1008 | GALVANISE | S235JR | ATTACHE | 1.12757 | 1.13911 | 0.00014364 | 0.00014511 | 0.00126 | 0.051768 | 0.04893 | 210
ATTACHE | STEEL/S235JR | 5850 | 19517.2 | 70919.2 | +5.754 | +5.946 | H25 | H25 | 1 | 1008 | GALVANISE | S235JR | ATTACHE | 1.03092 | 1.04148 | 0.000131328 | 0.000132672 | 0.000684 | 0.047448 | 0.044736 | 192
ATTACHE | STEEL/S235JR | 5850 | 23367.2 | 70919.2 | +5.754 | +5.946 | H25 | H25 | 1 | 1008 | GALVANISE | S235JR | ATTACHE | 1.03092 | 1.04148 | 0.000131328 | 0.000132672 | 0.000684 | 0.047448 | 0.044736 | 192
ATTACHE | STEEL/S235JR | 5850 | 25564.7 | 70919.2 | +5.754 | +5.946 | H25 | H25 | 1 | 1008 | GALVANISE | S235JR | ATTACHE | 1.03092 | 1.04148 | 0.000131328 | 0.000132672 | 0.000684 | 0.047448 | 0.044736 | 192
ATTACHE | STEEL/S235JR | 5767.21 | 18660 | 68142.2 | +5.750 | +5.810 | 428 | P102 | 1 | 1008 | GALVANISE | S235JR | ATTACHE | 1.12757 | 1.13911 | 0.00014364 | 0.00014511 | 0.00126 | 0.051768 | 0.04893 | 210
ATTACHE | STEEL/S235JR | 5767.21 | 18660 | 70617.2 | +5.750 | +5.810 | H24 | H24 | 1 | 1008 | GALVANISE | S235JR | ATTACHE | 1.12757 | 1.13911 | 0.00014364 | 0.00014511 | 0.00126 | 0.051768 | 0.04893 | 210
ATTACHE | STEEL/S235JR | 5850 | 19187.2 | 70617.2 | +5.754 | +5.946 | H25 | H25 | 1 | 1008 | GALVANISE | S235JR | ATTACHE | 1.03092 | 1.04148 | 0.000131328 | 0.000132672 | 0.000684 | 0.047448 | 0.044736 | 192
ATTACHE | STEEL/S235JR | 5850 | 18287.2 | 70617.2 | +5.754 | +5.946 | H25 | H25 | 1 | 1008 | GALVANISE | S235JR | ATTACHE | 1.03092 | 1.04148 | 0.000131328 | 0.000132672 | 0.000684 | 0.047448 | 0.044736 | 192
ATTACHE | STEEL/S235JR | 5767.21 | 19950 | 70919.2 | +5.750 | +5.810 | 428 | P103 | 1 | 1008 | GALVANISE | S235JR | ATTACHE | 1.12757 | 1.13911 | 0.00014364 | 0.00014511 | 0.00126 | 0.051768 | 0.04893 | 210
ATTACHE | STEEL/S235JR | 5850 | 19187.2 | 68142.2 | +5.754 | +5.946 | H25 | H25 | 1 | 1008 | GALVANISE | S235JR | ATTACHE | 1.03092 | 1.04148 | 0.000131328 | 0.000132672 | 0.000684 | 0.047448 | 0.044736 | 192
ATTACHE | STEEL/S235JR | 5850 | 18287.2 | 68142.2 | +5.754 | +5.946 | H25 | H25 | 1 | 1008 | GALVANISE | S235JR | ATTACHE | 1.03092 | 1.04148 | 0.000131328 | 0.000132672 | 0.000684 | 0.047448 | 0.044736 | 192
ATTACHE | STEEL/S235JR | 5850 | 13271.8 | 70617.2 | +5.754 | +5.946 | H27 | H27 | 1 | 1008 | GALVANISE | S235JR | ATTACHE | 1.03092 | 1.04148 | 0.000131328 | 0.000132672 | 0.000684 | 0.047448 | 0.044736 | 192
ATTACHE | STEEL/S235JR | 5900 | 13271.8 | 73057.8 | +5.854 | +5.946 | H26 | H26 | 1 | 1008 | GALVANISE | S235JR | ATTACHE | 0.493985 | 0.49904 | 0.000062928 | 0.000063572 | 0.000684 | 0.023448 | 0.021436 | 92
ATTACHE | STEEL/S235JR | 5850 | 15927.2 | 68142.2 | +5.754 | +5.946 | H25 | H25 | 1 | 1008 | GALVANISE | S235JR | ATTACHE | 1.03092 | 1.04148 | 0.000131328 | 0.000132672 | 0.000684 | 0.047448 | 0.044736 | 192
ATTACHE | STEEL/S235JR | 5850 | 15927.2 | 70617.2 | +5.754 | +5.946 | H25 | H25 | 1 | 1008 | GALVANISE | S235JR | ATTACHE | 1.03092 | 1.04148 | 0.000131328 | 0.000132672 | 0.000684 | 0.047448 | 0.044736 | 192
ATTACHE | STEEL/S235JR | 5867.21 | 17107.2 | 70600 | +5.850 | +5.910 | H24 | H24 | 1 | 1008 | GALVANISE | S235JR | ATTACHE | 1.12757 | 1.13911 | 0.00014364 | 0.00014511 | 0.00126 | 0.051768 | 0.04893 | 210
ATTACHE | STEEL/S235JR | 5867.21 | 17107.2 | 68125 | +5.850 | +5.910 | H24 | H24 | 1 | 1008 | GALVANISE | S235JR | ATTACHE | 1.12757 | 1.13911 | 0.00014364 | 0.00014511 | 0.00126 | 0.051768 | 0.04893 | 210
ATTACHE | STEEL/S235JR | 5850 | 13567.2 | 70617.2 | +5.754 | +5.946 | H25 | H25 | 1 | 1008 | GALVANISE | S235JR | ATTACHE | 1.03092 | 1.04148 | 0.000131328 | 0.000132672 | 0.000684 | 0.047448 | 0.044736 | 192
ATTACHE | STEEL/S235JR | 5850 | 13567.2 | 68142.2 | +5.754 | +5.946 | H25 | H25 | 1 | 1008 | GALVANISE | S235JR | ATTACHE | 1.03092 | 1.04148 | 0.000131328 | 0.000132672 | 0.000684 | 0.047448 | 0.044736 | 192
ATTACHE | STEEL/S235JR | 5867.21 | 14747.2 | 70600 | +5.850 | +5.910 | H24 | H24 | 1 | 1008 | GALVANISE | S235JR | ATTACHE | 1.12757 | 1.13911 | 0.00014364 | 0.00014511 | 0.00126 | 0.051768 | 0.04893 | 210
ATTACHE | STEEL/S235JR | 5850 | 11207.2 | 78042.2 | +5.754 | +5.946 | H25 | H25 | 1 | 1008 | GALVANISE | S235JR | ATTACHE | 1.03092 | 1.04148 | 0.000131328 | 0.000132672 | 0.000684 | 0.047448 | 0.044736 | 192
ATTACHE | STEEL/S235JR | 5850 | 11207.2 | 75567.2 | +5.754 | +5.946 | H25 | H25 | 1 | 1008 | GALVANISE | S235JR | ATTACHE | 1.03092 | 1.04148 | 0.000131328 | 0.000132672 | 0.000684 | 0.047448 | 0.044736 | 192
ATTACHE | STEEL/S235JR | 5850 | 11207.2 | 70617.2 | +5.754 | +5.946 | H25 | H25 | 1 | 1008 | GALVANISE | S235JR | ATTACHE | 1.03092 | 1.04148 | 0.000131328 | 0.000132672 | 0.000684 | 0.047448 | 0.044736 | 192
ATTACHE | STEEL/S235JR | 5850 | 11207.2 | 73092.2 | +5.754 | +5.946 | H21 | H21 | 1 | 1008 | GALVANISE | S235JR | ATTACHE | 1.03092 | 1.04148 | 0.000131328 | 0.000132672 | 0.000684 | 0.047448 | 0.044736 | 192
ATTACHE | STEEL/S235JR | 5900 | 11207.2 | 73057.8 | +5.854 | +5.946 | H26 | H26 | 1 | 1008 | GALVANISE | S235JR | ATTACHE | 0.493985 | 0.49904 | 0.000062928 | 0.000063572 | 0.000684 | 0.023448 | 0.021436 | 92
ATTACHE | STEEL/S235JR | 5850 | 11207.2 | 68142.2 | +5.754 | +5.946 | H25 | H25 | 1 | 1008 | GALVANISE | S235JR | ATTACHE | 1.03092 | 1.04148 | 0.000131328 | 0.000132672 | 0.000684 | 0.047448 | 0.044736 | 192
ATTACHE | STEEL/S235JR | 5850 | 8847.21 | 78042.2 | +5.754 | +5.946 | H25 | H25 | 1 | 1008 | GALVANISE | S235JR | ATTACHE | 1.03092 | 1.04148 | 0.000131328 | 0.000132672 | 0.000684 | 0.047448 | 0.044736 | 192
ATTACHE | STEEL/S235JR | 5850 | 8847.21 | 75567.2 | +5.754 | +5.946 | H25 | H25 | 1 | 1008 | GALVANISE | S235JR | ATTACHE | 1.03092 | 1.04148 | 0.000131328 | 0.000132672 | 0.000684 | 0.047448 | 0.044736 | 192
ATTACHE | STEEL/S235JR | 5850 | 8847.21 | 70617.2 | +5.754 | +5.946 | H25 | H25 | 1 | 1008 | GALVANISE | S235JR | ATTACHE | 1.03092 | 1.04148 | 0.000131328 | 0.000132672 | 0.000684 | 0.047448 | 0.044736 | 192
ATTACHE | STEEL/S235JR | 5850 | 8847.21 | 73092.2 | +5.754 | +5.946 | H21 | H21 | 1 | 1008 | GALVANISE | S235JR | ATTACHE | 1.03092 | 1.04148 | 0.000131328 | 0.000132672 | 0.000684 | 0.047448 | 0.044736 | 192
ATTACHE | STEEL/S235JR | 5900 | 8847.21 | 73057.8 | +5.854 | +5.946 | H26 | H26 | 1 | 1008 | GALVANISE | S235JR | ATTACHE | 0.493985 | 0.49904 | 0.000062928 | 0.000063572 | 0.000684 | 0.023448 | 0.021436 | 92
ATTACHE | STEEL/S235JR | 5850 | 8847.21 | 68142.2 | +5.754 | +5.946 | H25 | H25 | 1 | 1008 | GALVANISE | S235JR | ATTACHE | 1.03092 | 1.04148 | 0.000131328 | 0.000132672 | 0.000684 | 0.047448 | 0.044736 | 192
ATTACHE | STEEL/S235JR | 5850 | 6392.21 | 78042.2 | +5.754 | +5.946 | H25 | H25 | 1 | 1008 | GALVANISE | S235JR | ATTACHE | 1.03092 | 1.04148 | 0.000131328 | 0.000132672 | 0.000684 | 0.047448 | 0.044736 | 192
ATTACHE | STEEL/S235JR | 5850 | 6392.21 | 75567.2 | +5.754 | +5.946 | H25 | H25 | 1 | 1008 | GALVANISE | S235JR | ATTACHE | 1.03092 | 1.04148 | 0.000131328 | 0.000132672 | 0.000684 | 0.047448 | 0.044736 | 192
ATTACHE | STEEL/S235JR | 5850 | 6392.21 | 70617.2 | +5.754 | +5.946 | H25 | H25 | 1 | 1008 | GALVANISE | S235JR | ATTACHE | 1.03092 | 1.04148 | 0.000131328 | 0.000132672 | 0.000684 | 0.047448 | 0.044736 | 192
ATTACHE | STEEL/S235JR | 5850 | 6392.21 | 73092.2 | +5.754 | +5.946 | H21 | H21 | 1 | 1008 | GALVANISE | S235JR | ATTACHE | 1.03092 | 1.04148 | 0.000131328 | 0.000132672 | 0.000684 | 0.047448 | 0.044736 | 192
ATTACHE | STEEL/S235JR | 5900 | 6392.21 | 73057.8 | +5.854 | +5.946 | H26 | H26 | 1 | 1008 | GALVANISE | S235JR | ATTACHE | 0.493985 | 0.49904 | 0.000062928 | 0.000063572 | 0.000684 | 0.023448 | 0.021436 | 92
ATTACHE | STEEL/S235JR | 5850 | 6392.21 | 68142.2 | +5.754 | +5.946 | H25 | H25 | 1 | 1008 | GALVANISE | S235JR | ATTACHE | 1.03092 | 1.04148 | 0.000131328 | 0.000132672 | 0.000684 | 0.047448 | 0.044736 | 192
ATTACHE | STEEL/S235JR | 5867.21 | 10027.2 | 78025 | +5.850 | +5.910 | H24 | H24 | 1 | 1008 | GALVANISE | S235JR | ATTACHE | 1.12757 | 1.13911 | 0.00014364 | 0.00014511 | 0.00126 | 0.051768 | 0.04893 | 210
ATTACHE | STEEL/S235JR | 5867.21 | 10027.2 | 75550 | +5.850 | +5.910 | H24 | H24 | 1 | 1008 | GALVANISE | S235JR | ATTACHE | 1.12757 | 1.13911 | 0.00014364 | 0.00014511 | 0.00126 | 0.051768 | 0.04893 | 210
ATTACHE | STEEL/S235JR | 5867.21 | 10027.2 | 73075 | +5.850 | +5.910 | H20 | H20 | 1 | 1008 | GALVANISE | S235JR | ATTACHE | 1.12757 | 1.13911 | 0.00014364 | 0.00014511 | 0.00126 | 0.051768 | 0.04893 | 210
ATTACHE | STEEL/S235JR | 5867.21 | 10027.2 | 70600 | +5.850 | +5.910 | H24 | H24 | 1 | 1008 | GALVANISE | S235JR | ATTACHE | 1.12757 | 1.13911 | 0.00014364 | 0.00014511 | 0.00126 | 0.051768 | 0.04893 | 210
ATTACHE | STEEL/S235JR | 5867.21 | 7667.21 | 68125 | +5.850 | +5.910 | H24 | H24 | 1 | 1008 | GALVANISE | S235JR | ATTACHE | 1.12757 | 1.13911 | 0.00014364 | 0.00014511 | 0.00126 | 0.051768 | 0.04893 | 210
ATTACHE | STEEL/S235JR | 5867.21 | 7667.21 | 70600 | +5.850 | +5.910 | H24 | H24 | 1 | 1008 | GALVANISE | S235JR | ATTACHE | 1.12757 | 1.13911 | 0.00014364 | 0.00014511 | 0.00126 | 0.051768 | 0.04893 | 210
ATTACHE | STEEL/S235JR | 5867.21 | 7667.21 | 73075 | +5.850 | +5.910 | H20 | H20 | 1 | 1008 | GALVANISE | S235JR | ATTACHE | 1.12757 | 1.13911 | 0.00014364 | 0.00014511 | 0.00126 | 0.051768 | 0.04893 | 210
 | STEEL/E24-2 | 4374.44 | 35117.2 | 79235 | +4.320 | +4.403 | 445 | P12 | 1 | 1001 | GRENAILLE-PEINT | E24-2 |  | 1.02777 | 1.07804 | 0.000130926 | 0.00013733 | 0 | 0.0473171 | 0.0463065 | 198.741
 | STEEL/E24-2 | 4374.44 | 34982.8 | 79235 | +4.320 | +4.403 | 444 | P12 | 1 | 1001 | GRENAILLE-PEINT | E24-2 |  | 1.02777 | 1.07804 | 0.000130926 | 0.00013733 | 0 | 0.0473171 | 0.0463065 | 198.741
 | STEEL/E24-2 | 5365.24 | 29917.2 | 79234.7 | +5.321 | +5.384 | 439 | P11 | 1 | 1011 | GRENAILLE-PEINT | E24-2 |  | 1.0204 | 1.03084 | 0.000129987 | 0.000131318 | 0 | 0.0469776 | 0.0442793 | 190.04
 | STEEL/E24-2 | 5365.24 | 29782.8 | 79234.7 | +5.321 | +5.384 | 439 | P11 | 1 | 1011 | GRENAILLE-PEINT | E24-2 |  | 1.0204 | 1.03084 | 0.000129987 | 0.000131318 | 0 | 0.0469776 | 0.0442793 | 190.04
 | STEEL/E24-2 | 3752.77 | 24582.8 | 79234.5 | +3.707 | +3.773 | 439 | P10 | 1 | 1011 | GRENAILLE-PEINT | E24-2 |  | 1.0207 | 1.03115 | 0.000130026 | 0.000131356 | 0 | 0.0469911 | 0.0442924 | 190.096
 | STEEL/E24-2 | 3752.77 | 24717.2 | 79234.5 | +3.707 | +3.773 | 439 | P10 | 1 | 1011 | GRENAILLE-PEINT | E24-2 |  | 1.0207 | 1.03115 | 0.000130026 | 0.000131356 | 0 | 0.0469911 | 0.0442924 | 190.096
 | STEEL/E24-2 | 3752.77 | 19382.8 | 79234.5 | +3.707 | +3.773 | 439 | P9 | 1 | 1011 | GRENAILLE-PEINT | E24-2 |  | 1.0207 | 1.03115 | 0.000130026 | 0.000131356 | 0 | 0.0469911 | 0.0442924 | 190.096
 | STEEL/E24-2 | 3752.77 | 19517.2 | 79234.5 | +3.707 | +3.773 | 439 | P9 | 1 | 1011 | GRENAILLE-PEINT | E24-2 |  | 1.0207 | 1.03115 | 0.000130026 | 0.000131356 | 0 | 0.0469911 | 0.0442924 | 190.096
 | STEEL/E24-2 | 3752.77 | 13617.2 | 79234.5 | +3.707 | +3.773 | 439 | P8 | 1 | 1011 | GRENAILLE-PEINT | E24-2 |  | 1.0207 | 1.03115 | 0.000130026 | 0.000131356 | 0 | 0.0469911 | 0.0442924 | 190.096
 | STEEL/E24-2 | 5060.56 | 7717.21 | 79234.5 | +5.015 | +5.081 | 439 | P6 | 1 | 1011 | GRENAILLE-PEINT | E24-2 |  | 1.0207 | 1.03115 | 0.000130026 | 0.000131356 | 0 | 0.0469911 | 0.0442924 | 190.096
 | STEEL/E24-2 | 5060.56 | 7582.79 | 79234.5 | +5.015 | +5.081 | 439 | P6 | 1 | 1011 | GRENAILLE-PEINT | E24-2 |  | 1.0207 | 1.03115 | 0.000130026 | 0.000131356 | 0 | 0.0469911 | 0.0442924 | 190.096
ATTACHE | STEEL/S235JR | 5867.21 | 30545 | 72675.9 | +5.850 | +5.910 | 428 | P97 | 1 | 1008 | GALVANISE | S235JR | ATTACHE | 1.12757 | 1.13911 | 0.00014364 | 0.00014511 | 0.00126 | 0.051768 | 0.04893 | 210
ATTACHE | STEEL/S235JR | 5867.21 | 5117.21 | 78025 | +5.850 | +5.910 | H24 | H24 | 1 | 1008 | GALVANISE | S235JR | ATTACHE | 1.12757 | 1.13911 | 0.00014364 | 0.00014511 | 0.00126 | 0.051768 | 0.04893 | 210
ATTACHE | STEEL/S235JR | 5850 | 3842.21 | 73092.2 | +5.754 | +5.946 | H21 | H21 | 1 | 1008 | GALVANISE | S235JR | ATTACHE | 1.03092 | 1.04148 | 0.000131328 | 0.000132672 | 0.000684 | 0.047448 | 0.044736 | 192
