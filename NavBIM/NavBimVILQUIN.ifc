Properties of the parts of a building model (IFC2X3), part 13 of 32

# IfcBeam: PL3*86 (10)
Name | Center of gravity Z (mm) | Center of gravity Y (mm) | Center of gravity X (mm) | Bottom elevation | Top elevation | Part mark | Assembly mark | Phase | Class
TOLE | 5935 | 69197 | 44193.5 | +5.892 | +5.978 | 1252 | L106 | 3 | 3003
TOLE | 5935 | 69197 | 32946.5 | +5.892 | +5.978 | 1252 | L106 | 3 | 3003
TOLE | 5935 | 69197 | 55868.5 | +5.892 | +5.978 | 1247 | L98 | 1 | 1003
TOLE | 5935 | 69197 | 44206.5 | +5.892 | +5.978 | 1247 | L98 | 1 | 1003
TOLE | 5935 | 69197 | 55881.5 | +5.892 | +5.978 | 1247 | L98 | 1 | 1003
TOLE | 5935 | 69197 | 67543.5 | +5.892 | +5.978 | 1247 | L98 | 1 | 1003
TOLE | 5473.58 | -47 | 79214.8 | +5.431 | +5.517 | 1247 | L100 | 1 | 1003
TOLE | 5637.76 | -47 | 73918.7 | +5.595 | +5.681 | 1247 | L100 | 1 | 1003
TOLE | 5935 | 69197 | 79128.5 | +5.892 | +5.978 | 1247 | L96 | 1 | 1003
TOLE | 5935 | 69197 | 67556.5 | +5.892 | +5.978 | 1247 | L96 | 1 | 1003

# IfcBeam: PL30*152, GOUSSET
In: Undefined
Description: PL30*152; Material: STEEL/S235JR
Tekla Common - Center of gravity Z: 5548.16 mm; Center of gravity Y: 66340 mm; Center of gravity X: 56769.5 mm; Bottom elevation: +5.459; Top elevation: +5.637; Part mark: G84; Assembly mark: G84; Phase: 1; Class: 99; Grade: S235JR; Profile: PL30*152; Name: GOUSSET; sets with these values: 2
Tekla Quantity - Net weight: 2.27797 kg; Gross weight: 2.27797 kg; Weight: 2.27797 kg; Net volume: 0.000290188 m3; Gross volume: 0.000290188 m3; Gross footprint area: 0.00215988 m2; Area per tons: 26.1659 m2; Net surface area: 0.0596052 m2; Gross area: 0.0596052 m2; Height: 151.73 mm; Width: 30 mm; Length: 177.47 mm; sets with these values: 2
Tekla Status - Erection Comment: Missing Value; Checked Date: 0; Assigned By: Me; sets with these values: 2
BaseQuantities - Length: 177.47 mm; OuterSurfaceArea: 0.0596052 m2; NetVolume: 0.000290188 m3; NetWeight: 2.27797 kg

# IfcBeam: PL30*158, GOUSSET
In: Undefined
Description: PL30*158; Material: STEEL/S235JR
Tekla Common - Center of gravity Z: 4266.18 mm; Center of gravity Y: 29982.5 mm; Center of gravity X: 55579.8 mm; Bottom elevation: +4.177; Top elevation: +4.355; Part mark: G88; Assembly mark: G88; Phase: 1; Class: 99; Grade: S235JR; Profile: PL30*158; Name: GOUSSET; sets with these values: 2
Tekla Quantity - Net weight: 1.99145 kg; Gross weight: 1.99145 kg; Weight: 1.99145 kg; Net volume: 0.000253687 m3; Gross volume: 0.000253687 m3; Gross footprint area: 0.00215988 m2; Area per tons: 26.0141 m2; Net surface area: 0.0518057 m2; Gross area: 0.0518057 m2; Height: 158.35 mm; Width: 30 mm; Length: 177.47 mm; sets with these values: 2
Tekla Status - Erection Comment: Missing Value; Checked Date: 0; Assigned By: Me; sets with these values: 2
BaseQuantities - Length: 177.47 mm; OuterSurfaceArea: 0.0518057 m2; NetVolume: 0.000253687 m3; NetWeight: 1.99145 kg

# IfcBeam: PL30*16 (11)
In: Undefined
Description: PL30*16; Material: STEEL/S235JR
Tekla Common - Phase: 1; Class: 99; Grade: S235JR; Profile: PL30*16; Name: GOUSSET; sets with these values: 2
Tekla Quantity - Area per tons: 27.2984 m2; Height: 16 mm; Width: 30 mm; sets with these values: 2
Tekla Status - Erection Comment: Missing Value; Checked Date: 0; Assigned By: Me; sets with these values: 2
Name | Center of gravity Z (mm) | Center of gravity Y (mm) | Center of gravity X (mm) | Bottom elevation | Top elevation | Part mark = Assembly mark | Net weight (kg) = Weight (kg) = NetWeight (kg) | Gross weight (kg) | Net volume (m3) = Gross volume (m3) = NetVolume (m3) | Gross footprint area (m2) | Net surface area (m2) = OuterSurfaceArea (m2) | Gross area (m2) | Tekla Quantity, Length (mm) = BaseQuantities, Length (mm)
GOUSSET | 4395.17 | 19590 | 32108.2 | +4.355 | +4.436 | G94 | 0.288452 | 0.305622 | 0.0000367455 | 0 | 0.00787429 | 0.00129776 | 81.11
GOUSSET | 4354.62 | 19590 | 32148.4 | +4.347 | +4.363 | G94 | 0.288452 | 0.305622 | 0.0000367455 | 0.00215988 | 0.00787429 | 0.00129776 | 81.11
GOUSSET | 4314.15 | 19590 | 32188.8 | +4.274 | +4.355 | G94 | 0.288452 | 0.305622 | 0.0000367455 | 0 | 0.00787429 | 0.00129776 | 81.11
GOUSSET | 4274.26 | 19590 | 32148.6 | +4.266 | +4.282 | G94 | 0.288452 | 0.305622 | 0.0000367455 | 0.00215988 | 0.00787429 | 0.00129776 | 81.11
GOUSSET | 4435.73 | 19590 | 32148.4 | +4.428 | +4.444 | G94 | 0.288452 | 0.305622 | 0.0000367455 | 0.00215988 | 0.00787429 | 0.00129776 | 81.11
GOUSSET | 5007.17 | 58471.6 | 47069.9 | +4.999 | +5.015 | G94 | 0.288452 | 0.305622 | 0.0000367455 | 0.00215988 | 0.00787429 | 0.00129776 | 81.11
GOUSSET | 4966.7 | 58471.6 | 47110.3 | +4.926 | +5.007 | G94 | 0.288452 | 0.305622 | 0.0000367455 | 0 | 0.00787429 | 0.00129776 | 81.11
GOUSSET | 5047.72 | 58471.6 | 47110.5 | +5.007 | +5.088 | G94 | 0.288452 | 0.305622 | 0.0000367455 | 0 | 0.00787429 | 0.00129776 | 81.11
GOUSSET | 5088.28 | 58471.6 | 47069.9 | +5.080 | +5.096 | G94 | 0.288452 | 0.305622 | 0.0000367455 | 0.00215988 | 0.00787429 | 0.00129776 | 81.11
GOUSSET | 5250.32 | 19350 | 20944.6 | +5.169 | +5.331 | G98 | 0.576904 | 0.576904 | 0.0000734909 | 0 | 0.0157486 | 0.0157486 | 162.22
GOUSSET | 4926.81 | 58471.6 | 47070.2 | +4.919 | +4.935 | G94 | 0.288452 | 0.305622 | 0.0000367455 | 0.00215988 | 0.00787429 | 0.00129776 | 81.11

# IfcBeam: PL30*160 (3)
In: Undefined
Description: PL30*160; Material: STEEL/S235JR
Tekla Common - Phase: 1; Class: 99; Grade: S235JR; Profile: PL30*160; Name: GOUSSET; sets with these values: 2
Tekla Quantity - Width: 30 mm; sets with these values: 2
Tekla Status - Erection Comment: Missing Value; Checked Date: 0; Assigned By: Me; sets with these values: 2
Name | Center of gravity Z (mm) | Center of gravity Y (mm) | Center of gravity X (mm) | Bottom elevation | Top elevation | Part mark = Assembly mark | Net weight (kg) = Gross weight (kg) = Weight (kg) = NetWeight (kg) | Net volume (m3) = Gross volume (m3) = NetVolume (m3) | Gross footprint area (m2) | Area per tons (m2) | Net surface area (m2) = Gross area (m2) = OuterSurfaceArea (m2) | Height (mm) | Tekla Quantity, Length (mm) = BaseQuantities, Length (mm)
GOUSSET | 4629.52 | 24627.3 | 61610.4 | +4.541 | +4.718 | G87 | 1.9907 | 0.000253592 | 0.00215988 | 26.0105 | 0.0517791 | 160.42 | 177.47
GOUSSET | 5256.12 | 8516.37 | 47117.7 | +5.175 | +5.338 | G90 | 1.42809 | 0.000181922 | 0 | 26.3996 | 0.0377011 | 160.26 | 162.88
GOUSSET | 3600.83 | 17346.6 | 44155 | +3.512 | +3.690 | G86 | 1.98974 | 0.00025347 | 0.00215988 | 25.9966 | 0.0517265 | 160.26 | 177.47

# IfcBeam: PL30*170, GOUSSET
In: Undefined
Description: PL30*170; Material: STEEL/S235JR
Tekla Common - Center of gravity Z: 4611.56 mm; Center of gravity Y: 63765 mm; Center of gravity X: 38385.9 mm; Bottom elevation: +4.504; Top elevation: +4.674; Part mark: G92; Assembly mark: G92; Phase: 1; Class: 99; Grade: S235JR; Profile: PL30*170; Name: GOUSSET; sets with these values: 2
Tekla Quantity - Net weight: 0.858856 kg; Gross weight: 0.858856 kg; Weight: 0.858856 kg; Net volume: 0.000109408 m3; Gross volume: 0.000109408 m3; Gross footprint area: 0.00215988 m2; Area per tons: 26.5567 m2; Net surface area: 0.0228084 m2; Gross area: 0.0228084 m2; Height: 170.127 mm; Width: 30 mm; Length: 89.1069 mm; sets with these values: 2
Tekla Status - Erection Comment: Missing Value; Checked Date: 0; Assigned By: Me; sets with these values: 2
BaseQuantities - Length: 89.1069 mm; OuterSurfaceArea: 0.0228084 m2; NetVolume: 0.000109408 m3; NetWeight: 0.858856 kg

# IfcBeam: PL30*177 (5)
In: Undefined
Description: PL30*177; Material: STEEL/S235JR
Tekla Common - Phase: 1; Class: 99; Grade: S235JR; Profile: PL30*177; Name: GOUSSET; sets with these values: 2
Tekla Quantity - Gross footprint area: 0.00215988 m2; Height: 177.47 mm; Width: 30 mm; sets with these values: 2
Tekla Status - Erection Comment: Missing Value; Checked Date: 0; Assigned By: Me; sets with these values: 2
Name | Center of gravity Z (mm) | Center of gravity Y (mm) | Center of gravity X (mm) | Bottom elevation | Top elevation | Part mark = Assembly mark | Net weight (kg) = Gross weight (kg) = Weight (kg) = NetWeight (kg) | Net volume (m3) = Gross volume (m3) = NetVolume (m3) | Area per tons (m2) | Net surface area (m2) = Gross area (m2) = OuterSurfaceArea (m2) | Tekla Quantity, Length (mm) = BaseQuantities, Length (mm)
GOUSSET | 5348.7 | 69028.4 | 44391.8 | +5.254 | +5.431 | G96 | 1.68762 | 0.000214983 | 25.0194 | 0.0422232 | 96.74
GOUSSET | 4624.27 | 69113.5 | 50037.2 | +4.536 | +4.713 | G89 | 2.01916 | 0.000257218 | 27.2984 | 0.05512 | 96.9
GOUSSET | 5194.56 | 61082.2 | 32801.3 | +5.113 | +5.290 | G97 | 1.68941 | 0.000215211 | 25.0337 | 0.0422921 | 97.11
GOUSSET | 4125.89 | 49773.4 | 32631.6 | +4.037 | +4.215 | G91 | 1.41321 | 0.000180027 | 25.4781 | 0.036006 | 96.79
GOUSSET | 3156.11 | 17218.1 | 12204.8 | +3.072 | +3.250 | G85 | 2.26286 | 0.000288262 | 25.5976 | 0.0579237 | 160.26

# IfcBeam: PL30*97, GOUSSET
In: Undefined
Description: PL30*97; Material: STEEL/S235JR
Tekla Common - Center of gravity Z: 4060.36 mm; Center of gravity Y: 52212.5 mm; Center of gravity X: 44284.6 mm; Bottom elevation: +3.979; Top elevation: +4.141; Part mark: G93; Assembly mark: G93; Phase: 1; Class: 99; Grade: S235JR; Profile: PL30*97; Name: GOUSSET; sets with these values: 2
Tekla Quantity - Net weight: 0.851336 kg; Gross weight: 0.851336 kg; Weight: 0.851336 kg; Net volume: 0.00010845 m3; Gross volume: 0.00010845 m3; Gross footprint area: 0 m2; Area per tons: 25.7955 m2; Net surface area: 0.0219606 m2; Gross area: 0.0219606 m2; Height: 96.79 mm; Width: 30 mm; Length: 162.04 mm; sets with these values: 2
Tekla Status - Erection Comment: Missing Value; Checked Date: 0; Assigned By: Me; sets with these values: 2
BaseQuantities - Length: 162.04 mm; OuterSurfaceArea: 0.0219606 m2; NetVolume: 0.00010845 m3; NetWeight: 0.851336 kg

# IfcBeam: PL30*99, GOUSSET
In: Undefined
Description: PL30*99; Material: STEEL/S235JR
Tekla Common - Center of gravity Z: 5344.08 mm; Center of gravity Y: 40415.4 mm; Center of gravity X: 56045.7 mm; Bottom elevation: +5.263; Top elevation: +5.425; Part mark: G95; Assembly mark: G95; Phase: 1; Class: 99; Grade: S235JR; Profile: PL30*99; Name: GOUSSET; sets with these values: 2
Tekla Quantity - Net weight: 1.15381 kg; Gross weight: 1.15381 kg; Weight: 1.15381 kg; Net volume: 0.000146982 m3; Gross volume: 0.000146982 m3; Gross footprint area: 0 m2; Area per tons: 27.2984 m2; Net surface area: 0.0314971 m2; Gross area: 0.0314971 m2; Height: 99.34 mm; Width: 30 mm; Length: 162.22 mm; sets with these values: 2
Tekla Status - Erection Comment: Missing Value; Checked Date: 0; Assigned By: Me; sets with these values: 2
BaseQuantities - Length: 162.22 mm; OuterSurfaceArea: 0.0314971 m2; NetVolume: 0.000146982 m3; NetWeight: 1.15381 kg

# IfcBeam: PL300*250, CHEMIN_CABLES
In: Undefined
Description: PL300*250; Material: STEEL/E24-2
Tekla Common - Center of gravity Z: 3500.36 mm; Center of gravity Y: 19890 mm; Center of gravity X: 75443.9 mm; Bottom elevation: +3.273; Top elevation: +3.728; Part mark: Z59; Assembly mark: Z59; Phase: 7; Class: 6; Grade: E24-2; Profile: PL300*250; Name: CHEMIN_CABLES; sets with these values: 2
Tekla Quantity - Net weight: 3893.51 kg; Gross weight: 3893.51 kg; Weight: 3893.51 kg; Net volume: 0.495988 m3; Gross volume: 0.495988 m3; Gross footprint area: 0 m2; Area per tons: 1.90689 m2; Net surface area: 7.42449 m2; Gross area: 7.42449 m2; Height: 300 mm; Width: 250 mm; Length: 6613.18 mm; sets with these values: 2
BaseQuantities - Length: 6613.18 mm; OuterSurfaceArea: 7.42449 m2; NetVolume: 0.495988 m3; NetWeight: 3893.51 kg

# IfcBeam: PL300*6 (14)
In: Undefined
Description: PL300*6
Tekla Common - Phase: 1; Profile: PL300*6; sets with these values: 2
Tekla Quantity - Height: 300 mm; Width: 6 mm; sets with these values: 2
Name | Material | Center of gravity Z (mm) | Center of gravity Y (mm) | Center of gravity X (mm) | Bottom elevation | Top elevation | Part mark | Assembly mark | Class | Finish | Grade | Name | Net weight (kg) = Gross weight (kg) = Weight (kg) = NetWeight (kg) | Net volume (m3) = Gross volume (m3) = NetVolume (m3) | Gross footprint area (m2) | Area per tons (m2) | Net surface area (m2) = Gross area (m2) = OuterSurfaceArea (m2) | Tekla Quantity, Length (mm) = BaseQuantities, Length (mm)
PLAT | STEEL/S235JR | 5876.36 | 28650 | 68589.8 | +5.844 | +5.909 | 357 | S39 | 1008 | GALVANISE | S235JR | PLAT | 6.83783 | 0.000871062 | 0 | 43.8386 | 0.299761 | 483.923
PLAT | STEEL/S235JR | 5876.36 | 20750 | 68589.8 | +5.844 | +5.909 | 357 | S38 | 1008 | GALVANISE | S235JR | PLAT | 6.83783 | 0.000871062 | 0 | 43.8386 | 0.299761 | 483.923
 | STEEL/E24-2 | 4640 | -75 | 71003 | +4.600 | +4.680 | 321 | L4 | 1003 | GRENAILLE-PEINT | E24-2 |  | 1.1304 | 0.000144 | 0.0018 | 46.4968 | 0.05256 | 80
 | STEEL/E24-2 | 4640 | -75 | 74838 | +4.600 | +4.680 | 321 | L5 | 1003 | GRENAILLE-PEINT | E24-2 |  | 1.1304 | 0.000144 | 0.0018 | 46.4968 | 0.05256 | 80
PLAT | STEEL/S235JR | 5876.36 | 24650 | 68589.8 | +5.844 | +5.909 | 357 | S37 | 1008 | GALVANISE | S235JR | PLAT | 6.83783 | 0.000871062 | 0 | 43.8386 | 0.299761 | 483.923
PLAT | STEEL/S235JR | 5876.36 | 29900 | 68589.8 | +5.844 | +5.909 | 357 | S39 | 1008 | GALVANISE | S235JR | PLAT | 6.83783 | 0.000871062 | 0 | 43.8386 | 0.299761 | 483.923
PLAT | STEEL/S235JR | 5876.36 | 26545 | 68589.8 | +5.844 | +5.909 | 357 | S11 | 1008 | GALVANISE | S235JR | PLAT | 6.83783 | 0.000871062 | 0 | 43.8386 | 0.299761 | 483.923
PLAT | STEEL/S235JR | 5876.36 | 27400 | 68589.8 | +5.844 | +5.909 | 357 | S39 | 1008 | GALVANISE | S235JR | PLAT | 6.83783 | 0.000871062 | 0 | 43.8386 | 0.299761 | 483.923
PLAT | STEEL/S235JR | 5876.36 | 19500 | 68589.8 | +5.844 | +5.909 | 357 | S38 | 1008 | GALVANISE | S235JR | PLAT | 6.83783 | 0.000871062 | 0 | 43.8386 | 0.299761 | 483.923
PLAT | STEEL/S235JR | 5876.36 | 32400 | 68589.8 | +5.844 | +5.909 | 357 | S28 | 1008 | GALVANISE | S235JR | PLAT | 6.83783 | 0.000871062 | 0 | 43.8386 | 0.299761 | 483.923
PLAT | STEEL/S235JR | 5876.36 | 25547.5 | 68589.8 | +5.844 | +5.909 | 357 | S38 | 1008 | GALVANISE | S235JR | PLAT | 6.83783 | 0.000871062 | 0 | 43.8386 | 0.299761 | 483.923
PLAT | STEEL/S235JR | 5876.36 | 22050 | 68589.8 | +5.844 | +5.909 | 357 | S37 | 1008 | GALVANISE | S235JR | PLAT | 6.83783 | 0.000871062 | 0 | 43.8386 | 0.299761 | 483.923
PLAT | STEEL/S235JR | 5876.36 | 23350 | 68589.8 | +5.844 | +5.909 | 357 | S38 | 1008 | GALVANISE | S235JR | PLAT | 6.83783 | 0.000871062 | 0 | 43.8386 | 0.299761 | 483.923
PLAT | STEEL/S235JR | 5876.36 | 31150 | 68589.8 | +5.844 | +5.909 | 357 | S39 | 1008 | GALVANISE | S235JR | PLAT | 6.83783 | 0.000871062 | 0 | 43.8386 | 0.299761 | 483.923

# IfcBeam: PL320*6 (11)
In: Undefined
Description: PL320*6; Material: STEEL/S235JR
Tekla Common - Center of gravity Z: 5760 mm; Center of gravity X: 20618 mm; Bottom elevation: +5.600; Top elevation: +5.920; Part mark: 356; Phase: 2; Class: 2007; Finish: GALVANISE; Grade: S235JR; Profile: PL320*6; Name: PLAT; sets with these values: 2
Tekla Quantity - Net weight: 4.09883 kg; Gross weight: 4.82304 kg; Weight: 4.09883 kg; Net volume: 0.000522144 m3; Gross volume: 0.0006144 m3; Gross footprint area: 0.00192 m2; Area per tons: 45.0626 m2; Net surface area: 0.184704 m2; Gross area: 0.21248 m2; Height: 320 mm; Width: 6 mm; Length: 320 mm; sets with these values: 2
BaseQuantities - Length: 320 mm; OuterSurfaceArea: 0.184704 m2; NetVolume: 0.000522144 m3; NetWeight: 4.09883 kg
Name | Center of gravity Y (mm) | Assembly mark
PLAT | 42706.5 | S1
PLAT | 37506.5 | S1
PLAT | 32306.5 | S1
PLAT | 21906.5 | S1
PLAT | 12513.5 | S1
PLAT | 45306.5 | S1
PLAT | 82.0019 | S2
PLAT | 27106.5 | S1
PLAT | 17233.5 | S1
PLAT | 9866.5 | S1
PLAT | 4956.5 | S1

# IfcBeam: PL3450*200 (2)
In: Undefined
Description: PL3450*200; Material: CONCRETE/BETON COURANT
Tekla Common - Center of gravity Z: 4225 mm; Bottom elevation: +2.500; Top elevation: +5.950; Phase: 10; Class: 75; Grade: BETON COURANT; Profile: PL3450*200; Name: MACONNERIE; sets with these values: 2
Tekla Quantity - Height: 3450 mm; Width: 200 mm; sets with these values: 2
Name | Center of gravity Y (mm) | Center of gravity X (mm) | Part mark = Assembly mark | Net weight (kg) = Gross weight (kg) = Weight (kg) = NetWeight (kg) | Net volume (m3) = Gross volume (m3) = NetVolume (m3) | Gross footprint area (m2) | Area per tons (m2) | Net surface area (m2) = Gross area (m2) = OuterSurfaceArea (m2) | Tekla Quantity, Length (mm) = BaseQuantities, Length (mm)
MACONNERIE | 26245 | 75645 | Z18 | 10751.6 | 5.1198 | 1.484 | 5.16631 | 55.546 | 7420
MACONNERIE | 32045 | 75745 | Z20 | 10461.8 | 4.9818 | 1.444 | 5.16987 | 54.086 | 7220

# IfcBeam: PL3860*200, MACONNERIE
In: Undefined
Description: PL3860*200; Material: CONCRETE/BETON COURANT
Tekla Common - Center of gravity Z: 5081.82 mm; Center of gravity Y: 48225 mm; Center of gravity X: 24220 mm; Bottom elevation: +3.140; Top elevation: +7.000; Part mark: Z48; Assembly mark: Z48; Phase: 10; Class: 75; Grade: BETON COURANT; Profile: PL3860*200; Name: MACONNERIE; sets with these values: 2
Tekla Quantity - Net weight: 10740.9 kg; Gross weight: 11194.5 kg; Weight: 10740.9 kg; Net volume: 5.11474 m3; Gross volume: 5.33074 m3; Gross footprint area: 1.38102 m2; Area per tons: 5.24101 m2; Net surface area: 56.2934 m2; Gross area: 57.6134 m2; Height: 3860 mm; Width: 200 mm; Length: 6905.1 mm; sets with these values: 2
BaseQuantities - Length: 6905.1 mm; OuterSurfaceArea: 56.2934 m2; NetVolume: 5.11474 m3; NetWeight: 10740.9 kg

# IfcBeam: PL3920*180, MACONNERIE
In: Undefined
Description: PL3920*180; Material: CONCRETE/BETON COURANT
Tekla Common - Center of gravity Z: 1960 mm; Center of gravity Y: 9657.47 mm; Center of gravity X: 74225 mm; Bottom elevation: -0.000; Top elevation: +3.920; Part mark: Z3; Assembly mark: Z3; Phase: 10; Class: 75; Grade: BETON COURANT; Profile: PL3920*180; Name: MACONNERIE; sets with these values: 2
Tekla Quantity - Net weight: 29287.1 kg; Gross weight: 29287.1 kg; Weight: 29287.1 kg; Net volume: 13.9462 m3; Gross volume: 13.9462 m3; Gross footprint area: 3.55771 m2; Area per tons: 5.58214 m2; Net surface area: 163.485 m2; Gross area: 163.485 m2; Height: 3920 mm; Width: 180 mm; Length: 19765.1 mm; sets with these values: 2
BaseQuantities - Length: 19765.1 mm; OuterSurfaceArea: 163.485 m2; NetVolume: 13.9462 m3; NetWeight: 29287.1 kg

# IfcBeam: PL3920*200, MACONNERIE
In: Undefined
Description: PL3920*200; Material: CONCRETE/BETON COURANT
Tekla Common - Center of gravity Z: 1960 mm; Center of gravity Y: 3675 mm; Center of gravity X: 70565.2 mm; Bottom elevation: -0.000; Top elevation: +3.920; Part mark: Z21; Assembly mark: Z21; Phase: 10; Class: 75; Grade: BETON COURANT; Profile: PL3920*200; Name: MACONNERIE; sets with these values: 2
Tekla Quantity - Net weight: 12841.9 kg; Gross weight: 12841.9 kg; Weight: 12841.9 kg; Net volume: 6.1152 m3; Gross volume: 6.1152 m3; Gross footprint area: 1.56 m2; Area per tons: 5.12696 m2; Net surface area: 65.84 m2; Gross area: 65.84 m2; Height: 3920 mm; Width: 200 mm; Length: 7800 mm; sets with these values: 2
BaseQuantities - Length: 7800 mm; OuterSurfaceArea: 65.84 m2; NetVolume: 6.1152 m3; NetWeight: 12841.9 kg

# IfcBeam: PL4340*200, PREFA
In: Undefined
Description: PL4340*200; Material: CONCRETE/BETON COURANT
Tekla Common - Center of gravity Z: 2117.1 mm; Center of gravity Y: 41206.1 mm; Center of gravity X: -285 mm; Bottom elevation: -0.000; Top elevation: +4.340; Part mark: Z38; Assembly mark: Z38; Phase: 10; Class: 75; Grade: BETON COURANT; Profile: PL4340*200; Name: PREFA; sets with these values: 2
Tekla Quantity - Net weight: 29916.1 kg; Gross weight: 36246.4 kg; Weight: 29916.1 kg; Net volume: 14.2458 m3; Gross volume: 17.2602 m3; Gross footprint area: 3.192 m2; Area per tons: 5.08581 m2; Net surface area: 152.148 m2; Gross area: 182.292 m2; Height: 4340 mm; Width: 200 mm; Length: 19885 mm; sets with these values: 2
BaseQuantities - Length: 19885 mm; OuterSurfaceArea: 152.148 m2; NetVolume: 14.2458 m3; NetWeight: 29916.1 kg

# IfcBeam: PL4450*200, MACONNERIE
In: Undefined
Description: PL4450*200; Material: CONCRETE/BETON COURANT
Tekla Common - Center of gravity Z: 2225 mm; Center of gravity Y: 49560 mm; Center of gravity X: 4477.5 mm; Bottom elevation: -0.000; Top elevation: +4.450; Part mark: Z19; Assembly mark: Z19; Phase: 10; Class: 75; Grade: BETON COURANT; Profile: PL4450*200; Name: MACONNERIE; sets with these values: 2
Tekla Quantity - Net weight: 18176 kg; Gross weight: 18176 kg; Weight: 18176 kg; Net volume: 8.65525 m3; Gross volume: 8.65525 m3; Gross footprint area: 1.945 m2; Area per tons: 5.07385 m2; Net surface area: 92.2225 m2; Gross area: 92.2225 m2; Height: 4450 mm; Width: 200 mm; Length: 9725 mm; sets with these values: 2
BaseQuantities - Length: 9725 mm; OuterSurfaceArea: 92.2225 m2; NetVolume: 8.65525 m3; NetWeight: 18176 kg

# IfcBeam: PL4500*200 (4)
In: Undefined
Description: PL4500*200; Material: CONCRETE/BETON COURANT
Tekla Common - Phase: 10; Grade: BETON COURANT; Profile: PL4500*200; sets with these values: 2
Tekla Quantity - Height: 4500 mm; Width: 200 mm; sets with these values: 2
Name | Center of gravity Z (mm) | Center of gravity Y (mm) | Center of gravity X (mm) | Bottom elevation | Top elevation | Part mark = Assembly mark | Class | Name | Net weight (kg) = Weight (kg) = NetWeight (kg) | Gross weight (kg) | Net volume (m3) = NetVolume (m3) | Gross volume (m3) | Gross footprint area (m2) | Area per tons (m2) | Net surface area (m2) = OuterSurfaceArea (m2) | Gross area (m2) | Tekla Quantity, Length (mm) = BaseQuantities, Length (mm)
PREFA | 6750 | 35308.2 | 19440 | +4.500 | +9.000 | Z54 | 77 | PREFA | 137150 | 137150 | 65.3098 | 65.3098 | 14.5133 | 4.98667 | 683.924 | 683.924 | 72566.4
PREFA | 6750 | 35308.2 | 10640 | +4.500 | +9.000 | Z54 | 77 | PREFA | 137150 | 137150 | 65.3098 | 65.3098 | 14.5133 | 4.98667 | 683.924 | 683.924 | 72566.4
PREFA | 2092.57 | 10250.3 | 9440 | -0.000 | +4.500 | Z39 | 75 | PREFA | 1423.59 | 1578.15 | 0.6779 | 0.7515 | 0.121 | 6.26093 | 8.913 | 9.649 | 835
MACONNERIE | 2250 | 49237.5 | 9440 | -0.000 | +4.500 | Z16 | 75 | MACONNERIE | 1597.05 | 1597.05 | 0.7605 | 0.7605 | 0.169 | 6.10062 | 9.743 | 9.743 | 845

# IfcBeam: PL4860*200 (3)
In: Undefined
Description: PL4860*200; Material: CONCRETE/BETON COURANT
Tekla Common - Bottom elevation: +6.140; Top elevation: +11.000; Phase: 10; Class: 75; Grade: BETON COURANT; Profile: PL4860*200; Name: MACONNERIE; sets with these values: 2
Tekla Quantity - Height: 4860 mm; Width: 200 mm; sets with these values: 2
Name | Center of gravity Z (mm) | Center of gravity Y (mm) | Center of gravity X (mm) | Part mark = Assembly mark | Net weight (kg) = Weight (kg) = NetWeight (kg) | Gross weight (kg) | Net volume (m3) = NetVolume (m3) | Gross volume (m3) | Gross footprint area (m2) | Area per tons (m2) | Net surface area (m2) = OuterSurfaceArea (m2) | Gross area (m2) | Tekla Quantity, Length (mm) = BaseQuantities, Length (mm)
MACONNERIE | 8570 | 49820 | 29127.5 | Z17 | 14686.4 | 14686.4 | 6.99354 | 6.99354 | 1.439 | 5.09023 | 74.7574 | 74.7574 | 7195
MACONNERIE | 8599.98 | 58375.3 | 32825 | Z49 | 33490.8 | 34700.4 | 15.948 | 16.524 | 3.4 | 5.06599 | 169.664 | 173.984 | 17000
MACONNERIE | 8559.58 | 66620 | 26347.8 | Z45 | 25593.7 | 26362.1 | 12.1875 | 12.5534 | 2.583 | 5.09636 | 130.435 | 132.644 | 12915

# IfcBeam: PL4860*250 (2)
In: Undefined
Description: PL4860*250; Material: CONCRETE/BETON COURANT
Tekla Common - Bottom elevation: +6.140; Top elevation: +11.000; Phase: 10; Class: 75; Grade: BETON COURANT; Profile: PL4860*250; Name: MACONNERIE; sets with these values: 2
Tekla Quantity - Height: 4860 mm; Width: 250 mm; sets with these values: 2
Name | Center of gravity Z (mm) | Center of gravity Y (mm) | Center of gravity X (mm) | Part mark = Assembly mark | Net weight (kg) = Weight (kg) = NetWeight (kg) | Gross weight (kg) | Net volume (m3) = NetVolume (m3) | Gross volume (m3) | Gross footprint area (m2) | Area per tons (m2) | Net surface area (m2) = OuterSurfaceArea (m2) | Gross area (m2) | Tekla Quantity, Length (mm) = BaseQuantities, Length (mm)
MACONNERIE | 8284.37 | 49845.8 | 22659 | Z60 | 11943 | 14594.6 | 5.68714 | 6.9498 | 1.43 | 4.521 | 53.9943 | 60.8884 | 5720
MACONNERIE | 8170.21 | 58447.5 | 19687.1 | Z61 | 25836.6 | 43375.5 | 12.3031 | 20.655 | 4.25 | 4.76081 | 123.003 | 176.17 | 17000

# IfcBeam: PL5*200 (12)
In: Undefined
Description: PL5*200; Material: STEEL/S235JR
Tekla Common - Center of gravity Z: 4477.5 mm; Bottom elevation: +4.475; Top elevation: +4.480; Part mark: Y5; Assembly mark: Y5; Phase: 1; Class: 1008; Finish: GALVANISE; Grade: S235JR; Profile: PL5*200; Name: CALE; sets with these values: 2
Tekla Quantity - Net weight: 1.57 kg; Gross weight: 1.57 kg; Weight: 1.57 kg; Net volume: 0.0002 m3; Gross volume: 0.0002 m3; Gross footprint area: 0.04 m2; Area per tons: 53.5032 m2; Net surface area: 0.084 m2; Gross area: 0.084 m2; Height: 200 mm; Width: 5 mm; Length: 200 mm; sets with these values: 2
BaseQuantities - Length: 200 mm; OuterSurfaceArea: 0.084 m2; NetVolume: 0.0002 m3; NetWeight: 1.57 kg
Name | Center of gravity Y (mm) | Center of gravity X (mm)
CALE | 18227 | 77004
CALE | 18227 | 77945
CALE | 20847 | 73830
CALE | 20847 | 75824
CALE | 22320 | 77004
CALE | 22320 | 77945
CALE | 19763.2 | 75824
CALE | 19763.2 | 73830
CALE | 15670.2 | 75824
CALE | 15670.2 | 73830
CALE | 24940 | 73830
CALE | 24940 | 75824

# IfcBeam: PL50*10 (40)
In: Undefined
Description: PL50*10; Material: STEEL/E24-2
Tekla Common - Finish: GRENAILLE-PEINT; Grade: E24-2; Profile: PL50*10; Name: PLATINE; sets with these values: 2
Tekla Quantity - Net weight: 0.314 kg; Gross weight: 0.314 kg; Weight: 0.314 kg; Net volume: 0.00004 m3; Gross volume: 0.00004 m3; Gross footprint area: 0 m2; Area per tons: 33.758 m2; Net surface area: 0.0106 m2; Gross area: 0.0106 m2; Height: 50 mm; Width: 10 mm; Length: 80 mm; sets with these values: 2
BaseQuantities - Length: 80 mm; OuterSurfaceArea: 0.0106 m2; NetVolume: 0.00004 m3; NetWeight: 0.314 kg
Name | Center of gravity Z (mm) | Center of gravity Y (mm) | Center of gravity X (mm) | Bottom elevation | Top elevation | Part mark | Assembly mark | Phase | Class
PLATINE | 4739.26 | 46502.1 | 20850 | +4.692 | +4.786 | 175 | N46 | 2 | 2006
PLATINE | 5091.75 | 47056.5 | 20850 | +5.045 | +5.139 | 175 | N46 | 2 | 2006
PLATINE | 4697.95 | 41862.9 | 20850 | +4.651 | +4.745 | 175 | N46 | 2 | 2006
PLATINE | 5025.75 | 41347.3 | 20850 | +4.979 | +5.073 | 175 | N46 | 2 | 2006
PLATINE | 4697.95 | 41862.9 | 32525 | +4.651 | +4.745 | 225 | N43 | 3 | 3003
PLATINE | 5025.75 | 41347.3 | 32525 | +4.979 | +5.073 | 225 | N43 | 3 | 3003
PLATINE | 5025.75 | 20547.3 | 20850 | +4.979 | +5.073 | 175 | N45 | 2 | 2006
PLATINE | 4697.95 | 21062.9 | 20850 | +4.651 | +4.745 | 175 | N45 | 2 | 2006
PLATINE | 5025.75 | 39152.7 | 20850 | +4.979 | +5.073 | 175 | N44 | 2 | 2006
PLATINE | 4697.95 | 38637.1 | 20850 | +4.651 | +4.745 | 175 | N44 | 2 | 2006
PLATINE | 4697.95 | 41862.9 | 67550 | +4.651 | +4.745 | 175 | N6 | 1 | 1006
PLATINE | 5025.75 | 41347.3 | 67550 | +4.979 | +5.073 | 175 | N6 | 1 | 1006
PLATINE | 5025.75 | 20547.3 | 67550 | +4.979 | +5.073 | 175 | N11 | 1 | 1006
PLATINE | 4697.95 | 21062.9 | 67550 | +4.651 | +4.745 | 175 | N11 | 1 | 1006
PLATINE | 5025.75 | 39152.7 | 67550 | +4.979 | +5.073 | 175 | N7 | 1 | 1006
PLATINE | 4697.95 | 38637.1 | 67550 | +4.651 | +4.745 | 175 | N7 | 1 | 1006
PLATINE | 4697.95 | 59437.1 | 67550 | +4.651 | +4.745 | 175 | N13 | 1 | 1006
PLATINE | 5025.75 | 59952.7 | 67550 | +4.979 | +5.073 | 175 | N13 | 1 | 1006
PLATINE | 4697.95 | 41862.9 | 55875 | +4.651 | +4.745 | 175 | N41 | 1 | 1006
PLATINE | 5025.75 | 41347.3 | 55875 | +4.979 | +5.073 | 175 | N41 | 1 | 1006
PLATINE | 5025.75 | 20547.3 | 55875 | +4.979 | +5.073 | 175 | N10 | 1 | 1006
PLATINE | 4697.95 | 21062.9 | 55875 | +4.651 | +4.745 | 175 | N10 | 1 | 1006
PLATINE | 5025.75 | 39152.7 | 55875 | +4.979 | +5.073 | 175 | N8 | 1 | 1006
PLATINE | 4697.95 | 38637.1 | 55875 | +4.651 | +4.745 | 175 | N8 | 1 | 1006
PLATINE | 4697.95 | 59437.1 | 55875 | +4.651 | +4.745 | 175 | N13 | 1 | 1006
PLATINE | 5025.75 | 59952.7 | 55875 | +4.979 | +5.073 | 175 | N13 | 1 | 1006
PLATINE | 5025.75 | 20547.3 | 32525 | +4.979 | +5.073 | 175 | N9 | 3 | 3006
PLATINE | 4697.95 | 21062.9 | 32525 | +4.651 | +4.745 | 175 | N9 | 3 | 3006
PLATINE | 5025.75 | 39152.7 | 32525 | +4.979 | +5.073 | 175 | N40 | 3 | 3006
PLATINE | 4697.95 | 38637.1 | 32525 | +4.651 | +4.745 | 175 | N40 | 3 | 3006
PLATINE | 4697.95 | 41862.9 | 44200 | +4.651 | +4.745 | 175 | N41 | 1 | 1006
PLATINE | 5025.75 | 41347.3 | 44200 | +4.979 | +5.073 | 175 | N41 | 1 | 1006
PLATINE | 5025.75 | 20547.3 | 44200 | +4.979 | +5.073 | 175 | N10 | 1 | 1006
PLATINE | 4697.95 | 21062.9 | 44200 | +4.651 | +4.745 | 175 | N10 | 1 | 1006
PLATINE | 5025.75 | 39152.7 | 44200 | +4.979 | +5.073 | 175 | N8 | 1 | 1006
PLATINE | 4697.95 | 38637.1 | 44200 | +4.651 | +4.745 | 175 | N8 | 1 | 1006
PLATINE | 4697.95 | 59437.1 | 44200 | +4.651 | +4.745 | 175 | N42 | 1 | 1006
PLATINE | 5025.75 | 59952.7 | 44200 | +4.979 | +5.073 | 175 | N42 | 1 | 1006
PLATINE | 5080.6 | 49061.9 | 32525 | +5.035 | +5.127 | 225 | N43 | 3 | 3003
PLATINE | 4749 | 48730.9 | 32525 | +4.703 | +4.795 | 225 | N43 | 3 | 3003

# IfcBeam: PL50*5 (14)
In: Undefined
Description: PL50*5; Material: STEEL/S235JR
Tekla Common - Center of gravity X: -732 mm; Part mark: Y4; Assembly mark: Y4; Phase: 4; Class: 4000; Finish: GALVANISE; Grade: S235JR; Profile: PL50*5; Name: CALLE; sets with these values: 2
Tekla Quantity - Net weight: 0.098125 kg; Gross weight: 0.098125 kg; Weight: 0.098125 kg; Net volume: 0.0000125 m3; Gross volume: 0.0000125 m3; Gross footprint area: 0 m2; Area per tons: 61.1465 m2; Net surface area: 0.006 m2; Gross area: 0.006 m2; Height: 50 mm; Width: 5 mm; Length: 50 mm; sets with these values: 2
BaseQuantities - Length: 50 mm; OuterSurfaceArea: 0.006 m2; NetVolume: 0.0000125 m3; NetWeight: 0.098125 kg
Name | Center of gravity Z (mm) | Center of gravity Y (mm) | Bottom elevation | Top elevation
CALLE | 4697.67 | 47943.2 | +4.670 | +4.726
CALLE | 4631.78 | 47447.5 | +4.604 | +4.660
CALLE | 4565.89 | 46951.9 | +4.538 | +4.594
CALLE | 4500 | 46456.3 | +4.472 | +4.528
CALLE | 4434.11 | 45960.6 | +4.406 | +4.462
CALLE | 4368.22 | 45465 | +4.340 | +4.396
CALLE | 4302.33 | 44969.3 | +4.274 | +4.330
CALLE | 4697.67 | 40831.8 | +4.670 | +4.726
CALLE | 4631.78 | 41327.5 | +4.604 | +4.660
CALLE | 4302.33 | 43805.7 | +4.274 | +4.330
CALLE | 4368.22 | 43310 | +4.340 | +4.396
CALLE | 4434.11 | 42814.4 | +4.406 | +4.462
CALLE | 4500 | 42318.7 | +4.472 | +4.528
CALLE | 4565.89 | 41823.1 | +4.538 | +4.594

# IfcBeam: PL50*6 (8)
In: Undefined
Description: PL50*6; Material: STEEL/E24-2
Tekla Common - Center of gravity X: -205 mm; Part mark: 330; Phase: 2; Class: 2003; Finish: GRENAILLE-PEINT; Grade: E24-2; Profile: PL50*6; Name: PLAT; sets with these values: 2
Tekla Quantity - Net weight: 0.21195 kg; Gross weight: 0.21195 kg; Weight: 0.21195 kg; Net volume: 0.000027 m3; Gross volume: 0.000027 m3; Gross footprint area: 0.0045 m2; Area per tons: 50.3892 m2; Net surface area: 0.01068 m2; Gross area: 0.01068 m2; Height: 50 mm; Width: 6 mm; Length: 90 mm; sets with these values: 2
BaseQuantities - Length: 90 mm; OuterSurfaceArea: 0.01068 m2; NetVolume: 0.000027 m3; NetWeight: 0.21195 kg
Name | Center of gravity Z (mm) | Center of gravity Y (mm) | Bottom elevation | Top elevation | Assembly mark
PLAT | 4287 | 15160 | +4.284 | +4.290 | L51
PLAT | 4287 | 15220 | +4.284 | +4.290 | L50
PLAT | 2983 | 15160 | +2.980 | +2.986 | L51
PLAT | 2983 | 15220 | +2.980 | +2.986 | L50
PLAT | 4287 | 22011.2 | +4.284 | +4.290 | L49
PLAT | 2983 | 22011.2 | +2.980 | +2.986 | L49
PLAT | 2983 | 21951.2 | +2.980 | +2.986 | L50
PLAT | 4287 | 21951.2 | +4.284 | +4.290 | L50

# IfcBeam: PL50*8 (542)
In: Undefined
Description: PL50*8; Material: STEEL/E24-2
Tekla Common - Part mark: Y3; Assembly mark: Y3; Finish: GRENAILLE-PEINT; Grade: E24-2; Profile: PL50*8; Name: CALE; sets with these values: 2
Tekla Quantity - Net weight: 0.157 kg; Gross weight: 0.157 kg; Weight: 0.157 kg; Net volume: 0.00002 m3; Gross volume: 0.00002 m3; Gross footprint area: 0 m2; Area per tons: 42.0382 m2; Net surface area: 0.0066 m2; Gross area: 0.0066 m2; Height: 50 mm; Width: 8 mm; Length: 50 mm; sets with these values: 2
BaseQuantities - Length: 50 mm; OuterSurfaceArea: 0.0066 m2; NetVolume: 0.00002 m3; NetWeight: 0.157 kg
Name | Center of gravity Z (mm) | Center of gravity Y (mm) | Center of gravity X (mm) | Bottom elevation | Top elevation | Phase | Class
CALE | 4868.81 | 4627.58 | 26146.8 | +4.861 | +4.877 | 3 | 3004
CALE | 4512.31 | 3022.42 | 29065.5 | +4.504 | +4.521 | 3 | 3004
CALE | 4557.19 | 3343.45 | 28698.1 | +4.549 | +4.565 | 3 | 3004
CALE | 4602.07 | 3664.49 | 28330.6 | +4.594 | +4.610 | 3 | 3004
CALE | 4646.95 | 3985.52 | 27963.2 | +4.639 | +4.655 | 3 | 3004
CALE | 4691.83 | 4306.55 | 27595.7 | +4.684 | +4.700 | 3 | 3004
CALE | 4736.72 | 4627.58 | 27228.2 | +4.728 | +4.745 | 3 | 3004
CALE | 4382.51 | 2093.95 | 30128.2 | +4.374 | +4.391 | 3 | 3004
CALE | 4336.71 | 1766.37 | 30503.2 | +4.328 | +4.345 | 3 | 3004
CALE | 4290.91 | 1438.79 | 30878.1 | +4.283 | +4.299 | 3 | 3004
CALE | 4245.11 | 1111.21 | 31253.1 | +4.237 | +4.253 | 3 | 3004
CALE | 4199.32 | 783.628 | 31628.1 | +4.191 | +4.208 | 3 | 3004
CALE | 4153.52 | 456.048 | 32003 | +4.145 | +4.162 | 3 | 3004
CALE | 3548.11 | 34395.6 | 20290.5 | +3.543 | +3.553 | 2 | 2004
CALE | 3536.73 | 34056.4 | 19923.3 | +3.532 | +3.542 | 2 | 2004
CALE | 3525.35 | 33717.2 | 19556.2 | +3.520 | +3.530 | 2 | 2004
CALE | 3513.96 | 33378 | 19189 | +3.509 | +3.519 | 2 | 2004
CALE | 3502.58 | 33038.8 | 18821.8 | +3.497 | +3.508 | 2 | 2004
CALE | 3491.2 | 32699.6 | 18454.7 | +3.486 | +3.496 | 2 | 2004
CALE | 3460.04 | 32716.6 | 17449.5 | +3.455 | +3.465 | 2 | 2004
CALE | 3448.66 | 33055.8 | 17082.3 | +3.444 | +3.454 | 2 | 2004
CALE | 3437.27 | 33395 | 16715.1 | +3.432 | +3.442 | 2 | 2004
CALE | 3425.89 | 33734.2 | 16348 | +3.421 | +3.431 | 2 | 2004
CALE | 3414.51 | 34073.4 | 15980.8 | +3.409 | +3.420 | 2 | 2004
CALE | 3403.13 | 34412.6 | 15613.7 | +3.398 | +3.408 | 2 | 2004
CALE | 3548.11 | 30091.9 | 20290.5 | +3.543 | +3.553 | 2 | 2004
CALE | 3536.73 | 30431.1 | 19923.3 | +3.532 | +3.542 | 2 | 2004
CALE | 3491.2 | 31787.9 | 18454.7 | +3.486 | +3.496 | 2 | 2004
CALE | 3502.58 | 31448.7 | 18821.8 | +3.497 | +3.508 | 2 | 2004
CALE | 3513.96 | 31109.5 | 19189 | +3.509 | +3.519 | 2 | 2004
CALE | 3403.13 | 30074.9 | 15613.7 | +3.398 | +3.408 | 2 | 2004
CALE | 3414.51 | 30414.1 | 15980.8 | +3.409 | +3.420 | 2 | 2004
CALE | 3460.04 | 31770.9 | 17449.5 | +3.455 | +3.465 | 2 | 2004
CALE | 3448.66 | 31431.7 | 17082.3 | +3.444 | +3.454 | 2 | 2004
CALE | 3437.27 | 31092.5 | 16715.1 | +3.432 | +3.442 | 2 | 2004
CALE | 3525.35 | 30770.3 | 19556.2 | +3.520 | +3.530 | 2 | 2004
CALE | 3425.89 | 30753.3 | 16348 | +3.421 | +3.431 | 2 | 2004
CALE | 3368.67 | 46039 | 14502.1 | +3.364 | +3.374 | 2 | 2004
CALE | 3354.69 | 46254.3 | 14051 | +3.350 | +3.360 | 2 | 2004
CALE | 3340.71 | 46469.7 | 13600 | +3.336 | +3.346 | 2 | 2004
CALE | 3326.72 | 46685 | 13149 | +3.322 | +3.332 | 2 | 2004
CALE | 3312.74 | 46900.3 | 12697.9 | +3.308 | +3.318 | 2 | 2004
CALE | 3228.85 | 48192.4 | 9991.73 | +3.224 | +3.234 | 2 | 2004
CALE | 3242.83 | 47977 | 10442.8 | +3.238 | +3.248 | 2 | 2004
CALE | 3256.81 | 47761.7 | 10893.8 | +3.252 | +3.262 | 2 | 2004
CALE | 3270.8 | 47546.4 | 11344.8 | +3.266 | +3.276 | 2 | 2004
CALE | 3298.76 | 47115.7 | 12246.9 | +3.294 | +3.304 | 2 | 2004
CALE | 3284.78 | 47331 | 11795.9 | +3.280 | +3.290 | 2 | 2004
CALE | 3281.73 | 43472.7 | 11697.4 | +3.277 | +3.287 | 2 | 2004
CALE | 3270.52 | 43817.9 | 11335.9 | +3.265 | +3.276 | 2 | 2004
CALE | 3259.31 | 44163.1 | 10974.4 | +3.254 | +3.264 | 2 | 2004
CALE | 3248.1 | 44508.3 | 10612.8 | +3.243 | +3.253 | 2 | 2004
CALE | 3236.9 | 44853.5 | 10251.3 | +3.232 | +3.242 | 2 | 2004
CALE | 3225.69 | 45198.7 | 9889.79 | +3.221 | +3.231 | 2 | 2004
CALE | 3281.73 | 42544 | 11697.4 | +3.277 | +3.287 | 2 | 2004
CALE | 3259.31 | 41853.5 | 10974.4 | +3.254 | +3.264 | 2 | 2004
CALE | 3236.9 | 41163.1 | 10251.3 | +3.232 | +3.242 | 2 | 2004
CALE | 3225.69 | 40817.9 | 9889.79 | +3.221 | +3.231 | 2 | 2004
CALE | 3248.1 | 41508.3 | 10612.8 | +3.243 | +3.253 | 2 | 2004
CALE | 3270.52 | 42198.8 | 11335.9 | +3.265 | +3.276 | 2 | 2004
CALE | 3313.11 | 43510.7 | 12709.9 | +3.308 | +3.318 | 2 | 2004
CALE | 3324.32 | 43855.9 | 13071.4 | +3.319 | +3.329 | 2 | 2004
CALE | 3369.15 | 45236.7 | 14517.5 | +3.364 | +3.374 | 2 | 2004
CALE | 3357.94 | 44891.5 | 14156 | +3.353 | +3.363 | 2 | 2004
CALE | 3335.53 | 44201.1 | 13432.9 | +3.330 | +3.341 | 2 | 2004
CALE | 3346.73 | 44546.3 | 13794.4 | +3.342 | +3.352 | 2 | 2004
CALE | 3282.19 | 37145.8 | 11712.4 | +3.277 | +3.287 | 2 | 2004
CALE | 3270.81 | 36806.6 | 11345.2 | +3.266 | +3.276 | 2 | 2004
CALE | 3259.42 | 36467.4 | 10978 | +3.254 | +3.265 | 2 | 2004
CALE | 3248.04 | 36128.2 | 10610.9 | +3.243 | +3.253 | 2 | 2004
CALE | 3236.66 | 35789 | 10243.7 | +3.232 | +3.242 | 2 | 2004
CALE | 3225.28 | 35449.8 | 9876.54 | +3.220 | +3.230 | 2 | 2004
CALE | 3225.28 | 39712.7 | 9876.54 | +3.220 | +3.230 | 2 | 2004
CALE | 3248.04 | 39034.3 | 10610.9 | +3.243 | +3.253 | 2 | 2004
CALE | 3270.81 | 38355.9 | 11345.2 | +3.266 | +3.276 | 2 | 2004
CALE | 3312.67 | 38054.1 | 12695.5 | +3.308 | +3.318 | 2 | 2004
CALE | 3335.43 | 38732.5 | 13429.9 | +3.330 | +3.341 | 2 | 2004
CALE | 3358.2 | 39410.9 | 14164.2 | +3.353 | +3.363 | 2 | 2004
CALE | 3236.66 | 39373.5 | 10243.7 | +3.232 | +3.242 | 2 | 2004
CALE | 3259.42 | 38695.1 | 10978 | +3.254 | +3.265 | 2 | 2004
CALE | 3282.19 | 38016.7 | 11712.4 | +3.277 | +3.287 | 2 | 2004
CALE | 3324.05 | 38393.3 | 13062.7 | +3.319 | +3.329 | 2 | 2004
CALE | 3346.81 | 39071.7 | 13797 | +3.342 | +3.352 | 2 | 2004
CALE | 3369.58 | 39750.1 | 14531.4 | +3.364 | +3.375 | 2 | 2004
CALE | 3369.58 | 35412.4 | 14531.4 | +3.364 | +3.375 | 2 | 2004
CALE | 3358.2 | 35751.6 | 14164.2 | +3.353 | +3.363 | 2 | 2004
CALE | 3312.67 | 37108.4 | 12695.5 | +3.308 | +3.318 | 2 | 2004
CALE | 3324.05 | 36769.2 | 13062.7 | +3.319 | +3.329 | 2 | 2004
CALE | 3335.43 | 36430 | 13429.9 | +3.330 | +3.341 | 2 | 2004
CALE | 3346.81 | 36090.8 | 13797 | +3.342 | +3.352 | 2 | 2004
CALE | 3311.62 | 22400.2 | 12661.9 | +3.307 | +3.317 | 2 | 2004
CALE | 3323.42 | 22733.6 | 13042.4 | +3.318 | +3.329 | 2 | 2004
CALE | 3335.21 | 23067 | 13422.9 | +3.330 | +3.340 | 2 | 2004
CALE | 3347.01 | 23400.4 | 13803.3 | +3.342 | +3.352 | 2 | 2004
CALE | 3358.8 | 23733.8 | 14183.8 | +3.354 | +3.364 | 2 | 2004
CALE | 3370.6 | 24067.1 | 14564.3 | +3.366 | +3.376 | 2 | 2004
CALE | 3224.64 | 24021 | 9855.9 | +3.220 | +3.230 | 2 | 2004
CALE | 3236.29 | 23691.6 | 10231.9 | +3.231 | +3.241 | 2 | 2004
CALE | 3247.95 | 23362.2 | 10607.8 | +3.243 | +3.253 | 2 | 2004
CALE | 3259.6 | 23032.8 | 10983.8 | +3.255 | +3.265 | 2 | 2004
CALE | 3271.26 | 22703.4 | 11359.7 | +3.266 | +3.276 | 2 | 2004
CALE | 3282.91 | 22373.9 | 11735.7 | +3.278 | +3.288 | 2 | 2004
CALE | 3224.64 | 19941.5 | 9855.9 | +3.220 | +3.230 | 2 | 2004
CALE | 3236.29 | 20270.9 | 10231.9 | +3.231 | +3.241 | 2 | 2004
CALE | 3247.95 | 20600.3 | 10607.8 | +3.243 | +3.253 | 2 | 2004
CALE | 3282.91 | 21588.6 | 11735.7 | +3.278 | +3.288 | 2 | 2004
CALE | 3271.26 | 21259.1 | 11359.7 | +3.266 | +3.276 | 2 | 2004
CALE | 3311.62 | 21562.3 | 12661.9 | +3.307 | +3.317 | 2 | 2004
CALE | 3323.42 | 21228.9 | 13042.4 | +3.318 | +3.329 | 2 | 2004
CALE | 3335.21 | 20895.5 | 13422.9 | +3.330 | +3.340 | 2 | 2004
CALE | 3259.6 | 20929.7 | 10983.8 | +3.255 | +3.265 | 2 | 2004
CALE | 3370.6 | 19895.4 | 14564.3 | +3.366 | +3.376 | 2 | 2004
CALE | 3358.8 | 20228.7 | 14183.8 | +3.354 | +3.364 | 2 | 2004
CALE | 3347.01 | 20562.1 | 13803.3 | +3.342 | +3.352 | 2 | 2004
CALE | 3282.71 | 17655.3 | 11729.1 | +3.278 | +3.288 | 2 | 2004
CALE | 3270.98 | 17934.1 | 11350.9 | +3.266 | +3.276 | 2 | 2004
CALE | 3259.26 | 18212.9 | 10972.7 | +3.254 | +3.264 | 2 | 2004
CALE | 3247.54 | 18491.8 | 10594.5 | +3.242 | +3.253 | 2 | 2004
CALE | 3235.81 | 18770.6 | 10216.4 | +3.231 | +3.241 | 2 | 2004
CALE | 3224.09 | 19049.5 | 9838.21 | +3.219 | +3.229 | 2 | 2004
CALE | 3282.71 | 16984.7 | 11729.1 | +3.278 | +3.288 | 2 | 2004
CALE | 3270.98 | 16705.9 | 11350.9 | +3.266 | +3.276 | 2 | 2004
CALE | 3259.26 | 16427.1 | 10972.7 | +3.254 | +3.264 | 2 | 2004
CALE | 3247.54 | 16148.2 | 10594.5 | +3.242 | +3.253 | 2 | 2004
CALE | 3235.81 | 15869.4 | 10216.4 | +3.231 | +3.241 | 2 | 2004
CALE | 3224.09 | 15590.5 | 9838.21 | +3.219 | +3.229 | 2 | 2004
CALE | 3282.71 | 12724.7 | 11729.1 | +3.278 | +3.288 | 2 | 2004
CALE | 3270.98 | 12445.9 | 11350.9 | +3.266 | +3.276 | 2 | 2004
CALE | 3259.26 | 12167.1 | 10972.7 | +3.254 | +3.264 | 2 | 2004
CALE | 3247.54 | 11888.2 | 10594.5 | +3.242 | +3.253 | 2 | 2004
CALE | 3235.81 | 11609.4 | 10216.4 | +3.231 | +3.241 | 2 | 2004
CALE | 3224.09 | 11330.5 | 9838.21 | +3.219 | +3.229 | 2 | 2004
CALE | 3282.71 | 13395.3 | 11729.1 | +3.278 | +3.288 | 2 | 2004
CALE | 3270.98 | 13674.1 | 11350.9 | +3.266 | +3.276 | 2 | 2004
CALE | 3259.26 | 13952.9 | 10972.7 | +3.254 | +3.264 | 2 | 2004
CALE | 3247.54 | 14231.8 | 10594.5 | +3.242 | +3.253 | 2 | 2004
CALE | 3235.81 | 14510.6 | 10216.4 | +3.231 | +3.241 | 2 | 2004
CALE | 3224.09 | 14789.5 | 9838.21 | +3.219 | +3.229 | 2 | 2004
CALE | 3370.64 | 14816.2 | 14565.5 | +3.366 | +3.376 | 2 | 2004
CALE | 3358.91 | 14537.3 | 14187.3 | +3.354 | +3.364 | 2 | 2004
CALE | 3347.19 | 14258.5 | 13809.2 | +3.342 | +3.352 | 2 | 2004
CALE | 3335.47 | 13979.6 | 13431 | +3.330 | +3.341 | 2 | 2004
CALE | 3323.74 | 13700.8 | 13052.8 | +3.319 | +3.329 | 2 | 2004
CALE | 3312.02 | 13422 | 12674.7 | +3.307 | +3.317 | 2 | 2004
CALE | 3370.64 | 15563.8 | 14565.5 | +3.366 | +3.376 | 2 | 2004
CALE | 3347.19 | 16121.5 | 13809.2 | +3.342 | +3.352 | 2 | 2004
CALE | 3323.74 | 16679.2 | 13052.8 | +3.319 | +3.329 | 2 | 2004
CALE | 3358.91 | 15842.7 | 14187.3 | +3.354 | +3.364 | 2 | 2004
CALE | 3335.47 | 16400.4 | 13431 | +3.330 | +3.341 | 2 | 2004
CALE | 3312.02 | 16958 | 12674.7 | +3.307 | +3.317 | 2 | 2004
CALE | 3370.64 | 11303.8 | 14565.5 | +3.366 | +3.376 | 2 | 2004
CALE | 3358.91 | 11582.7 | 14187.3 | +3.354 | +3.364 | 2 | 2004
CALE | 3312.02 | 12698 | 12674.7 | +3.307 | +3.317 | 2 | 2004
CALE | 3323.74 | 12419.2 | 13052.8 | +3.319 | +3.329 | 2 | 2004
CALE | 3335.47 | 12140.4 | 13431 | +3.330 | +3.341 | 2 | 2004
CALE | 3347.19 | 11861.5 | 13809.2 | +3.342 | +3.352 | 2 | 2004
CALE | 5365.22 | 59952 | 68782.6 | +5.357 | +5.373 | 1 | 1004
CALE | 5319.8 | 59620.8 | 69154.4 | +5.312 | +5.328 | 1 | 1004
CALE | 5274.39 | 59289.6 | 69526.2 | +5.266 | +5.283 | 1 | 1004
CALE | 5228.98 | 58958.4 | 69898 | +5.221 | +5.237 | 1 | 1004
CALE | 4867.48 | 60578 | 72857.6 | +4.859 | +4.876 | 1 | 1004
CALE | 4912.89 | 60246.8 | 72485.8 | +4.905 | +4.921 | 1 | 1004
CALE | 4867.48 | 56322 | 72857.6 | +4.859 | +4.876 | 1 | 1004
CALE | 4912.89 | 56653.2 | 72485.8 | +4.905 | +4.921 | 1 | 1004
CALE | 4958.31 | 56984.4 | 72114 | +4.950 | +4.967 | 1 | 1004
CALE | 5003.72 | 57315.6 | 71742.2 | +4.995 | +5.012 | 1 | 1004
CALE | 5049.13 | 57646.8 | 71370.4 | +5.041 | +5.057 | 1 | 1004
CALE | 5094.55 | 57978 | 70998.6 | +5.086 | +5.103 | 1 | 1004
CALE | 5227.16 | 57954.8 | 69912.9 | +5.219 | +5.235 | 1 | 1004
CALE | 5272.57 | 57623.6 | 69541.1 | +5.264 | +5.281 | 1 | 1004
CALE | 5227.16 | 43345.2 | 69912.9 | +5.219 | +5.235 | 1 | 1004
CALE | 5272.57 | 43676.4 | 69541.1 | +5.264 | +5.281 | 1 | 1004
CALE | 5317.99 | 44007.6 | 69169.2 | +5.310 | +5.326 | 1 | 1004
CALE | 5363.4 | 44338.8 | 68797.4 | +5.355 | +5.372 | 1 | 1004
CALE | 5408.81 | 44670 | 68425.6 | +5.401 | +5.417 | 1 | 1004
CALE | 5454.22 | 45001.2 | 68053.8 | +5.446 | +5.462 | 1 | 1004
CALE | 4867.48 | 44978 | 72857.6 | +4.859 | +4.876 | 1 | 1004
CALE | 4912.89 | 44646.8 | 72485.8 | +4.905 | +4.921 | 1 | 1004
CALE | 4958.31 | 44315.6 | 72114 | +4.950 | +4.967 | 1 | 1004
CALE | 5003.72 | 43984.4 | 71742.2 | +4.995 | +5.012 | 1 | 1004
CALE | 5049.13 | 43653.2 | 71370.4 | +5.041 | +5.057 | 1 | 1004
CALE | 5094.55 | 43322 | 70998.6 | +5.086 | +5.103 | 1 | 1004
CALE | 4867.48 | 40722 | 72857.6 | +4.859 | +4.876 | 1 | 1004
CALE | 4912.89 | 41053.2 | 72485.8 | +4.905 | +4.921 | 1 | 1004
CALE | 4958.31 | 41384.4 | 72114 | +4.950 | +4.967 | 1 | 1004
CALE | 5003.72 | 41715.6 | 71742.2 | +4.995 | +5.012 | 1 | 1004
CALE | 5049.13 | 42046.8 | 71370.4 | +5.041 | +5.057 | 1 | 1004
CALE | 5094.55 | 42378 | 70998.6 | +5.086 | +5.103 | 1 | 1004
CALE | 5225.57 | 42366.4 | 69925.9 | +5.217 | +5.234 | 1 | 1004
CALE | 5270.98 | 42035.2 | 69554.1 | +5.263 | +5.279 | 1 | 1004
CALE | 5316.4 | 41704 | 69182.3 | +5.308 | +5.325 | 1 | 1004
CALE | 5361.81 | 41372.8 | 68810.5 | +5.354 | +5.370 | 1 | 1004
CALE | 5407.22 | 41041.6 | 68438.7 | +5.399 | +5.415 | 1 | 1004
CALE | 5452.63 | 40710.4 | 68066.8 | +5.444 | +5.461 | 1 | 1004
CALE | 4867.48 | 35522 | 72857.6 | +4.859 | +4.876 | 1 | 1004
CALE | 4912.89 | 35853.2 | 72485.8 | +4.905 | +4.921 | 1 | 1004
CALE | 4958.31 | 36184.4 | 72114 | +4.950 | +4.967 | 1 | 1004
CALE | 5003.72 | 36515.6 | 71742.2 | +4.995 | +5.012 | 1 | 1004
CALE | 5049.13 | 36846.8 | 71370.4 | +5.041 | +5.057 | 1 | 1004
CALE | 5452.63 | 39789.6 | 68066.8 | +5.444 | +5.461 | 1 | 1004
CALE | 5407.22 | 39458.4 | 68438.7 | +5.399 | +5.415 | 1 | 1004
CALE | 5361.81 | 39127.2 | 68810.5 | +5.354 | +5.370 | 1 | 1004
CALE | 5316.4 | 38796 | 69182.3 | +5.308 | +5.325 | 1 | 1004
CALE | 5270.98 | 38464.8 | 69554.1 | +5.263 | +5.279 | 1 | 1004
CALE | 5225.57 | 38133.6 | 69925.9 | +5.217 | +5.234 | 1 | 1004
CALE | 4912.89 | 39446.8 | 72485.8 | +4.905 | +4.921 | 1 | 1004
CALE | 4867.48 | 39778 | 72857.6 | +4.859 | +4.876 | 1 | 1004
CALE | 5003.72 | 38784.4 | 71742.2 | +4.995 | +5.012 | 1 | 1004
CALE | 4958.31 | 39115.6 | 72114 | +4.950 | +4.967 | 1 | 1004
CALE | 5094.55 | 37178 | 70998.6 | +5.086 | +5.103 | 1 | 1004
CALE | 5094.55 | 38122 | 70998.6 | +5.086 | +5.103 | 1 | 1004
CALE | 5049.13 | 38453.2 | 71370.4 | +5.041 | +5.057 | 1 | 1004
CALE | 5363.4 | 36161.2 | 68797.4 | +5.355 | +5.372 | 1 | 1004
CALE | 5454.22 | 35498.8 | 68053.8 | +5.446 | +5.462 | 1 | 1004
CALE | 5408.81 | 35830 | 68425.6 | +5.401 | +5.417 | 1 | 1004
CALE | 5317.99 | 36492.4 | 69169.2 | +5.310 | +5.326 | 1 | 1004
CALE | 5272.57 | 36823.6 | 69541.1 | +5.264 | +5.281 | 1 | 1004
CALE | 5227.16 | 37154.8 | 69912.9 | +5.219 | +5.235 | 1 | 1004
CALE | 5408.81 | 56630 | 68425.6 | +5.401 | +5.417 | 1 | 1004
CALE | 5363.4 | 56961.2 | 68797.4 | +5.355 | +5.372 | 1 | 1004
CALE | 5317.99 | 57292.4 | 69169.2 | +5.310 | +5.326 | 1 | 1004
CALE | 5454.22 | 56298.8 | 68053.8 | +5.446 | +5.462 | 1 | 1004
CALE | 5456.04 | 60614.5 | 68039 | +5.448 | +5.464 | 1 | 1004
CALE | 4958.31 | 59915.6 | 72114 | +4.950 | +4.967 | 1 | 1004
CALE | 5410.63 | 60283.2 | 68410.8 | +5.402 | +5.419 | 1 | 1004
CALE | 5003.72 | 59584.4 | 71742.2 | +4.995 | +5.012 | 1 | 1004
CALE | 5049.13 | 59253.2 | 71370.4 | +5.041 | +5.057 | 1 | 1004
CALE | 5094.55 | 58922 | 70998.6 | +5.086 | +5.103 | 1 | 1004
CALE | 5467.67 | 24156.6 | 67943.8 | +5.459 | +5.476 | 1 | 1009
CALE | 5429.69 | 23767 | 68254.7 | +5.421 | +5.438 | 1 | 1009
CALE | 5391.7 | 23377.3 | 68565.7 | +5.383 | +5.400 | 1 | 1009
CALE | 5353.72 | 22987.6 | 68876.7 | +5.345 | +5.362 | 1 | 1009
CALE | 5315.74 | 22597.9 | 69187.7 | +5.308 | +5.324 | 1 | 1009
CALE | 5061.16 | 24113.8 | 71272 | +5.053 | +5.069 | 1 | 1009
CALE | 5098.38 | 23731.9 | 70967.2 | +5.090 | +5.107 | 1 | 1009
CALE | 5135.61 | 23350 | 70662.4 | +5.127 | +5.144 | 1 | 1009
CALE | 5172.83 | 22968.1 | 70357.7 | +5.165 | +5.181 | 1 | 1009
CALE | 5210.06 | 22586.2 | 70052.9 | +5.202 | +5.218 | 1 | 1009
CALE | 5210.06 | 21513.8 | 70052.9 | +5.202 | +5.218 | 1 | 1009
CALE | 5172.83 | 21131.9 | 70357.7 | +5.165 | +5.181 | 1 | 1009
CALE | 5135.61 | 20750 | 70662.4 | +5.127 | +5.144 | 1 | 1009
CALE | 5098.38 | 20368.1 | 70967.2 | +5.090 | +5.107 | 1 | 1009
CALE | 5061.16 | 19986.2 | 71271.9 | +5.053 | +5.069 | 1 | 1009
CALE | 5314.6 | 21513.8 | 69197 | +5.306 | +5.323 | 1 | 1009
CALE | 5351.82 | 21131.9 | 68892.2 | +5.344 | +5.360 | 1 | 1009
CALE | 5389.04 | 20750 | 68587.5 | +5.381 | +5.397 | 1 | 1009
CALE | 5426.27 | 20368.1 | 68282.7 | +5.418 | +5.435 | 1 | 1009
CALE | 5463.49 | 19986.2 | 67977.9 | +5.455 | +5.472 | 1 | 1009
CALE | 5126.77 | 19010.5 | 67939.9 | +5.122 | +5.132 | 1 | 1009
CALE | 5117.1 | 18658.9 | 68251.7 | +5.112 | +5.122 | 1 | 1009
CALE | 5107.44 | 18307.4 | 68563.5 | +5.102 | +5.113 | 1 | 1009
CALE | 5097.77 | 17955.9 | 68875.3 | +5.093 | +5.103 | 1 | 1009
CALE | 5088.11 | 17604.3 | 69187.1 | +5.083 | +5.093 | 1 | 1009
CALE | 5023.11 | 15240.6 | 71283.7 | +5.018 | +5.028 | 1 | 1009
CALE | 5032.37 | 15577.2 | 70985.2 | +5.027 | +5.037 | 1 | 1009
CALE | 5041.62 | 15913.7 | 70686.6 | +5.037 | +5.047 | 1 | 1009
CALE | 5050.88 | 16250.3 | 70388.1 | +5.046 | +5.056 | 1 | 1009
CALE | 5060.13 | 16586.9 | 70089.5 | +5.055 | +5.065 | 1 | 1009
CALE | 5087.95 | 16581.3 | 69192.1 | +5.083 | +5.093 | 1 | 1009
CALE | 5097.51 | 16233.5 | 68883.6 | +5.092 | +5.103 | 1 | 1009
CALE | 5107.08 | 15885.7 | 68575.1 | +5.102 | +5.112 | 1 | 1009
CALE | 5116.64 | 15537.9 | 68266.6 | +5.112 | +5.122 | 1 | 1009
CALE | 5126.2 | 15190.1 | 67958.1 | +5.121 | +5.131 | 1 | 1009
CALE | 5023.11 | 14219.4 | 71283.7 | +5.018 | +5.028 | 1 | 1009
CALE | 5032.37 | 13882.8 | 70985.2 | +5.027 | +5.037 | 1 | 1009
CALE | 5041.62 | 13546.3 | 70686.6 | +5.037 | +5.047 | 1 | 1009
CALE | 5050.88 | 13209.7 | 70388.1 | +5.046 | +5.056 | 1 | 1009
CALE | 5060.13 | 12873.1 | 70089.5 | +5.055 | +5.065 | 1 | 1009
CALE | 5087.95 | 12878.7 | 69192.1 | +5.083 | +5.093 | 1 | 1009
CALE | 5097.51 | 13226.5 | 68883.6 | +5.092 | +5.103 | 1 | 1009
CALE | 5107.08 | 13574.3 | 68575.1 | +5.102 | +5.112 | 1 | 1009
CALE | 5116.64 | 13922.1 | 68266.6 | +5.112 | +5.122 | 1 | 1009
CALE | 5126.21 | 14269.9 | 67958.1 | +5.121 | +5.131 | 1 | 1009
CALE | 5060.13 | 11866.9 | 70089.5 | +5.055 | +5.065 | 1 | 1009
CALE | 5050.88 | 11530.3 | 70388.1 | +5.046 | +5.056 | 1 | 1009
CALE | 5041.62 | 11193.7 | 70686.6 | +5.037 | +5.047 | 1 | 1009
CALE | 5032.37 | 10857.2 | 70985.2 | +5.027 | +5.037 | 1 | 1009
CALE | 5023.11 | 10520.6 | 71283.7 | +5.018 | +5.028 | 1 | 1009
CALE | 5087.95 | 11861.3 | 69192.1 | +5.083 | +5.093 | 1 | 1009
CALE | 5097.51 | 11513.5 | 68883.6 | +5.092 | +5.103 | 1 | 1009
CALE | 5107.08 | 11165.7 | 68575.1 | +5.102 | +5.112 | 1 | 1009
CALE | 5116.64 | 10817.9 | 68266.6 | +5.112 | +5.122 | 1 | 1009
CALE | 5126.2 | 10470.1 | 67958.1 | +5.121 | +5.131 | 1 | 1009
CALE | 5060.13 | 8153.1 | 70089.5 | +5.055 | +5.065 | 1 | 1009
CALE | 5050.88 | 8489.68 | 70388.1 | +5.046 | +5.056 | 1 | 1009
CALE | 5041.62 | 8826.26 | 70686.6 | +5.037 | +5.047 | 1 | 1009
CALE | 5032.37 | 9162.84 | 70985.2 | +5.027 | +5.037 | 1 | 1009
CALE | 5023.11 | 9499.42 | 71283.7 | +5.018 | +5.028 | 1 | 1009
CALE | 5126.21 | 9549.86 | 67958.1 | +5.121 | +5.131 | 1 | 1009
CALE | 5116.64 | 9202.07 | 68266.6 | +5.112 | +5.122 | 1 | 1009
CALE | 5107.08 | 8854.28 | 68575.1 | +5.102 | +5.112 | 1 | 1009
CALE | 5097.51 | 8506.49 | 68883.6 | +5.092 | +5.103 | 1 | 1009
CALE | 5087.95 | 8158.7 | 69192.1 | +5.083 | +5.093 | 1 | 1009
CALE | 5022.74 | 5632.42 | 71295.5 | +5.018 | +5.028 | 1 | 1009
CALE | 5032.17 | 6003.71 | 70991.5 | +5.027 | +5.037 | 1 | 1009
CALE | 5041.6 | 6375 | 70687.4 | +5.037 | +5.047 | 1 | 1009
CALE | 5051.02 | 6746.29 | 70383.4 | +5.046 | +5.056 | 1 | 1009
CALE | 5060.45 | 7117.58 | 70079.3 | +5.055 | +5.066 | 1 | 1009
CALE | 5126.32 | 5592.57 | 67954.4 | +5.121 | +5.131 | 1 | 1009
CALE | 5116.68 | 5971.23 | 68265.2 | +5.112 | +5.122 | 1 | 1009
CALE | 5107.05 | 6349.89 | 68576 | +5.102 | +5.112 | 1 | 1009
CALE | 5097.41 | 6728.55 | 68886.9 | +5.092 | +5.103 | 1 | 1009
CALE | 5087.78 | 7107.21 | 69197.7 | +5.083 | +5.093 | 1 | 1009
CALE | 5087.73 | 3088.59 | 69199.2 | +5.083 | +5.093 | 1 | 1009
CALE | 5097.36 | 3467.43 | 68888.6 | +5.092 | +5.102 | 1 | 1009
CALE | 5106.99 | 3846.27 | 68578 | +5.102 | +5.112 | 1 | 1009
CALE | 5116.62 | 4225.11 | 68267.3 | +5.112 | +5.122 | 1 | 1009
CALE | 5126.25 | 4603.95 | 67956.7 | +5.121 | +5.131 | 1 | 1009
CALE | 5022.77 | 4567.2 | 71294.7 | +5.018 | +5.028 | 1 | 1009
CALE | 5032.2 | 4196.09 | 70990.5 | +5.027 | +5.037 | 1 | 1009
CALE | 5041.63 | 3824.98 | 70686.2 | +5.037 | +5.047 | 1 | 1009
CALE | 5051.07 | 3453.87 | 70381.9 | +5.046 | +5.056 | 1 | 1009
CALE | 5060.5 | 3082.76 | 70077.6 | +5.055 | +5.066 | 1 | 1009
CALE | 5087.34 | 2026.91 | 69211.9 | +5.082 | +5.092 | 1 | 1009
CALE | 5097.16 | 1640.33 | 68894.9 | +5.092 | +5.102 | 1 | 1009
CALE | 5106.99 | 1253.75 | 68578 | +5.102 | +5.112 | 1 | 1009
CALE | 5116.81 | 867.167 | 68261 | +5.112 | +5.122 | 1 | 1009
CALE | 5126.64 | 480.587 | 67944 | +5.122 | +5.132 | 1 | 1009
CALE | 4986.64 | 2454.58 | 75380.9 | +4.961 | +5.012 | 1 | 1009
CALE | 4998.73 | 2192.45 | 74990.9 | +4.973 | +5.024 | 1 | 1009
CALE | 5010.81 | 1930.32 | 74601 | +4.985 | +5.037 | 1 | 1009
CALE | 5022.9 | 1668.19 | 74211.1 | +4.997 | +5.049 | 1 | 1009
CALE | 5034.99 | 1406.06 | 73821.2 | +5.009 | +5.061 | 1 | 1009
CALE | 5047.08 | 1143.93 | 73431.3 | +5.021 | +5.073 | 1 | 1009
CALE | 5059.16 | 881.802 | 73041.3 | +5.033 | +5.085 | 1 | 1009
CALE | 5071.25 | 619.672 | 72651.4 | +5.046 | +5.097 | 1 | 1009
CALE | 5083.34 | 357.542 | 72261.5 | +5.058 | +5.109 | 1 | 1009
CALE | 5095.32 | 97.6022 | 71874.8 | +5.070 | +5.121 | 1 | 1009
CALE | 5183.86 | 2048.15 | 70051.3 | +5.179 | +5.189 | 1 | 1009
CALE | 5174.04 | 1661.58 | 70368.3 | +5.169 | +5.179 | 1 | 1009
CALE | 5144.56 | 501.849 | 71319.2 | +5.139 | +5.150 | 1 | 1009
CALE | 5154.39 | 888.419 | 71002.2 | +5.149 | +5.159 | 1 | 1009
CALE | 5164.21 | 1275 | 70685.2 | +5.159 | +5.169 | 1 | 1009
CALE | 5455.21 | 433.128 | 56370.7 | +5.447 | +5.463 | 1 | 1004
CALE | 5409.41 | 760.708 | 56745.7 | +5.401 | +5.418 | 1 | 1004
CALE | 5363.62 | 1088.29 | 57120.7 | +5.355 | +5.372 | 1 | 1004
CALE | 5317.82 | 1415.87 | 57495.6 | +5.310 | +5.326 | 1 | 1004
CALE | 5272.02 | 1743.45 | 57870.6 | +5.264 | +5.280 | 1 | 1004
CALE | 5226.23 | 2071.03 | 58245.5 | +5.218 | +5.234 | 1 | 1004
CALE | 4150.31 | 433.128 | 67054.3 | +4.142 | +4.159 | 1 | 1004
CALE | 4196.11 | 760.708 | 66679.3 | +4.188 | +4.204 | 1 | 1004
CALE | 4241.91 | 1088.29 | 66304.3 | +4.234 | +4.250 | 1 | 1004
CALE | 4287.71 | 1415.87 | 65929.4 | +4.279 | +4.296 | 1 | 1004
CALE | 4333.5 | 1743.45 | 65554.4 | +4.325 | +4.342 | 1 | 1004
CALE | 4379.3 | 2071.03 | 65179.5 | +4.371 | +4.388 | 1 | 1004
CALE | 4736.72 | 4627.58 | 62253.2 | +4.728 | +4.745 | 1 | 1004
CALE | 4691.83 | 4306.55 | 62620.7 | +4.684 | +4.700 | 1 | 1004
CALE | 4646.95 | 3985.52 | 62988.2 | +4.639 | +4.655 | 1 | 1004
CALE | 4602.07 | 3664.49 | 63355.6 | +4.594 | +4.610 | 1 | 1004
CALE | 4557.19 | 3343.45 | 63723.1 | +4.549 | +4.565 | 1 | 1004
CALE | 4512.31 | 3022.42 | 64090.5 | +4.504 | +4.521 | 1 | 1004
CALE | 5093.22 | 3022.42 | 59334.5 | +5.085 | +5.101 | 1 | 1004
CALE | 5048.34 | 3343.45 | 59701.9 | +5.040 | +5.057 | 1 | 1004
CALE | 5003.45 | 3664.49 | 60069.4 | +4.995 | +5.012 | 1 | 1004
CALE | 4958.57 | 3985.52 | 60436.8 | +4.950 | +4.967 | 1 | 1004
CALE | 4868.81 | 4627.58 | 61171.8 | +4.861 | +4.877 | 1 | 1004
CALE | 4913.69 | 4306.55 | 60804.3 | +4.905 | +4.922 | 1 | 1004
CALE | 4512.31 | 3022.42 | 52415.5 | +4.504 | +4.521 | 1 | 1004
CALE | 4736.72 | 4627.58 | 50578.2 | +4.728 | +4.745 | 1 | 1004
CALE | 4602.07 | 3664.49 | 51680.6 | +4.594 | +4.610 | 1 | 1004
CALE | 5048.34 | 3343.45 | 48026.9 | +5.040 | +5.057 | 1 | 1004
CALE | 4868.81 | 4627.58 | 49496.8 | +4.861 | +4.877 | 1 | 1004
CALE | 4150.31 | 433.128 | 55379.3 | +4.142 | +4.159 | 1 | 1004
CALE | 5226.23 | 2071.03 | 46570.5 | +5.218 | +5.234 | 1 | 1004
CALE | 5272.02 | 1743.45 | 46195.6 | +5.264 | +5.280 | 1 | 1004
CALE | 5317.82 | 1415.87 | 45820.6 | +5.310 | +5.326 | 1 | 1004
CALE | 5363.62 | 1088.29 | 45445.7 | +5.355 | +5.372 | 1 | 1004
CALE | 5409.41 | 760.708 | 45070.7 | +5.401 | +5.418 | 1 | 1004
CALE | 5455.21 | 433.128 | 44695.7 | +5.447 | +5.463 | 1 | 1004
CALE | 5224.85 | 2080.85 | 34906.8 | +5.217 | +5.233 | 3 | 3004
CALE | 5362.24 | 1098.11 | 33781.9 | +5.354 | +5.370 | 3 | 3004
CALE | 4379.3 | 2071.03 | 41829.5 | +4.371 | +4.388 | 3 | 3004
CALE | 4241.91 | 1088.29 | 42954.3 | +4.234 | +4.250 | 3 | 3004
CALE | 5453.84 | 442.948 | 33032 | +5.446 | +5.462 | 3 | 3004
CALE | 5408.04 | 770.528 | 33406.9 | +5.400 | +5.416 | 3 | 3004
CALE | 5316.45 | 1425.69 | 34156.9 | +5.308 | +5.325 | 3 | 3004
CALE | 5270.65 | 1753.27 | 34531.8 | +5.262 | +5.279 | 3 | 3004
CALE | 4150.31 | 433.128 | 43704.3 | +4.142 | +4.159 | 3 | 3004
CALE | 4196.11 | 760.708 | 43329.3 | +4.188 | +4.204 | 3 | 3004
CALE | 4287.71 | 1415.87 | 42579.4 | +4.279 | +4.296 | 3 | 3004
CALE | 4333.5 | 1743.45 | 42204.4 | +4.325 | +4.342 | 3 | 3004
CALE | 4913.69 | 4306.55 | 49129.3 | +4.905 | +4.922 | 1 | 1004
CALE | 4379.3 | 2071.03 | 53504.5 | +4.371 | +4.388 | 1 | 1004
CALE | 4958.57 | 3985.52 | 48761.8 | +4.950 | +4.967 | 1 | 1004
CALE | 5003.45 | 3664.49 | 48394.4 | +4.995 | +5.012 | 1 | 1004
CALE | 4333.5 | 1743.45 | 53879.4 | +4.325 | +4.342 | 1 | 1004
CALE | 4557.19 | 3343.45 | 52048.1 | +4.549 | +4.565 | 1 | 1004
CALE | 4287.71 | 1415.87 | 54254.4 | +4.279 | +4.296 | 1 | 1004
CALE | 5093.22 | 3022.42 | 47659.5 | +5.085 | +5.101 | 1 | 1004
CALE | 4646.95 | 3985.52 | 51313.2 | +4.639 | +4.655 | 1 | 1004
CALE | 4691.83 | 4306.55 | 50945.7 | +4.684 | +4.700 | 1 | 1004
CALE | 4241.91 | 1088.29 | 54629.3 | +4.234 | +4.250 | 1 | 1004
CALE | 4196.11 | 760.708 | 55004.3 | +4.188 | +4.204 | 1 | 1004
CALE | 48.6298 | 13026.2 | 79225 | +0.013 | +0.084 | 1 | 1002
CALE | 4913.69 | 4306.55 | 37454.3 | +4.905 | +4.922 | 3 | 3004
CALE | 4868.81 | 4627.58 | 37821.8 | +4.861 | +4.877 | 3 | 3004
CALE | 4958.57 | 3985.52 | 37086.8 | +4.950 | +4.967 | 3 | 3004
CALE | 5003.45 | 3664.49 | 36719.4 | +4.995 | +5.012 | 3 | 3004
CALE | 5048.34 | 3343.45 | 36351.9 | +5.040 | +5.057 | 3 | 3004
CALE | 5093.22 | 3022.42 | 35984.5 | +5.085 | +5.101 | 3 | 3004
CALE | 4512.31 | 3022.42 | 40740.5 | +4.504 | +4.521 | 3 | 3004
CALE | 4557.19 | 3343.45 | 40373.1 | +4.549 | +4.565 | 3 | 3004
CALE | 4602.07 | 3664.49 | 40005.6 | +4.594 | +4.610 | 3 | 3004
CALE | 4646.95 | 3985.52 | 39638.2 | +4.639 | +4.655 | 3 | 3004
CALE | 4691.83 | 4306.55 | 39270.7 | +4.684 | +4.700 | 3 | 3004
CALE | 4736.72 | 4627.58 | 38903.2 | +4.728 | +4.745 | 3 | 3004
CALE | 5453.84 | 442.948 | 21357 | +5.446 | +5.462 | 3 | 3004
CALE | 5362.24 | 1098.11 | 22106.9 | +5.354 | +5.370 | 3 | 3004
CALE | 5224.85 | 2080.85 | 23231.8 | +5.217 | +5.233 | 3 | 3004
CALE | 5093.22 | 3022.42 | 24309.5 | +5.085 | +5.101 | 3 | 3004
CALE | 4958.57 | 3985.52 | 25411.8 | +4.950 | +4.967 | 3 | 3004
CALE | 5048.34 | 3343.45 | 24676.9 | +5.040 | +5.057 | 3 | 3004
CALE | 5003.45 | 3664.49 | 25044.4 | +4.995 | +5.012 | 3 | 3004
CALE | 4913.69 | 4306.55 | 25779.3 | +4.905 | +4.922 | 3 | 3004
CALE | 5270.65 | 1753.27 | 22856.8 | +5.262 | +5.279 | 3 | 3004
CALE | 5316.45 | 1425.69 | 22481.9 | +5.308 | +5.325 | 3 | 3004
CALE | 3621.92 | 31076.8 | 3339.88 | +3.617 | +3.627 | 2 | 2004
CALE | 3611.72 | 30742 | 3631.37 | +3.606 | +3.617 | 2 | 2004
CALE | 4989.58 | 4668.67 | 72365.3 | +4.985 | +4.995 | 1 | 1009
CALE | 4976.77 | 4387.44 | 72778.5 | +4.972 | +4.982 | 1 | 1009
CALE | 4963.96 | 4106.21 | 73191.7 | +4.959 | +4.969 | 1 | 1009
CALE | 4951.15 | 3824.98 | 73604.9 | +4.946 | +4.956 | 1 | 1009
CALE | 4938.34 | 3543.75 | 74018.1 | +4.933 | +4.943 | 1 | 1009
CALE | 4925.53 | 3262.52 | 74431.3 | +4.920 | +4.931 | 1 | 1009
CALE | 4912.72 | 2981.29 | 74844.5 | +4.908 | +4.918 | 1 | 1009
CALE | 5060.23 | 17589.4 | 70086.2 | +5.055 | +5.065 | 1 | 1009
CALE | 5050.87 | 17929.7 | 70388.1 | +5.046 | +5.056 | 1 | 1009
CALE | 5041.52 | 18270 | 70690 | +5.036 | +5.047 | 1 | 1009
CALE | 5032.16 | 18610.3 | 70991.8 | +5.027 | +5.037 | 1 | 1009
CALE | 5022.8 | 18950.6 | 71293.7 | +5.018 | +5.028 | 1 | 1009
CALE | 5055.06 | 25158 | 71321.9 | +5.047 | +5.063 | 1 | 1009
CALE | 5086.7 | 25506 | 71062.8 | +5.078 | +5.095 | 1 | 1009
