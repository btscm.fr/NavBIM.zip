Properties of the parts of a building model (IFC2X3), part 3 of 32

# IfcBeam: IPEA300 (314)
Name | Center of gravity Z (mm) | Center of gravity Y (mm) | Center of gravity X (mm) | Bottom elevation | Top elevation | Part mark | Assembly mark | Phase | Class | Name | Net weight (kg) = NetWeight (kg) | Gross weight (kg) = Weight (kg) | Net volume (m3) = NetVolume (m3) | Gross volume (m3) | Gross footprint area (m2) | Net surface area (m2) | Gross area (m2) = OuterSurfaceArea (m2) | Tekla Quantity, Length (mm) = BaseQuantities, Length (mm)
EMPANNON | 4955.2 | 35050 | 38374.9 | +4.104 | +5.809 | K14 | K14 | 3 | 3005 | EMPANNON | 404.869 | 424.406 | 0.0515757 | 0.0540645 | 0 | 13.6811 | 13.4871 | 11626.8
EMPANNON | 4956.4 | 37650 | 38362.5 | +4.104 | +5.809 | K16 | K16 | 3 | 3005 | EMPANNON | 405.746 | 424.406 | 0.0516874 | 0.0540645 | 0 | 13.7066 | 13.4871 | 11626.8
EMPANNON | 5390.12 | 19450 | 69836.5 | +5.007 | +5.773 | 61 | K43 | 1 | 1010 | EMPANNON | 134.825 | 141.91 | 0.0171752 | 0.0180777 | 0 | 4.56058 | 4.50972 | 3887.69
EMPANNON | 4956.4 | 45450 | 26687.5 | +4.104 | +5.809 | K17 | K17 | 3 | 3005 | EMPANNON | 405.746 | 424.406 | 0.0516874 | 0.0540645 | 0 | 13.7066 | 13.4871 | 11626.8
EMPANNON | 3383.58 | 37581.2 | 15064.6 | +3.059 | +3.708 | 91 | K70 | 2 | 2005 | EMPANNON | 399.217 | 418.419 | 0.0508556 | 0.0533017 | 0 | 13.4852 | 13.2968 | 11462.7
EMPANNON | 3727.79 | 37581.3 | 4645.28 | +3.418 | +4.036 | 93 | K83 | 2 | 2005 | EMPANNON | 322.217 | 338.753 | 0.0410468 | 0.0431532 | 0 | 10.8958 | 10.7651 | 9280.27
EMPANNON | 3727.79 | 24512.5 | 4645.28 | +3.418 | +4.036 | 82 | K77 | 2 | 2005 | EMPANNON | 322.217 | 338.753 | 0.0410468 | 0.0431532 | 0 | 10.8958 | 10.7651 | 9280.27
EMPANNON | 3727.79 | 21981.3 | 4645.28 | +3.418 | +4.036 | 83 | K78 | 2 | 2005 | EMPANNON | 322.217 | 338.753 | 0.0410468 | 0.0431532 | 0 | 10.8958 | 10.7651 | 9280.27
EMPANNON | 3383.58 | 34912.5 | 15064.6 | +3.059 | +3.708 | 75 | K61 | 2 | 2005 | EMPANNON | 399.217 | 418.419 | 0.0508556 | 0.0533017 | 0 | 13.4852 | 13.2968 | 11462.7
EMPANNON | 3727.79 | 32243.8 | 4645.28 | +3.418 | +4.036 | 78 | K73 | 2 | 2005 | EMPANNON | 322.217 | 338.753 | 0.0410468 | 0.0431532 | 0 | 10.8958 | 10.7651 | 9280.27
EMPANNON | 3187.19 | -1041.87 | 32525 | +3.023 | +3.352 | 98 | K53 | 3 | 3003 | EMPANNON | 55.8028 | 58.5898 | 0.00710864 | 0.00746367 | 0 | 1.89279 | 1.8619 | 1605.09
EMPANNON | 3190.75 | -1220.03 | 24742 | +3.023 | +3.359 | 94 | K50 | 3 | 3003 | EMPANNON | 68.2791 | 71.478 | 0.00869797 | 0.00910547 | 0 | 2.31397 | 2.27147 | 1958.17
EMPANNON | 3189.4 | -1152.42 | 28633 | +3.023 | +3.356 | 97 | K52 | 3 | 3003 | EMPANNON | 63.5442 | 66.6012 | 0.00809481 | 0.00848423 | 0 | 2.15413 | 2.1165 | 1824.57
EMPANNON | 3182.26 | -795.241 | 38362.4 | +3.023 | +3.342 | 96 | K51 | 3 | 3003 | EMPANNON | 38.5316 | 40.6722 | 0.00490849 | 0.00518117 | 0 | 1.30974 | 1.29251 | 1114.23

# IfcBeam: L100*10 (32)
In: Undefined
Description: L100*10
Tekla Common - Finish: GRENAILLE-PEINT; Profile: L100*10; sets with these values: 2
Tekla Quantity - Area per tons: 187.102 m2; Height: 100 mm; Width: 100 mm; sets with these values: 2
Name | Material | Center of gravity Z (mm) | Center of gravity Y (mm) | Center of gravity X (mm) | Bottom elevation | Top elevation | Part mark | Assembly mark | Phase | Class | Grade | Net weight (kg) = NetWeight (kg) | Gross weight (kg) = Weight (kg) | Net volume (m3) = NetVolume (m3) | Gross volume (m3) | Gross footprint area (m2) | Net surface area (m2) | Gross area (m2) = OuterSurfaceArea (m2) | Tekla Quantity, Length (mm) = BaseQuantities, Length (mm)
ATTACHE | STEEL/S235JR | 10021.4 | 63717.3 | 32696.3 | +9.916 | +10.126 | H73 | H73 | 2 | 2005 | S235JR | 3.13215 | 3.16512 | 0.000399 | 0.0004032 | 0.0019 | 0.0878 | 0.5922 | 210 | Tekla Common - Name: ATTACHE
 | STEEL/E24-2 | 3743.79 | 13634.4 | 75519.3 | +3.713 | +3.817 | 1232 | B12 | 1 | 1002 | E24-2 | 1.78978 | 1.80862 | 0.000227997 | 0.000230397 | 0 | 0.0517994 | 0.338396 | 119.998
 | STEEL/E24-2 | 3786.39 | 15548.9 | 75520.7 | +3.713 | +3.817 | 1232 | B12 | 1 | 1002 | E24-2 | 1.78978 | 1.80862 | 0.000227997 | 0.000230397 | 0 | 0.0517994 | 0.338396 | 119.998
 | STEEL/E24-2 | 4915.91 | 10112 | 78975.7 | +4.884 | +4.989 | 1232 | B15 | 1 | 1002 | E24-2 | 1.78978 | 1.80862 | 0.000227997 | 0.000230397 | 0 | 0.0517994 | 0.338396 | 119.998
 | STEEL/E24-2 | 5132.9 | 10112 | 71975.8 | +5.102 | +5.205 | 1232 | B14 | 1 | 1002 | E24-2 | 1.78978 | 1.80862 | 0.000227997 | 0.000230397 | 0 | 0.0517994 | 0.338396 | 119.998
 | STEEL/E24-2 | 5065.66 | 13355.2 | 75520.7 | +4.993 | +5.096 | 1232 | B13 | 1 | 1002 | E24-2 | 1.78978 | 1.80862 | 0.000227997 | 0.000230397 | 0 | 0.0517994 | 0.338396 | 119.998
 | STEEL/E24-2 | 5023.06 | 12454.4 | 75519.3 | +4.993 | +5.096 | 1232 | B13 | 1 | 1002 | E24-2 | 1.78978 | 1.80862 | 0.000227997 | 0.000230397 | 0 | 0.0517994 | 0.338396 | 119.998
 | STEEL/E24-2 | 5028.01 | 12268 | 75359.3 | +4.996 | +5.101 | 1232 | B14 | 1 | 1002 | E24-2 | 1.78978 | 1.80862 | 0.000227997 | 0.000230397 | 0 | 0.0517994 | 0.338396 | 119.998
 | STEEL/E24-2 | 5018.09 | 12268 | 75679.4 | +4.988 | +5.090 | 1232 | B15 | 1 | 1002 | E24-2 | 1.78978 | 1.80862 | 0.000227997 | 0.000230397 | 0 | 0.0517994 | 0.338396 | 119.998
 | STEEL/E24-2 | 4103.81 | 69183.7 | 67649.1 | +4.034 | +4.167 | 1232 | B16 | 1 | 1002 | E24-2 | 1.7898 | 1.80864 | 0.000228 | 0.0002304 | 0 | 0.0518 | 0.3384 | 120
 | STEEL/E24-2 | 4808.1 | 69183.7 | 72622.7 | +4.745 | +4.878 | 1232 | B16 | 1 | 1002 | E24-2 | 1.78978 | 1.80862 | 0.000227997 | 0.000230397 | 0 | 0.0517994 | 0.338396 | 119.998
 | STEEL/E24-2 | 4808.1 | 69183.7 | 60947.7 | +4.745 | +4.878 | 1232 | B16 | 1 | 1002 | E24-2 | 1.78978 | 1.80862 | 0.000227997 | 0.000230397 | 0 | 0.0517994 | 0.338396 | 119.998
 | STEEL/E24-2 | 4103.81 | 69183.7 | 55974.1 | +4.034 | +4.167 | 1232 | B16 | 1 | 1002 | E24-2 | 1.7898 | 1.80864 | 0.000228 | 0.0002304 | 0 | 0.0518 | 0.3384 | 120
 | STEEL/E24-2 | 4904.38 | 30318.7 | 79163.7 | +4.839 | +4.969 | 1230 | P49 | 1 | 1003 | E24-2 | 1.93895 | 1.95936 | 0.000247 | 0.0002496 | 0.0019 | 0.0558 | 0.3666 | 130
 | STEEL/E24-2 | 3934.78 | 59973.7 | 79163.7 | +3.870 | +4.000 | 1230 | P40 | 1 | 1003 | E24-2 | 1.93895 | 1.95936 | 0.000247 | 0.0002496 | 0.0019 | 0.0558 | 0.3666 | 130
 | STEEL/E24-2 | 2270.33 | 10931.6 | 79257.7 | +2.187 | +2.337 | 1232 | B17 | 1 | 1002 | E24-2 | 1.78978 | 1.80862 | 0.000227997 | 0.000230397 | 0 | 0.0517994 | 0.338396 | 119.998
 | STEEL/E24-2 | 3356.78 | 13443.2 | 79257.7 | +3.290 | +3.440 | 1232 | B17 | 1 | 1002 | E24-2 | 1.78978 | 1.80862 | 0.000227997 | 0.000230397 | 0 | 0.0517994 | 0.338396 | 119.998
ATTACHE | STEEL/S235JR | 10021.4 | 52657.3 | 32696.3 | +9.916 | +10.126 | H73 | H73 | 2 | 2005 | S235JR | 3.13215 | 3.16512 | 0.000399 | 0.0004032 | 0.0019 | 0.0878 | 0.5922 | 210 | Tekla Common - Name: ATTACHE
ATTACHE | STEEL/S235JR | 10021.4 | 55422.3 | 32696.3 | +9.916 | +10.126 | H73 | H73 | 2 | 2005 | S235JR | 3.13215 | 3.16512 | 0.000399 | 0.0004032 | 0.0019 | 0.0878 | 0.5922 | 210 | Tekla Common - Name: ATTACHE
ATTACHE | STEEL/S235JR | 10021.4 | 58187.3 | 32696.3 | +9.916 | +10.126 | H73 | H73 | 2 | 2005 | S235JR | 3.13215 | 3.16512 | 0.000399 | 0.0004032 | 0.0019 | 0.0878 | 0.5922 | 210 | Tekla Common - Name: ATTACHE
ATTACHE | STEEL/S235JR | 10021.4 | 60952.3 | 32696.3 | +9.916 | +10.126 | H73 | H73 | 2 | 2005 | S235JR | 3.13215 | 3.16512 | 0.000399 | 0.0004032 | 0.0019 | 0.0878 | 0.5922 | 210 | Tekla Common - Name: ATTACHE
ATTACHE | STEEL/S235JR | 3566.58 | 48491.4 | 20511.2 | +3.462 | +3.672 | H73 | H73 | 2 | 2005 | S235JR | 3.13215 | 3.16512 | 0.000399 | 0.0004032 | 0.0019 | 0.0878 | 0.5922 | 210 | Tekla Common - Name: ATTACHE
ATTACHE | STEEL/E24-2 | 3866.06 | 10100.8 | 718.997 | +3.792 | +3.898 | 1229 | L52 | 2 | 2003 | E24-2 | 2.68634 | 2.71462 | 0.000342209 | 0.000345812 | 0 | 0.0758441 | 0.507911 | 180.11 | Tekla Common - Name: ATTACHE
ATTACHE | STEEL/E24-2 | 3582.91 | 10100.8 | 8809 | +3.508 | +3.615 | 1229 | L52 | 2 | 2003 | E24-2 | 2.68634 | 2.71462 | 0.000342209 | 0.000345812 | 0 | 0.0758441 | 0.507911 | 180.11 | Tekla Common - Name: ATTACHE
ATTACHE | STEEL/E24-2 | 5621.02 | 50617.6 | 32753.7 | +5.516 | +5.726 | H71 | H71 | 3 | 3005 | E24-2 | 3.13215 | 3.16512 | 0.000399 | 0.0004032 | 0.0019 | 0.0878 | 0.5922 | 210 | Tekla Common - Name: ATTACHE
ATTACHE | STEEL/E24-2 | 5621.02 | 53217.6 | 32753.7 | +5.516 | +5.726 | H71 | H71 | 3 | 3005 | E24-2 | 3.13215 | 3.16512 | 0.000399 | 0.0004032 | 0.0019 | 0.0878 | 0.5922 | 210 | Tekla Common - Name: ATTACHE
ATTACHE | STEEL/E24-2 | 5621.02 | 55817.6 | 32753.7 | +5.516 | +5.726 | H71 | H71 | 3 | 3005 | E24-2 | 3.13215 | 3.16512 | 0.000399 | 0.0004032 | 0.0019 | 0.0878 | 0.5922 | 210 | Tekla Common - Name: ATTACHE
ATTACHE | STEEL/E24-2 | 5621.02 | 58417.6 | 32753.7 | +5.516 | +5.726 | H71 | H71 | 3 | 3005 | E24-2 | 3.13215 | 3.16512 | 0.000399 | 0.0004032 | 0.0019 | 0.0878 | 0.5922 | 210 | Tekla Common - Name: ATTACHE
ATTACHE | STEEL/E24-2 | 5621.02 | 63717.6 | 32753.7 | +5.516 | +5.726 | H71 | H71 | 3 | 3005 | E24-2 | 3.13215 | 3.16512 | 0.000399 | 0.0004032 | 0.0019 | 0.0878 | 0.5922 | 210 | Tekla Common - Name: ATTACHE
ATTACHE | STEEL/E24-2 | 5637.64 | 69117.6 | 32753.7 | +5.533 | +5.743 | H71 | H71 | 3 | 3005 | E24-2 | 3.13215 | 3.16512 | 0.000399 | 0.0004032 | 0.0019 | 0.0878 | 0.5922 | 210 | Tekla Common - Name: ATTACHE
ATTACHE | STEEL/E24-2 | 5621.02 | 66417.6 | 32753.7 | +5.516 | +5.726 | H71 | H71 | 3 | 3005 | E24-2 | 3.13215 | 3.16512 | 0.000399 | 0.0004032 | 0.0019 | 0.0878 | 0.5922 | 210 | Tekla Common - Name: ATTACHE
ATTACHE | STEEL/E24-2 | 4856.57 | 49828.7 | 27873.7 | +4.752 | +4.962 | H72 | H72 | 2 | 3003 | E24-2 | 3.13215 | 3.16512 | 0.000399 | 0.0004032 | 0.0019 | 0.0878 | 0.5922 | 210 | Tekla Common - Name: ATTACHE

# IfcBeam: L120*12
In: Undefined
Description: L120*12; Material: STEEL/E24-2
Tekla Common - Center of gravity Z: 4097.88 mm; Center of gravity Y: 32450 mm; Center of gravity X: 79056.4 mm; Bottom elevation: +4.042; Top elevation: +4.117; Part mark: 1159; Assembly mark: K99; Phase: 1; Class: 1010; Finish: GRENAILLE-PEINT; Grade: E24-2; Profile: L120*12; sets with these values: 2
Tekla Quantity - Net weight: 2.93056 kg; Gross weight: 3.66988 kg; Weight: 3.66988 kg; Net volume: 0.00037332 m3; Gross volume: 0.0004675 m3; Gross footprint area: 0.0204 m2; Area per tons: 21.7255 m2; Net surface area: 0.070692 m2; Gross area: 0.07973 m2; Height: 75 mm; Width: 120 mm; Length: 170 mm; sets with these values: 2
BaseQuantities - Length: 170 mm; OuterSurfaceArea: 0.07973 m2; NetVolume: 0.00037332 m3; NetWeight: 2.93056 kg

# IfcBeam: L150*15 (10)
In: Undefined
Description: L150*15; Material: STEEL/E24-2
Tekla Common - Center of gravity Y: -50.5263 mm; Part mark: 883; Finish: GRENAILLE-PEINT; Grade: E24-2; Profile: L150*15; sets with these values: 2
Tekla Quantity - Net weight: 5.36966 kg; Gross weight: 5.36966 kg; Weight: 5.36966 kg; Net volume: 0.000684033 m3; Gross volume: 0.000684033 m3; Gross footprint area: 0 m2; Area per tons: 19.4714 m2; Net surface area: 0.104555 m2; Gross area: 0.104555 m2; Height: 150 mm; Width: 150 mm; Length: 160.008 mm; sets with these values: 2
BaseQuantities - Length: 160.008 mm; OuterSurfaceArea: 0.104555 m2; NetVolume: 0.000684033 m3; NetWeight: 5.36966 kg
Name | Center of gravity Z (mm) | Center of gravity X (mm) | Bottom elevation | Top elevation | Assembly mark | Phase | Class
 | 4984.08 | 59194.5 | +4.896 | +5.089 | B7 | 1 | 1002
 | 4984.08 | 24169.5 | +4.896 | +5.089 | B7 | 3 | 3001
 | 2297.02 | 49778.8 | +2.188 | +2.386 | B5 | 1 | 1002
 | 4128.07 | 20992.1 | +4.023 | +4.217 | B7 | 3 | 3001
 | 4984.08 | 35844.5 | +4.896 | +5.089 | B7 | 3 | 3001
 | 4128.07 | 32667.1 | +4.023 | +4.217 | B7 | 3 | 3001
 | 4128.07 | 56017.1 | +4.023 | +4.217 | B7 | 1 | 1002
 | 4924.2 | 70647.2 | +4.836 | +5.029 | B8 | 1 | 1002
 | 4128.07 | 67692.1 | +4.023 | +4.217 | B8 | 1 | 1002
 | 4042.72 | 44346.4 | +3.953 | +4.152 | B5 | 1 | 1002

# IfcBeam: L40*4 (46)
In: Undefined
Description: L40*4
Tekla Common - Profile: L40*4; sets with these values: 2
Tekla Quantity - Area per tons: 64.1079 m2; Height: 40 mm; Width: 40 mm; sets with these values: 2
Name | Material | Center of gravity Z (mm) | Center of gravity Y (mm) | Center of gravity X (mm) | Bottom elevation | Top elevation | Part mark = Assembly mark | Phase | Class | Finish | Grade | Name | Net weight (kg) = NetWeight (kg) | Gross weight (kg) = Weight (kg) | Net volume (m3) = NetVolume (m3) | Gross volume (m3) | Gross footprint area (m2) | Net surface area (m2) | Gross area (m2) = OuterSurfaceArea (m2) | Tekla Quantity, Length (mm) = BaseQuantities, Length (mm)
BRACON | STEEL/E24-2 | 3309.27 | 14960.7 | 661.474 | +3.132 | +3.499 | W5 | 6 | 6001 | GRENAILLE-PEINT | E24-2 | BRACON | 1.14337 | 1.15841 | 0.000145652 | 0.000147568 | 0 | 0.0772669 | 0.0742633 | 479.118
BRACON | STEEL/E24-2 | 3309.27 | 13289.3 | 661.474 | +3.132 | +3.499 | W5 | 6 | 6001 | GRENAILLE-PEINT | E24-2 | BRACON | 1.14337 | 1.15841 | 0.000145652 | 0.000147568 | 0 | 0.0772669 | 0.0742633 | 479.118
BRACON | STEEL/E24-2 | 3309.27 | 10700.7 | 661.474 | +3.132 | +3.499 | W5 | 6 | 6001 | GRENAILLE-PEINT | E24-2 | BRACON | 1.14337 | 1.15841 | 0.000145652 | 0.000147568 | 0 | 0.0772669 | 0.0742633 | 479.118
BRACON | STEEL/E24-2 | 3309.27 | 13289.3 | 3326.47 | +3.132 | +3.499 | W5 | 6 | 6001 | GRENAILLE-PEINT | E24-2 | BRACON | 1.14337 | 1.15841 | 0.000145652 | 0.000147568 | 0 | 0.0772669 | 0.0742633 | 479.118
BRACON | STEEL/E24-2 | 3309.27 | 10700.7 | 3326.47 | +3.132 | +3.499 | W5 | 6 | 6001 | GRENAILLE-PEINT | E24-2 | BRACON | 1.14337 | 1.15841 | 0.000145652 | 0.000147568 | 0 | 0.0772669 | 0.0742633 | 479.118
CV | STEEL/S235JR | 4525 | 44398 | -717.526 | +4.260 | +4.790 | W2 | 4 | 4000 | GALVANISE | S235JR | CV | 1.26479 | 1.27176 | 0.00016112 | 0.000162008 | 0.000304 | 0.085408 | 0.08153 | 526
CV | STEEL/S235JR | 4510.43 | 46454.9 | -717.526 | +4.208 | +4.795 | W3 | 4 | 4000 | GALVANISE | S235JR | CV | 9.91286 | 10.0336 | 0.00126278 | 0.00127817 | 0 | 0.665231 | 0.643234 | 4149.9
CV | STEEL/S235JR | 4510.43 | 46454.9 | -746.474 | +4.208 | +4.795 | W3 | 4 | 4000 | GALVANISE | S235JR | CV | 9.91286 | 10.0336 | 0.00126278 | 0.00127817 | 0 | 0.665232 | 0.643234 | 4149.9
CV | STEEL/S235JR | 4510.43 | 42320.1 | -746.474 | +4.208 | +4.795 | W3 | 4 | 4000 | GALVANISE | S235JR | CV | 9.91286 | 10.0336 | 0.00126278 | 0.00127817 | 0 | 0.665232 | 0.643234 | 4149.9
CV | STEEL/S235JR | 4510.43 | 42320.1 | -717.526 | +4.208 | +4.795 | W3 | 4 | 4000 | GALVANISE | S235JR | CV | 9.91286 | 10.0336 | 0.00126278 | 0.00127817 | 0 | 0.665231 | 0.643234 | 4149.9
ATTACHE | STEEL/S235JR | 5938.53 | 10021.5 | 78975 | +5.910 | +5.950 | H55 | 1 | 1008 | GALVANISE | S235JR | ATTACHE | 1.57502 | 1.59575 | 0.00020064 | 0.00020328 | 0.0264 | 0.106208 | 0.1023 | 660
CSV | STEEL/E24-2 | 4471.18 | 34288.5 | 79146.5 | +3.987 | +4.969 | C135 | 1 | 1009 | GRENAILLE-PEINT | E24-2 | CSV | 3.76205 | 3.80188 | 0.000479242 | 0.000484316 | 0 | 0.25284 | 0.24373 | 1572.45
CSV | STEEL/E24-2 | 4471.19 | 32937.5 | 79146.5 | +3.987 | +4.969 | C135 | 1 | 1009 | GRENAILLE-PEINT | E24-2 | CSV | 3.76205 | 3.80188 | 0.000479242 | 0.000484316 | 0 | 0.252841 | 0.24373 | 1572.45
ATTACHE | STEEL/S235JR | 5938.53 | 1361.47 | 78975 | +5.910 | +5.950 | H55 | 1 | 1008 | GALVANISE | S235JR | ATTACHE | 1.57502 | 1.59575 | 0.00020064 | 0.00020328 | 0.0264 | 0.106208 | 0.1023 | 660
ATTACHE | STEEL/S235JR | 5938.53 | 7661.47 | 78975 | +5.910 | +5.950 | H55 | 1 | 1008 | GALVANISE | S235JR | ATTACHE | 1.57502 | 1.59575 | 0.00020064 | 0.00020328 | 0.0264 | 0.106208 | 0.1023 | 660
ATTACHE | STEEL/S235JR | 5938.53 | 3836.47 | 78975 | +5.910 | +5.950 | H55 | 1 | 1008 | GALVANISE | S235JR | ATTACHE | 1.57502 | 1.59575 | 0.00020064 | 0.00020328 | 0.0264 | 0.106208 | 0.1023 | 660
ATTACHE | STEEL/S235JR | 5938.53 | 8841.47 | 78975 | +5.910 | +5.950 | H55 | 1 | 1008 | GALVANISE | S235JR | ATTACHE | 1.57502 | 1.59575 | 0.00020064 | 0.00020328 | 0.0264 | 0.106208 | 0.1023 | 660
ATTACHE | STEEL/S235JR | 5938.53 | 2561.47 | 78975 | +5.910 | +5.950 | H55 | 1 | 1008 | GALVANISE | S235JR | ATTACHE | 1.57502 | 1.59575 | 0.00020064 | 0.00020328 | 0.0264 | 0.106208 | 0.1023 | 660
ATTACHE | STEEL/S235JR | 5938.53 | 5111.47 | 78975 | +5.910 | +5.950 | H55 | 1 | 1008 | GALVANISE | S235JR | ATTACHE | 1.57502 | 1.59575 | 0.00020064 | 0.00020328 | 0.0264 | 0.106208 | 0.1023 | 660
ATTACHE | STEEL/S235JR | 5938.53 | 12381.5 | 78975 | +5.910 | +5.950 | H55 | 1 | 1008 | GALVANISE | S235JR | ATTACHE | 1.57502 | 1.59575 | 0.00020064 | 0.00020328 | 0.0264 | 0.106208 | 0.1023 | 660
ATTACHE | STEEL/S235JR | 5938.53 | 11201.5 | 78975 | +5.910 | +5.950 | H55 | 1 | 1008 | GALVANISE | S235JR | ATTACHE | 1.57502 | 1.59575 | 0.00020064 | 0.00020328 | 0.0264 | 0.106208 | 0.1023 | 660
ATTACHE | STEEL/S235JR | 5938.53 | 6386.47 | 78975 | +5.910 | +5.950 | H55 | 1 | 1008 | GALVANISE | S235JR | ATTACHE | 1.57502 | 1.59575 | 0.00020064 | 0.00020328 | 0.0264 | 0.106208 | 0.1023 | 660
ATTACHE | STEEL/S235JR | 5938.53 | 161.474 | 78975 | +5.910 | +5.950 | H55 | 1 | 1008 | GALVANISE | S235JR | ATTACHE | 1.57502 | 1.59575 | 0.00020064 | 0.00020328 | 0.0264 | 0.106208 | 0.1023 | 660
ATTACHE | STEEL/S235JR | 5938.53 | 13277.5 | 78975 | +5.910 | +5.950 | H55 | 1 | 1008 | GALVANISE | S235JR | ATTACHE | 1.57502 | 1.59575 | 0.00020064 | 0.00020328 | 0.0264 | 0.106208 | 0.1023 | 660
ATTACHE | STEEL/S235JR | 5938.53 | 29911.5 | 78975 | +5.910 | +5.950 | H55 | 1 | 1008 | GALVANISE | S235JR | ATTACHE | 1.57502 | 1.59575 | 0.00020064 | 0.00020328 | 0.0264 | 0.106208 | 0.1023 | 660
ATTACHE | STEEL/S235JR | 5938.53 | 28661.5 | 78975 | +5.910 | +5.950 | H55 | 1 | 1008 | GALVANISE | S235JR | ATTACHE | 1.57502 | 1.59575 | 0.00020064 | 0.00020328 | 0.0264 | 0.106208 | 0.1023 | 660
ATTACHE | STEEL/S235JR | 5938.53 | 26556.5 | 78975 | +5.910 | +5.950 | H55 | 1 | 1008 | GALVANISE | S235JR | ATTACHE | 1.57502 | 1.59575 | 0.00020064 | 0.00020328 | 0.0264 | 0.106208 | 0.1023 | 660
ATTACHE | STEEL/S235JR | 5938.53 | 31161.5 | 78975 | +5.910 | +5.950 | H55 | 1 | 1008 | GALVANISE | S235JR | ATTACHE | 1.57502 | 1.59575 | 0.00020064 | 0.00020328 | 0.0264 | 0.106208 | 0.1023 | 660
ATTACHE | STEEL/S235JR | 5938.53 | 32388.5 | 78975 | +5.910 | +5.950 | H55 | 1 | 1008 | GALVANISE | S235JR | ATTACHE | 1.57502 | 1.59575 | 0.00020064 | 0.00020328 | 0.0264 | 0.106208 | 0.1023 | 660
ATTACHE | STEEL/S235JR | 5938.53 | 27411.5 | 78975 | +5.910 | +5.950 | H55 | 1 | 1008 | GALVANISE | S235JR | ATTACHE | 1.57502 | 1.59575 | 0.00020064 | 0.00020328 | 0.0264 | 0.106208 | 0.1023 | 660
CV | STEEL/E24-2 | 3628.23 | 32763.8 | -147.526 | +3.003 | +4.265 | W4 | 5 | 5001 | GRENAILLE-PEINT | E24-2 | CV | 3.84987 | 3.90053 | 0.00049043 | 0.000496883 | 0 | 0.258729 | 0.250055 | 1613.26
BRACON | STEEL/E24-2 | 3309.27 | 10700.7 | 6336.47 | +3.132 | +3.499 | W5 | 6 | 6001 | GRENAILLE-PEINT | E24-2 | BRACON | 1.14337 | 1.15841 | 0.000145652 | 0.000147568 | 0 | 0.0772669 | 0.0742633 | 479.118
BRACON | STEEL/E24-2 | 3309.27 | 13289.3 | 6336.47 | +3.132 | +3.499 | W5 | 6 | 6001 | GRENAILLE-PEINT | E24-2 | BRACON | 1.14337 | 1.15841 | 0.000145652 | 0.000147568 | 0 | 0.0772669 | 0.0742633 | 479.118
BRACON | STEEL/E24-2 | 3309.27 | 14960.7 | 3326.47 | +3.132 | +3.499 | W5 | 6 | 6001 | GRENAILLE-PEINT | E24-2 | BRACON | 1.14337 | 1.15841 | 0.000145652 | 0.000147568 | 0 | 0.0772669 | 0.0742633 | 479.118
BRACON | STEEL/E24-2 | 3309.27 | 17549.3 | 3326.47 | +3.132 | +3.499 | W5 | 6 | 6001 | GRENAILLE-PEINT | E24-2 | BRACON | 1.14337 | 1.15841 | 0.000145652 | 0.000147568 | 0 | 0.0772669 | 0.0742633 | 479.118
BRACON | STEEL/E24-2 | 3309.27 | 17549.3 | 661.474 | +3.132 | +3.499 | W5 | 6 | 6001 | GRENAILLE-PEINT | E24-2 | BRACON | 1.14337 | 1.15841 | 0.000145652 | 0.000147568 | 0 | 0.0772669 | 0.0742633 | 479.118
BRACON | STEEL/E24-2 | 3309.27 | 19220.7 | 661.474 | +3.132 | +3.499 | W5 | 6 | 6001 | GRENAILLE-PEINT | E24-2 | BRACON | 1.14337 | 1.15841 | 0.000145652 | 0.000147568 | 0 | 0.0772669 | 0.0742633 | 479.118
BRACON | STEEL/E24-2 | 3309.27 | 19220.7 | 3326.47 | +3.132 | +3.499 | W5 | 6 | 6001 | GRENAILLE-PEINT | E24-2 | BRACON | 1.14337 | 1.15841 | 0.000145652 | 0.000147568 | 0 | 0.0772669 | 0.0742633 | 479.118
BRACON | STEEL/E24-2 | 3309.27 | 22210.5 | 661.474 | +3.132 | +3.499 | W5 | 6 | 6001 | GRENAILLE-PEINT | E24-2 | BRACON | 1.14337 | 1.15841 | 0.000145652 | 0.000147568 | 0 | 0.0772669 | 0.0742633 | 479.118
BRACON | STEEL/E24-2 | 3309.27 | 22210.5 | 3326.47 | +3.132 | +3.499 | W5 | 6 | 6001 | GRENAILLE-PEINT | E24-2 | BRACON | 1.14337 | 1.15841 | 0.000145652 | 0.000147568 | 0 | 0.0772669 | 0.0742633 | 479.118
BRACON | STEEL/E24-2 | 3309.27 | 24283.2 | 661.474 | +3.132 | +3.499 | W5 | 6 | 6001 | GRENAILLE-PEINT | E24-2 | BRACON | 1.14337 | 1.15841 | 0.000145652 | 0.000147568 | 0 | 0.0772669 | 0.0742633 | 479.118
BRACON | STEEL/E24-2 | 3309.27 | 29345.7 | 661.474 | +3.132 | +3.499 | W5 | 6 | 6001 | GRENAILLE-PEINT | E24-2 | BRACON | 1.14337 | 1.15841 | 0.000145652 | 0.000147568 | 0 | 0.0772669 | 0.0742633 | 479.118
BRACON | STEEL/E24-2 | 3309.27 | 27273 | 661.474 | +3.132 | +3.499 | W5 | 6 | 6001 | GRENAILLE-PEINT | E24-2 | BRACON | 1.14337 | 1.15841 | 0.000145652 | 0.000147568 | 0 | 0.0772669 | 0.0742633 | 479.118
BRACON | STEEL/E24-2 | 3309.27 | 32473 | 661.474 | +3.132 | +3.499 | W5 | 6 | 6001 | GRENAILLE-PEINT | E24-2 | BRACON | 1.14337 | 1.15841 | 0.000145652 | 0.000147568 | 0 | 0.0772669 | 0.0742633 | 479.118
BRACON | STEEL/E24-2 | 3309.27 | 24283.2 | 3246.47 | +3.132 | +3.499 | W5 | 6 | 6001 | GRENAILLE-PEINT | E24-2 | BRACON | 1.14337 | 1.15841 | 0.000145652 | 0.000147568 | 0 | 0.0772669 | 0.0742633 | 479.118
BRACON | STEEL/E24-2 | 3309.27 | 14960.7 | 6256.47 | +3.132 | +3.499 | W5 | 6 | 6001 | GRENAILLE-PEINT | E24-2 | BRACON | 1.14337 | 1.15841 | 0.000145652 | 0.000147568 | 0 | 0.0772669 | 0.0742633 | 479.118

# IfcBeam: L50*5 (452)
In: Undefined
Description: L50*5; Material: STEEL/E24-2
Tekla Common - Finish: GRENAILLE-PEINT; Grade: E24-2; Profile: L50*5; sets with these values: 2
Tekla Quantity - Gross footprint area: 0 m2; Area per tons: 51.4862 m2; Height: 50 mm; Width: 50 mm; sets with these values: 2
Name | Center of gravity Z (mm) | Center of gravity Y (mm) | Center of gravity X (mm) | Bottom elevation | Top elevation | Part mark | Assembly mark | Phase | Class | Name | Net weight (kg) = NetWeight (kg) | Gross weight (kg) = Weight (kg) | Net volume (m3) = NetVolume (m3) | Gross volume (m3) | Net surface area (m2) | Gross area (m2) = OuterSurfaceArea (m2) | Tekla Quantity, Length (mm) = BaseQuantities, Length (mm)
ATTACHE | 4293.3 | 27865.7 | 57559.5 | +3.502 | +5.070 | H34 | H34 | 4 | 4001 | ATTACHE | 8.20002 | 8.28633 | 0.00104459 | 0.00105558 | 0.440777 | 0.426632 | 2199.13
ATTACHE | 4293.3 | 24034.3 | 57559.5 | +3.502 | +5.070 | H34 | H34 | 4 | 4001 | ATTACHE | 8.20002 | 8.28633 | 0.00104459 | 0.00105558 | 0.440777 | 0.426632 | 2199.13
CSV | 4422.56 | 46774 | 29649.1 | +4.042 | +4.783 | C45 | C45 | 3 | 3004 | CSV | 23.09 | 23.3179 | 0.0029414 | 0.00297044 | 1.23943 | 1.20055 | 6188.41
CSV | 5145.61 | 44148.9 | 23729.2 | +4.767 | +5.504 | C47 | C47 | 3 | 3004 | CSV | 22.9699 | 23.1966 | 0.0029261 | 0.00295498 | 1.23299 | 1.1943 | 6156.21
CSV | 5142.26 | 46729.4 | 23756.7 | +4.767 | +5.497 | C46 | C46 | 3 | 3004 | CSV | 22.7171 | 22.9411 | 0.0028939 | 0.00292244 | 1.21943 | 1.18115 | 6088.41
CSV | 4961.71 | 36360.2 | 25234.9 | +4.761 | +5.143 | C25 | C25 | 3 | 3004 | CSV | 13.4424 | 13.5688 | 0.00171241 | 0.00172851 | 0.721964 | 0.698608 | 3601.07
CSV | 4958.99 | 38959.6 | 25257.2 | +4.756 | +5.143 | C29 | C29 | 3 | 3004 | CSV | 13.6661 | 13.7949 | 0.00174091 | 0.00175731 | 0.733964 | 0.710248 | 3661.07
CSV | 5323.58 | 36337 | 22272.1 | +5.122 | +5.506 | C28 | C28 | 3 | 3004 | CSV | 13.7034 | 13.8326 | 0.00174566 | 0.00176211 | 0.735964 | 0.712188 | 3671.07
CSV | 5321.99 | 38951.4 | 22285.2 | +5.122 | +5.503 | C36 | C36 | 3 | 3004 | CSV | 13.5729 | 13.7007 | 0.00172903 | 0.00174531 | 0.728964 | 0.705398 | 3636.07
CSV | 4961.71 | 33739.8 | 25234.9 | +4.761 | +5.143 | C25 | C25 | 3 | 3004 | CSV | 13.4424 | 13.5688 | 0.00171241 | 0.00172851 | 0.721964 | 0.698608 | 3601.07
CSV | 4961.71 | 31160.2 | 25234.9 | +4.761 | +5.143 | C25 | C25 | 3 | 3004 | CSV | 13.4424 | 13.5688 | 0.00171241 | 0.00172851 | 0.721964 | 0.698608 | 3601.07
CSV | 5323.58 | 31137 | 22272.1 | +5.122 | +5.506 | C28 | C28 | 3 | 3004 | CSV | 13.7034 | 13.8326 | 0.00174566 | 0.00176211 | 0.735964 | 0.712188 | 3671.07
CSV | 5323.58 | 33763 | 22272.1 | +5.122 | +5.506 | C28 | C28 | 3 | 3004 | CSV | 13.7034 | 13.8326 | 0.00174566 | 0.00176211 | 0.735964 | 0.712188 | 3671.07
CSV | 4961.71 | 28539.8 | 25234.9 | +4.761 | +5.143 | C25 | C25 | 3 | 3004 | CSV | 13.4424 | 13.5688 | 0.00171241 | 0.00172851 | 0.721964 | 0.698608 | 3601.07
CSV | 4961.71 | 25960.2 | 25234.9 | +4.761 | +5.143 | C25 | C25 | 3 | 3004 | CSV | 13.4424 | 13.5688 | 0.00171241 | 0.00172851 | 0.721964 | 0.698608 | 3601.07
CSV | 5323.58 | 25937 | 22272.1 | +5.122 | +5.506 | C28 | C28 | 3 | 3004 | CSV | 13.7034 | 13.8326 | 0.00174566 | 0.00176211 | 0.735964 | 0.712188 | 3671.07
CSV | 5323.58 | 28563 | 22272.1 | +5.122 | +5.506 | C28 | C28 | 3 | 3004 | CSV | 13.7034 | 13.8326 | 0.00174566 | 0.00176211 | 0.735964 | 0.712188 | 3671.07
CSV | 4961.71 | 23339.8 | 25234.9 | +4.761 | +5.143 | C25 | C25 | 3 | 3004 | CSV | 13.4424 | 13.5688 | 0.00171241 | 0.00172851 | 0.721964 | 0.698608 | 3601.07
CSV | 5323.58 | 23363 | 22272.1 | +5.122 | +5.506 | C28 | C28 | 3 | 3004 | CSV | 13.7034 | 13.8326 | 0.00174566 | 0.00176211 | 0.735964 | 0.712188 | 3671.07
CSV | 4961.18 | 20719.9 | 25239.2 | +4.760 | +5.143 | C29 | C29 | 3 | 3004 | CSV | 13.6661 | 13.7949 | 0.00174091 | 0.00175731 | 0.733964 | 0.710248 | 3661.07
CSV | 5321.99 | 20748.6 | 22285.2 | +5.122 | +5.503 | C36 | C36 | 3 | 3004 | CSV | 13.5729 | 13.7007 | 0.00172903 | 0.00174531 | 0.728964 | 0.705398 | 3636.07
CSV | 4958.46 | 18281.3 | 25261.5 | +4.756 | +5.141 | C24 | C24 | 3 | 3004 | CSV | 13.0521 | 13.1744 | 0.00166268 | 0.00167826 | 0.701027 | 0.678298 | 3496.38
CSV | 4961.77 | 15920.7 | 25234.4 | +4.763 | +5.141 | C30 | C30 | 3 | 3004 | CSV | 12.791 | 12.9106 | 0.00162943 | 0.00164466 | 0.687027 | 0.664718 | 3426.38
CSV | 5321.58 | 15877.4 | 22288.5 | +5.120 | +5.504 | C24 | C24 | 3 | 3004 | CSV | 13.0521 | 13.1744 | 0.00166268 | 0.00167826 | 0.701027 | 0.678298 | 3496.38
CSV | 5320.4 | 18294.7 | 22298.2 | +5.120 | +5.502 | C35 | C35 | 3 | 3004 | CSV | 12.9588 | 13.0802 | 0.00165081 | 0.00166626 | 0.696027 | 0.673448 | 3471.38
CSV | 4961.77 | 13539.3 | 25234.4 | +4.763 | +5.141 | C30 | C30 | 3 | 3004 | CSV | 12.791 | 12.9106 | 0.00162943 | 0.00164466 | 0.687027 | 0.664718 | 3426.38
CSV | 5321.58 | 11157.4 | 22288.5 | +5.120 | +5.504 | C24 | C24 | 3 | 3004 | CSV | 13.0521 | 13.1744 | 0.00166268 | 0.00167826 | 0.701027 | 0.678298 | 3496.38
CSV | 4961.77 | 11200.7 | 25234.4 | +4.763 | +5.141 | C30 | C30 | 3 | 3004 | CSV | 12.791 | 12.9106 | 0.00162943 | 0.00164466 | 0.687027 | 0.664718 | 3426.38
CSV | 5321.58 | 13582.6 | 22288.5 | +5.120 | +5.504 | C24 | C24 | 3 | 3004 | CSV | 13.0521 | 13.1744 | 0.00166268 | 0.00167826 | 0.701027 | 0.678298 | 3496.38
CSV | 4961.77 | 8819.35 | 25234.4 | +4.763 | +5.141 | C30 | C30 | 3 | 3004 | CSV | 12.791 | 12.9106 | 0.00162943 | 0.00164466 | 0.687027 | 0.664718 | 3426.38
CSV | 4961.72 | 6385.32 | 25234.8 | +4.762 | +5.142 | C23 | C23 | 3 | 3004 | CSV | 13.3196 | 13.4447 | 0.00169676 | 0.0017127 | 0.715376 | 0.692218 | 3568.13
CSV | 5321.58 | 8862.56 | 22288.5 | +5.120 | +5.504 | C24 | C24 | 3 | 3004 | CSV | 13.0521 | 13.1744 | 0.00166268 | 0.00167826 | 0.701027 | 0.678298 | 3496.38
CSV | 5321.43 | 6341.75 | 22289.8 | +5.118 | +5.505 | C22 | C22 | 3 | 3004 | CSV | 13.5806 | 13.7085 | 0.00173001 | 0.0017463 | 0.729376 | 0.705798 | 3638.13
CSV | 4643.8 | 3814.68 | 28140.2 | +4.463 | +4.844 | C54 | C54 | 3 | 3004 | CSV | 13.3196 | 13.4447 | 0.00169676 | 0.0017127 | 0.715376 | 0.692218 | 3568.13
CSV | 4607.39 | 3814.68 | 28135.8 | +4.409 | +4.786 | C54 | C54 | 3 | 3004 | CSV | 13.3196 | 13.4447 | 0.00169676 | 0.0017127 | 0.715376 | 0.692218 | 3568.13
CSV | 4961.72 | 3814.68 | 25234.8 | +4.762 | +5.142 | C54 | C54 | 3 | 3004 | CSV | 13.3196 | 13.4447 | 0.00169676 | 0.0017127 | 0.715376 | 0.692218 | 3568.13
CSV | 4998.13 | 3814.68 | 25239.2 | +4.819 | +5.196 | C54 | C54 | 3 | 3004 | CSV | 13.3196 | 13.4447 | 0.00169676 | 0.0017127 | 0.715376 | 0.692218 | 3568.13
CSV | 4247.69 | 3858.25 | 31080.8 | +4.046 | +4.430 | C22 | C22 | 3 | 3004 | CSV | 13.5806 | 13.7085 | 0.00173001 | 0.0017463 | 0.729376 | 0.705798 | 3638.13
CSV | 4607.39 | 1285.32 | 28135.8 | +4.409 | +4.786 | C23 | C23 | 3 | 3004 | CSV | 13.3196 | 13.4447 | 0.00169676 | 0.0017127 | 0.715376 | 0.692218 | 3568.13
CSV | 4287.3 | 1264.68 | 31059 | +4.107 | +4.487 | C70 | C70 | 3 | 3004 | CSV | 13.3196 | 13.4447 | 0.00169676 | 0.0017127 | 0.715376 | 0.692218 | 3568.13
CSV | 4250.89 | 1264.68 | 31054.5 | +4.053 | +4.430 | C70 | C70 | 3 | 3004 | CSV | 13.3196 | 13.4447 | 0.00169676 | 0.0017127 | 0.715376 | 0.692218 | 3568.13
CSV | 3568.73 | 18746.5 | 77260.1 | +3.482 | +3.635 | C41 | C41 | 1 | 1009 | CSV | 14.2482 | 14.3831 | 0.00181505 | 0.00183224 | 0.765183 | 0.74053 | 3817.16
CSV | 3681.42 | 20829.8 | 73625.1 | +3.595 | +3.747 | C41 | C41 | 1 | 1009 | CSV | 14.2482 | 14.3831 | 0.00181505 | 0.00183224 | 0.765182 | 0.740529 | 3817.16
CSV | 3568.73 | 20853.5 | 77260.1 | +3.482 | +3.635 | C41 | C41 | 1 | 1009 | CSV | 14.2482 | 14.3831 | 0.00181505 | 0.00183224 | 0.765183 | 0.74053 | 3817.16
CSV | 3681.42 | 18770.2 | 73625.1 | +3.595 | +3.747 | C41 | C41 | 1 | 1009 | CSV | 14.2482 | 14.3831 | 0.00181505 | 0.00183224 | 0.765182 | 0.740529 | 3817.16
CSV | 3568.73 | 14579.8 | 77260.1 | +3.482 | +3.635 | C41 | C41 | 1 | 1009 | CSV | 14.2482 | 14.3831 | 0.00181505 | 0.00183224 | 0.765183 | 0.74053 | 3817.16
CSV | 3681.42 | 16663.1 | 73625.1 | +3.595 | +3.747 | C41 | C41 | 1 | 1009 | CSV | 14.2482 | 14.3831 | 0.00181505 | 0.00183224 | 0.765182 | 0.740529 | 3817.16
CSV | 3568.73 | 22913.1 | 77260.1 | +3.482 | +3.635 | C41 | C41 | 1 | 1009 | CSV | 14.2482 | 14.3831 | 0.00181505 | 0.00183224 | 0.765183 | 0.74053 | 3817.16
CSV | 5361.81 | 59776.2 | 68961.7 | +5.176 | +5.567 | C59 | C59 | 1 | 1004 | CSV | 13.8526 | 13.9833 | 0.00176466 | 0.00178131 | 0.743964 | 0.719948 | 3711.07
CSV | 4998.12 | 59739.8 | 71939.3 | +4.819 | +5.196 | C58 | C58 | 1 | 1004 | CSV | 13.4424 | 13.5688 | 0.00171241 | 0.00172851 | 0.721964 | 0.698608 | 3601.07
CSV | 4998.12 | 57160.2 | 71939.3 | +4.819 | +5.196 | C58 | C58 | 1 | 1004 | CSV | 13.4424 | 13.5688 | 0.00171241 | 0.00172851 | 0.721964 | 0.698608 | 3601.07
CSV | 5359.99 | 57137 | 68976.6 | +5.176 | +5.563 | C57 | C57 | 1 | 1004 | CSV | 13.7034 | 13.8326 | 0.00174566 | 0.00176211 | 0.735964 | 0.712188 | 3671.07
CSV | 5358.4 | 41548.6 | 68989.6 | +5.176 | +5.560 | C60 | C60 | 1 | 1004 | CSV | 13.5729 | 13.7007 | 0.00172903 | 0.00174531 | 0.728964 | 0.705398 | 3636.07
CSV | 4998.12 | 44139.8 | 71939.3 | +4.819 | +5.196 | C58 | C58 | 1 | 1004 | CSV | 13.4424 | 13.5688 | 0.00171241 | 0.00172851 | 0.721964 | 0.698608 | 3601.07
CSV | 4998.12 | 41560.2 | 71939.3 | +4.819 | +5.196 | C58 | C58 | 1 | 1004 | CSV | 13.4424 | 13.5688 | 0.00171241 | 0.00172851 | 0.721964 | 0.698608 | 3601.07
CSV | 5359.99 | 44163 | 68976.6 | +5.176 | +5.563 | C57 | C57 | 1 | 1004 | CSV | 13.7034 | 13.8326 | 0.00174566 | 0.00176211 | 0.735964 | 0.712188 | 3671.07
CSV | 5358.4 | 38951.4 | 68989.6 | +5.176 | +5.560 | C60 | C60 | 1 | 1004 | CSV | 13.5729 | 13.7007 | 0.00172903 | 0.00174531 | 0.728964 | 0.705398 | 3636.07
CSV | 4998.12 | 38939.8 | 71939.3 | +4.819 | +5.196 | C58 | C58 | 1 | 1004 | CSV | 13.4424 | 13.5688 | 0.00171241 | 0.00172851 | 0.721964 | 0.698608 | 3601.07
CSV | 4998.12 | 36360.2 | 71939.3 | +4.819 | +5.196 | C58 | C58 | 1 | 1004 | CSV | 13.4424 | 13.5688 | 0.00171241 | 0.00172851 | 0.721964 | 0.698608 | 3601.07
CSV | 5359.99 | 36337 | 68976.6 | +5.176 | +5.563 | C57 | C57 | 1 | 1004 | CSV | 13.7034 | 13.8326 | 0.00174566 | 0.00176211 | 0.735964 | 0.712188 | 3671.07
CSV | 5321.99 | 38951.4 | 68985.2 | +5.122 | +5.503 | C60 | C60 | 1 | 1004 | CSV | 13.5729 | 13.7007 | 0.00172903 | 0.00174531 | 0.728964 | 0.705398 | 3636.07
CSV | 4961.71 | 36360.2 | 71934.9 | +4.761 | +5.143 | C58 | C58 | 1 | 1004 | CSV | 13.4424 | 13.5688 | 0.00171241 | 0.00172851 | 0.721964 | 0.698608 | 3601.07
CSV | 5323.58 | 36337 | 68972.1 | +5.122 | +5.506 | C57 | C57 | 1 | 1004 | CSV | 13.7034 | 13.8326 | 0.00174566 | 0.00176211 | 0.735964 | 0.712188 | 3671.07
CSV | 4961.71 | 41560.2 | 71934.9 | +4.761 | +5.143 | C58 | C58 | 1 | 1004 | CSV | 13.4424 | 13.5688 | 0.00171241 | 0.00172851 | 0.721964 | 0.698608 | 3601.07
CSV | 4961.71 | 44139.8 | 71934.9 | +4.761 | +5.143 | C58 | C58 | 1 | 1004 | CSV | 13.4424 | 13.5688 | 0.00171241 | 0.00172851 | 0.721964 | 0.698608 | 3601.07
CSV | 5323.58 | 44163 | 68972.1 | +5.122 | +5.506 | C57 | C57 | 1 | 1004 | CSV | 13.7034 | 13.8326 | 0.00174566 | 0.00176211 | 0.735964 | 0.712188 | 3671.07
CSV | 4961.71 | 38939.8 | 71934.9 | +4.761 | +5.143 | C58 | C58 | 1 | 1004 | CSV | 13.4424 | 13.5688 | 0.00171241 | 0.00172851 | 0.721964 | 0.698608 | 3601.07
CSV | 5321.99 | 41548.6 | 68985.2 | +5.122 | +5.503 | C60 | C60 | 1 | 1004 | CSV | 13.5729 | 13.7007 | 0.00172903 | 0.00174531 | 0.728964 | 0.705398 | 3636.07
CSV | 4961.71 | 49339.8 | 71934.9 | +4.761 | +5.143 | C25 | C25 | 1 | 1004 | CSV | 13.4424 | 13.5688 | 0.00171241 | 0.00172851 | 0.721964 | 0.698608 | 3601.07
CSV | 5323.58 | 49363 | 68972.1 | +5.122 | +5.506 | C28 | C28 | 1 | 1004 | CSV | 13.7034 | 13.8326 | 0.00174566 | 0.00176211 | 0.735964 | 0.712188 | 3671.07
CSV | 4961.71 | 46760.2 | 71934.9 | +4.761 | +5.143 | C25 | C25 | 1 | 1004 | CSV | 13.4424 | 13.5688 | 0.00171241 | 0.00172851 | 0.721964 | 0.698608 | 3601.07
CSV | 5323.58 | 46737 | 68972.1 | +5.122 | +5.506 | C28 | C28 | 1 | 1004 | CSV | 13.7034 | 13.8326 | 0.00174566 | 0.00176211 | 0.735964 | 0.712188 | 3671.07
CSV | 4961.71 | 54539.8 | 71934.9 | +4.761 | +5.143 | C25 | C25 | 1 | 1004 | CSV | 13.4424 | 13.5688 | 0.00171241 | 0.00172851 | 0.721964 | 0.698608 | 3601.07
CSV | 5323.58 | 54563 | 68972.1 | +5.122 | +5.506 | C28 | C28 | 1 | 1004 | CSV | 13.7034 | 13.8326 | 0.00174566 | 0.00176211 | 0.735964 | 0.712188 | 3671.07
CSV | 4961.71 | 51960.2 | 71934.9 | +4.761 | +5.143 | C25 | C25 | 1 | 1004 | CSV | 13.4424 | 13.5688 | 0.00171241 | 0.00172851 | 0.721964 | 0.698608 | 3601.07
CSV | 5323.58 | 51937 | 68972.1 | +5.122 | +5.506 | C28 | C28 | 1 | 1004 | CSV | 13.7034 | 13.8326 | 0.00174566 | 0.00176211 | 0.735964 | 0.712188 | 3671.07
CSV | 4961.71 | 59739.8 | 71934.9 | +4.761 | +5.143 | C58 | C58 | 1 | 1004 | CSV | 13.4424 | 13.5688 | 0.00171241 | 0.00172851 | 0.721964 | 0.698608 | 3601.07
CSV | 5306.83 | 49338.4 | 34084.3 | +5.122 | +5.473 | C39 | C39 | 3 | 3004 | CSV | 12.8167 | 12.9365 | 0.00163269 | 0.00164796 | 0.688401 | 0.666051 | 3433.25
CSV | 5323.58 | 46737 | 33947.1 | +5.122 | +5.506 | C28 | C28 | 3 | 3004 | CSV | 13.7034 | 13.8326 | 0.00174566 | 0.00176211 | 0.735964 | 0.712188 | 3671.07
CSV | 5323.58 | 44163 | 33947.1 | +5.122 | +5.506 | C28 | C28 | 3 | 3004 | CSV | 13.7034 | 13.8326 | 0.00174566 | 0.00176211 | 0.735964 | 0.712188 | 3671.07
CSV | 5321.99 | 41548.6 | 33960.2 | +5.122 | +5.503 | C36 | C36 | 3 | 3004 | CSV | 13.5729 | 13.7007 | 0.00172903 | 0.00174531 | 0.728964 | 0.705398 | 3636.07
CSV | 4961.18 | 41519.9 | 36914.2 | +4.760 | +5.143 | C29 | C29 | 3 | 3004 | CSV | 13.6661 | 13.7949 | 0.00174091 | 0.00175731 | 0.733964 | 0.710248 | 3661.07
CSV | 4961.71 | 44139.8 | 36909.9 | +4.761 | +5.143 | C25 | C25 | 3 | 3004 | CSV | 13.4424 | 13.5688 | 0.00171241 | 0.00172851 | 0.721964 | 0.698608 | 3601.07
CSV | 4961.71 | 46760.2 | 36909.9 | +4.761 | +5.143 | C25 | C25 | 3 | 3004 | CSV | 13.4424 | 13.5688 | 0.00171241 | 0.00172851 | 0.721964 | 0.698608 | 3601.07
CSV | 4961.94 | 49338.1 | 36908 | +4.762 | +5.143 | C38 | C38 | 3 | 3004 | CSV | 13.4238 | 13.55 | 0.00171003 | 0.00172611 | 0.720964 | 0.697638 | 3596.07
CSV | 5321.99 | 20748.6 | 33960.2 | +5.122 | +5.503 | C36 | C36 | 3 | 3004 | CSV | 13.5729 | 13.7007 | 0.00172903 | 0.00174531 | 0.728964 | 0.705398 | 3636.07
CSV | 5321.99 | 38951.4 | 33960.2 | +5.122 | +5.503 | C36 | C36 | 3 | 3004 | CSV | 13.5729 | 13.7007 | 0.00172903 | 0.00174531 | 0.728964 | 0.705398 | 3636.07
CSV | 5323.58 | 36337 | 33947.1 | +5.122 | +5.506 | C28 | C28 | 3 | 3004 | CSV | 13.7034 | 13.8326 | 0.00174566 | 0.00176211 | 0.735964 | 0.712188 | 3671.07
CSV | 5323.58 | 33763 | 33947.1 | +5.122 | +5.506 | C28 | C28 | 3 | 3004 | CSV | 13.7034 | 13.8326 | 0.00174566 | 0.00176211 | 0.735964 | 0.712188 | 3671.07
CSV | 5323.58 | 31137 | 33947.1 | +5.122 | +5.506 | C28 | C28 | 3 | 3004 | CSV | 13.7034 | 13.8326 | 0.00174566 | 0.00176211 | 0.735964 | 0.712188 | 3671.07
CSV | 5323.58 | 28563 | 33947.1 | +5.122 | +5.506 | C28 | C28 | 3 | 3004 | CSV | 13.7034 | 13.8326 | 0.00174566 | 0.00176211 | 0.735964 | 0.712188 | 3671.07
CSV | 4958.99 | 38959.6 | 36932.2 | +4.756 | +5.143 | C29 | C29 | 3 | 3004 | CSV | 13.6661 | 13.7949 | 0.00174091 | 0.00175731 | 0.733964 | 0.710248 | 3661.07
CSV | 4961.71 | 36360.2 | 36909.9 | +4.761 | +5.143 | C25 | C25 | 3 | 3004 | CSV | 13.4424 | 13.5688 | 0.00171241 | 0.00172851 | 0.721964 | 0.698608 | 3601.07
CSV | 5430.58 | 26585.4 | 68096.1 | +5.333 | +5.510 | C90 | C90 | 1 | 1009 | CSV | 5.99636 | 6.0444 | 0.000763867 | 0.000769988 | 0.322578 | 0.311203 | 1604.14
CSV | 5166.35 | 26559.8 | 70259.5 | +5.079 | +5.235 | C88 | C88 | 1 | 1009 | CSV | 5.42452 | 5.46655 | 0.000691022 | 0.000696376 | 0.291907 | 0.281452 | 1450.78
CSV | 5090.41 | 25323.8 | 71183.7 | +5.020 | +5.180 | C88 | C88 | 1 | 1009 | CSV | 5.42452 | 5.46655 | 0.000691022 | 0.000696376 | 0.291907 | 0.281452 | 1450.78
CSV | 5055 | 1290.22 | 73616.4 | +4.963 | +5.126 | C9 | C9 | 1 | 1009 | CSV | 16.3026 | 16.4591 | 0.00207676 | 0.0020967 | 0.875377 | 0.847418 | 4368.13
CSV | 5054.37 | 1259.78 | 73636.9 | +4.963 | +5.125 | C8 | C8 | 1 | 1009 | CSV | 16.3026 | 16.4591 | 0.00207676 | 0.0020967 | 0.875377 | 0.847418 | 4368.13
CSV | 5023.6 | 8835.32 | 70675.9 | +4.959 | +5.068 | C13 | C13 | 1 | 1009 | CSV | 10.6839 | 10.7813 | 0.001361 | 0.00137341 | 0.574003 | 0.555086 | 2861.27
CSV | 5060.27 | 8835.32 | 70677 | +5.016 | +5.126 | C13 | C13 | 1 | 1009 | CSV | 10.6839 | 10.7813 | 0.001361 | 0.00137341 | 0.574003 | 0.555086 | 2861.27
CSV | 5321.99 | 38951.4 | 57310.2 | +5.122 | +5.503 | C36 | C36 | 1 | 1004 | CSV | 13.5729 | 13.7007 | 0.00172903 | 0.00174531 | 0.728964 | 0.705398 | 3636.07
CSV | 5323.58 | 54563 | 57297.1 | +5.122 | +5.506 | C28 | C28 | 1 | 1004 | CSV | 13.7034 | 13.8326 | 0.00174566 | 0.00176211 | 0.735964 | 0.712188 | 3671.07
CSV | 5323.58 | 57137 | 57297.1 | +5.122 | +5.506 | C28 | C28 | 1 | 1004 | CSV | 13.7034 | 13.8326 | 0.00174566 | 0.00176211 | 0.735964 | 0.712188 | 3671.07
CSV | 5323.58 | 46737 | 57297.1 | +5.122 | +5.506 | C28 | C28 | 1 | 1004 | CSV | 13.7034 | 13.8326 | 0.00174566 | 0.00176211 | 0.735964 | 0.712188 | 3671.07
CSV | 4961.18 | 41519.9 | 60264.2 | +4.760 | +5.143 | C29 | C29 | 1 | 1004 | CSV | 13.6661 | 13.7949 | 0.00174091 | 0.00175731 | 0.733964 | 0.710248 | 3661.07
CSV | 4961.71 | 44139.8 | 60259.9 | +4.761 | +5.143 | C25 | C25 | 1 | 1004 | CSV | 13.4424 | 13.5688 | 0.00171241 | 0.00172851 | 0.721964 | 0.698608 | 3601.07
CSV | 5323.58 | 36337 | 57297.1 | +5.122 | +5.506 | C28 | C28 | 1 | 1004 | CSV | 13.7034 | 13.8326 | 0.00174566 | 0.00176211 | 0.735964 | 0.712188 | 3671.07
CSV | 5323.58 | 33763 | 57297.1 | +5.122 | +5.506 | C28 | C28 | 1 | 1004 | CSV | 13.7034 | 13.8326 | 0.00174566 | 0.00176211 | 0.735964 | 0.712188 | 3671.07
CSV | 4958.99 | 38959.6 | 60282.2 | +4.756 | +5.143 | C29 | C29 | 1 | 1004 | CSV | 13.6661 | 13.7949 | 0.00174091 | 0.00175731 | 0.733964 | 0.710248 | 3661.07
CSV | 5323.58 | 49363 | 57297.1 | +5.122 | +5.506 | C28 | C28 | 1 | 1004 | CSV | 13.7034 | 13.8326 | 0.00174566 | 0.00176211 | 0.735964 | 0.712188 | 3671.07
CSV | 5323.58 | 51937 | 57297.1 | +5.122 | +5.506 | C28 | C28 | 1 | 1004 | CSV | 13.7034 | 13.8326 | 0.00174566 | 0.00176211 | 0.735964 | 0.712188 | 3671.07
CSV | 4961.71 | 31160.2 | 60259.9 | +4.761 | +5.143 | C25 | C25 | 1 | 1004 | CSV | 13.4424 | 13.5688 | 0.00171241 | 0.00172851 | 0.721964 | 0.698608 | 3601.07
CSV | 5323.58 | 31137 | 57297.1 | +5.122 | +5.506 | C28 | C28 | 1 | 1004 | CSV | 13.7034 | 13.8326 | 0.00174566 | 0.00176211 | 0.735964 | 0.712188 | 3671.07
CSV | 3598.13 | 30918.3 | 3495.28 | +3.525 | +3.651 | C71 | C71 | 2 | 2004 | CSV | 12.1542 | 12.267 | 0.0015483 | 0.00156268 | 0.652867 | 0.631583 | 3255.58
CSV | 3634.79 | 30918.3 | 3496.56 | +3.583 | +3.708 | C71 | C71 | 2 | 2004 | CSV | 12.1542 | 12.267 | 0.0015483 | 0.00156268 | 0.652867 | 0.631583 | 3255.58
CSV | 5323.58 | 23363 | 33947.1 | +5.122 | +5.506 | C28 | C28 | 3 | 3004 | CSV | 13.7034 | 13.8326 | 0.00174566 | 0.00176211 | 0.735964 | 0.712188 | 3671.07
CSV | 4961.71 | 23339.8 | 36909.9 | +4.761 | +5.143 | C25 | C25 | 3 | 3004 | CSV | 13.4424 | 13.5688 | 0.00171241 | 0.00172851 | 0.721964 | 0.698608 | 3601.07
CSV | 4961.71 | 28539.8 | 48584.9 | +4.761 | +5.143 | C25 | C25 | 1 | 1004 | CSV | 13.4424 | 13.5688 | 0.00171241 | 0.00172851 | 0.721964 | 0.698608 | 3601.07
CSV | 4961.72 | 3814.68 | 36909.8 | +4.762 | +5.142 | C54 | C54 | 3 | 3004 | CSV | 13.3196 | 13.4447 | 0.00169676 | 0.0017127 | 0.715376 | 0.692218 | 3568.13
CSV | 4247.69 | 1241.75 | 42755.8 | +4.046 | +4.430 | C55 | C55 | 3 | 3004 | CSV | 13.5806 | 13.7085 | 0.00173001 | 0.0017463 | 0.729376 | 0.705798 | 3638.13
CSV | 4284.1 | 1241.75 | 42760.2 | +4.100 | +4.487 | C55 | C55 | 3 | 3004 | CSV | 13.5806 | 13.7085 | 0.00173001 | 0.0017463 | 0.729376 | 0.705798 | 3638.13
CSV | 5323.58 | 36337 | 45622.1 | +5.122 | +5.506 | C28 | C28 | 1 | 1004 | CSV | 13.7034 | 13.8326 | 0.00174566 | 0.00176211 | 0.735964 | 0.712188 | 3671.07
CSV | 5323.58 | 31137 | 45622.1 | +5.122 | +5.506 | C28 | C28 | 1 | 1004 | CSV | 13.7034 | 13.8326 | 0.00174566 | 0.00176211 | 0.735964 | 0.712188 | 3671.07
CSV | 4961.18 | 41519.9 | 48589.2 | +4.760 | +5.143 | C29 | C29 | 1 | 1004 | CSV | 13.6661 | 13.7949 | 0.00174091 | 0.00175731 | 0.733964 | 0.710248 | 3661.07
CSV | 4961.71 | 57160.2 | 48584.9 | +4.761 | +5.143 | C25 | C25 | 1 | 1004 | CSV | 13.4424 | 13.5688 | 0.00171241 | 0.00172851 | 0.721964 | 0.698608 | 3601.07
CSV | 4961.71 | 31160.2 | 48584.9 | +4.761 | +5.143 | C25 | C25 | 1 | 1004 | CSV | 13.4424 | 13.5688 | 0.00171241 | 0.00172851 | 0.721964 | 0.698608 | 3601.07
CSV | 5356.47 | 1251.58 | 33980.5 | +5.176 | +5.557 | C56 | C56 | 3 | 3004 | CSV | 13.4687 | 13.5954 | 0.00171576 | 0.0017319 | 0.723376 | 0.699978 | 3608.13
CSV | 4607.39 | 3814.68 | 39810.8 | +4.409 | +4.786 | C54 | C54 | 3 | 3004 | CSV | 13.3196 | 13.4447 | 0.00169676 | 0.0017127 | 0.715376 | 0.692218 | 3568.13
CSV | 4643.8 | 3814.68 | 39815.2 | +4.463 | +4.844 | C54 | C54 | 3 | 3004 | CSV | 13.3196 | 13.4447 | 0.00169676 | 0.0017127 | 0.715376 | 0.692218 | 3568.13
CSV | 4961.72 | 1285.32 | 36909.8 | +4.762 | +5.142 | C23 | C23 | 3 | 3004 | CSV | 13.3196 | 13.4447 | 0.00169676 | 0.0017127 | 0.715376 | 0.692218 | 3568.13
CSV | 5321.43 | 3858.25 | 33964.8 | +5.118 | +5.505 | C22 | C22 | 3 | 3004 | CSV | 13.5806 | 13.7085 | 0.00173001 | 0.0017463 | 0.729376 | 0.705798 | 3638.13
CSV | 5321.43 | 6341.75 | 33964.8 | +5.118 | +5.505 | C22 | C22 | 3 | 3004 | CSV | 13.5806 | 13.7085 | 0.00173001 | 0.0017463 | 0.729376 | 0.705798 | 3638.13
CSV | 4961.72 | 6385.32 | 36909.8 | +4.762 | +5.142 | C23 | C23 | 3 | 3004 | CSV | 13.3196 | 13.4447 | 0.00169676 | 0.0017127 | 0.715376 | 0.692218 | 3568.13
CSV | 4607.39 | 1285.32 | 39810.8 | +4.409 | +4.786 | C23 | C23 | 3 | 3004 | CSV | 13.3196 | 13.4447 | 0.00169676 | 0.0017127 | 0.715376 | 0.692218 | 3568.13
CSV | 4247.69 | 3858.25 | 42755.8 | +4.046 | +4.430 | C22 | C22 | 3 | 3004 | CSV | 13.5806 | 13.7085 | 0.00173001 | 0.0017463 | 0.729376 | 0.705798 | 3638.13
CSV | 4961.77 | 8819.35 | 36909.4 | +4.763 | +5.141 | C30 | C30 | 3 | 3004 | CSV | 12.791 | 12.9106 | 0.00162943 | 0.00164466 | 0.687027 | 0.664718 | 3426.38
CSV | 4961.77 | 11200.7 | 36909.4 | +4.763 | +5.141 | C30 | C30 | 3 | 3004 | CSV | 12.791 | 12.9106 | 0.00162943 | 0.00164466 | 0.687027 | 0.664718 | 3426.38
CSV | 5321.58 | 11157.4 | 33963.5 | +5.120 | +5.504 | C24 | C24 | 3 | 3004 | CSV | 13.0521 | 13.1744 | 0.00166268 | 0.00167826 | 0.701027 | 0.678298 | 3496.38
CSV | 5321.58 | 8862.56 | 33963.5 | +5.120 | +5.504 | C24 | C24 | 3 | 3004 | CSV | 13.0521 | 13.1744 | 0.00166268 | 0.00167826 | 0.701027 | 0.678298 | 3496.38
CSV | 5323.58 | 28563 | 45622.1 | +5.122 | +5.506 | C28 | C28 | 1 | 1004 | CSV | 13.7034 | 13.8326 | 0.00174566 | 0.00176211 | 0.735964 | 0.712188 | 3671.07
CSV | 5323.58 | 33763 | 45622.1 | +5.122 | +5.506 | C28 | C28 | 1 | 1004 | CSV | 13.7034 | 13.8326 | 0.00174566 | 0.00176211 | 0.735964 | 0.712188 | 3671.07
CSV | 4961.71 | 51960.2 | 48584.9 | +4.761 | +5.143 | C25 | C25 | 1 | 1004 | CSV | 13.4424 | 13.5688 | 0.00171241 | 0.00172851 | 0.721964 | 0.698608 | 3601.07
CSV | 4958.46 | 18281.3 | 48611.5 | +4.756 | +5.141 | C24 | C24 | 1 | 1004 | CSV | 13.0521 | 13.1744 | 0.00166268 | 0.00167826 | 0.701027 | 0.678298 | 3496.38
CSV | 4923.9 | 67809.4 | 36947.3 | +4.732 | +5.097 | C44 | C44 | 3 | 3004 | CSV | 13.3669 | 13.4926 | 0.00170279 | 0.0017188 | 0.717916 | 0.694681 | 3580.83
CSV | 4961.71 | 33739.8 | 48584.9 | +4.761 | +5.143 | C25 | C25 | 1 | 1004 | CSV | 13.4424 | 13.5688 | 0.00171241 | 0.00172851 | 0.721964 | 0.698608 | 3601.07
CSV | 4961.71 | 36360.2 | 48584.9 | +4.761 | +5.143 | C25 | C25 | 1 | 1004 | CSV | 13.4424 | 13.5688 | 0.00171241 | 0.00172851 | 0.721964 | 0.698608 | 3601.07
CSV | 4958.99 | 38959.6 | 48607.2 | +4.756 | +5.143 | C29 | C29 | 1 | 1004 | CSV | 13.6661 | 13.7949 | 0.00174091 | 0.00175731 | 0.733964 | 0.710248 | 3661.07
CSV | 4961.71 | 59739.8 | 48584.9 | +4.761 | +5.143 | C25 | C25 | 1 | 1004 | CSV | 13.4424 | 13.5688 | 0.00171241 | 0.00172851 | 0.721964 | 0.698608 | 3601.07
CSV | 4961.71 | 28539.8 | 36909.9 | +4.761 | +5.143 | C25 | C25 | 3 | 3004 | CSV | 13.4424 | 13.5688 | 0.00171241 | 0.00172851 | 0.721964 | 0.698608 | 3601.07
CSV | 4961.18 | 20719.9 | 36914.2 | +4.760 | +5.143 | C29 | C29 | 3 | 3004 | CSV | 13.6661 | 13.7949 | 0.00174091 | 0.00175731 | 0.733964 | 0.710248 | 3661.07
CSV | 4961.71 | 54539.8 | 48584.9 | +4.761 | +5.143 | C25 | C25 | 1 | 1004 | CSV | 13.4424 | 13.5688 | 0.00171241 | 0.00172851 | 0.721964 | 0.698608 | 3601.07
CSV | 5323.58 | 25937 | 33947.1 | +5.122 | +5.506 | C28 | C28 | 3 | 3004 | CSV | 13.7034 | 13.8326 | 0.00174566 | 0.00176211 | 0.735964 | 0.712188 | 3671.07
CSV | 5321.99 | 20748.6 | 45635.2 | +5.122 | +5.503 | C36 | C36 | 1 | 1004 | CSV | 13.5729 | 13.7007 | 0.00172903 | 0.00174531 | 0.728964 | 0.705398 | 3636.07
CSV | 4961.71 | 25960.2 | 36909.9 | +4.761 | +5.143 | C25 | C25 | 3 | 3004 | CSV | 13.4424 | 13.5688 | 0.00171241 | 0.00172851 | 0.721964 | 0.698608 | 3601.07
CSV | 4961.71 | 49339.8 | 48584.9 | +4.761 | +5.143 | C25 | C25 | 1 | 1004 | CSV | 13.4424 | 13.5688 | 0.00171241 | 0.00172851 | 0.721964 | 0.698608 | 3601.07
CSV | 4961.71 | 44139.8 | 48584.9 | +4.761 | +5.143 | C25 | C25 | 1 | 1004 | CSV | 13.4424 | 13.5688 | 0.00171241 | 0.00172851 | 0.721964 | 0.698608 | 3601.07
CSV | 5321.99 | 38951.4 | 45635.2 | +5.122 | +5.503 | C36 | C36 | 1 | 1004 | CSV | 13.5729 | 13.7007 | 0.00172903 | 0.00174531 | 0.728964 | 0.705398 | 3636.07
CSV | 4998.13 | 3814.68 | 36914.2 | +4.819 | +5.196 | C54 | C54 | 3 | 3004 | CSV | 13.3196 | 13.4447 | 0.00169676 | 0.0017127 | 0.715376 | 0.692218 | 3568.13
CSV | 5320.05 | 1251.58 | 33976 | +5.118 | +5.503 | C56 | C56 | 3 | 3004 | CSV | 13.4687 | 13.5954 | 0.00171576 | 0.0017319 | 0.723376 | 0.699978 | 3608.13
CSV | 5323.58 | 54563 | 45622.1 | +5.122 | +5.506 | C28 | C28 | 1 | 1004 | CSV | 13.7034 | 13.8326 | 0.00174566 | 0.00176211 | 0.735964 | 0.712188 | 3671.07
CSV | 5323.58 | 49363 | 45622.1 | +5.122 | +5.506 | C28 | C28 | 1 | 1004 | CSV | 13.7034 | 13.8326 | 0.00174566 | 0.00176211 | 0.735964 | 0.712188 | 3671.07
CSV | 5323.58 | 51937 | 45622.1 | +5.122 | +5.506 | C28 | C28 | 1 | 1004 | CSV | 13.7034 | 13.8326 | 0.00174566 | 0.00176211 | 0.735964 | 0.712188 | 3671.07
CSV | 4961.71 | 46760.2 | 48584.9 | +4.761 | +5.143 | C25 | C25 | 1 | 1004 | CSV | 13.4424 | 13.5688 | 0.00171241 | 0.00172851 | 0.721964 | 0.698608 | 3601.07
CSV | 5321.99 | 41548.6 | 45635.2 | +5.122 | +5.503 | C36 | C36 | 1 | 1004 | CSV | 13.5729 | 13.7007 | 0.00172903 | 0.00174531 | 0.728964 | 0.705398 | 3636.07
CSV | 5323.58 | 44163 | 45622.1 | +5.122 | +5.506 | C28 | C28 | 1 | 1004 | CSV | 13.7034 | 13.8326 | 0.00174566 | 0.00176211 | 0.735964 | 0.712188 | 3671.07
CSV | 5323.58 | 46737 | 45622.1 | +5.122 | +5.506 | C28 | C28 | 1 | 1004 | CSV | 13.7034 | 13.8326 | 0.00174566 | 0.00176211 | 0.735964 | 0.712188 | 3671.07
CSV | 5323.58 | 57137 | 45622.1 | +5.122 | +5.506 | C28 | C28 | 1 | 1004 | CSV | 13.7034 | 13.8326 | 0.00174566 | 0.00176211 | 0.735964 | 0.712188 | 3671.07
CSV | 5325.4 | 59776.2 | 45607.3 | +5.122 | +5.510 | C37 | C37 | 1 | 1004 | CSV | 13.8526 | 13.9833 | 0.00176466 | 0.00178131 | 0.743964 | 0.719948 | 3711.07
STABILITE | 853.71 | 9130.03 | 79243.3 | -0.354 | +2.078 | V2 | V2 | 1 | 1002 | STABILITE | 13.7191 | 13.8484 | 0.00174765 | 0.00176413 | 0.736803 | 0.713002 | 3675.27
STABILITE | 853.707 | 9130.03 | 79207.2 | -0.354 | +2.078 | V2 | V2 | 1 | 1002 | STABILITE | 13.7191 | 13.8484 | 0.00174765 | 0.00176413 | 0.736803 | 0.713002 | 3675.27
STABILITE | 3403.34 | 9093.38 | 79243.3 | +2.176 | +4.647 | V3 | V3 | 1 | 1002 | STABILITE | 13.9428 | 14.0745 | 0.00177615 | 0.00179293 | 0.748803 | 0.724642 | 3735.27
STABILITE | 3403.34 | 9093.38 | 79207.2 | +2.176 | +4.647 | V3 | V3 | 1 | 1002 | STABILITE | 13.9428 | 14.0745 | 0.00177615 | 0.00179293 | 0.748803 | 0.724642 | 3735.27
STABILITE | 853.707 | 12070 | 79242.8 | -0.354 | +2.078 | V2 | V2 | 1 | 1002 | STABILITE | 13.7191 | 13.8484 | 0.00174765 | 0.00176413 | 0.736803 | 0.713002 | 3675.27
CSV | 4961.77 | 15920.7 | 48584.4 | +4.763 | +5.141 | C30 | C30 | 1 | 1004 | CSV | 12.791 | 12.9106 | 0.00162943 | 0.00164466 | 0.687027 | 0.664718 | 3426.38
CSV | 5321.58 | 13582.6 | 45638.5 | +5.120 | +5.504 | C24 | C24 | 1 | 1004 | CSV | 13.0521 | 13.1744 | 0.00166268 | 0.00167826 | 0.701027 | 0.678298 | 3496.38
CSV | 4961.77 | 13539.3 | 48584.4 | +4.763 | +5.141 | C30 | C30 | 1 | 1004 | CSV | 12.791 | 12.9106 | 0.00162943 | 0.00164466 | 0.687027 | 0.664718 | 3426.38
CSV | 4607.39 | 1285.32 | 51485.8 | +4.409 | +4.786 | C23 | C23 | 1 | 1004 | CSV | 13.3196 | 13.4447 | 0.00169676 | 0.0017127 | 0.715376 | 0.692218 | 3568.13
CSV | 4247.69 | 3858.25 | 54430.8 | +4.046 | +4.430 | C22 | C22 | 1 | 1004 | CSV | 13.5806 | 13.7085 | 0.00173001 | 0.0017463 | 0.729376 | 0.705798 | 3638.13
CSV | 4961.71 | 23339.8 | 48584.9 | +4.761 | +5.143 | C25 | C25 | 1 | 1004 | CSV | 13.4424 | 13.5688 | 0.00171241 | 0.00172851 | 0.721964 | 0.698608 | 3601.07
CSV | 5321.58 | 11157.4 | 45638.5 | +5.120 | +5.504 | C24 | C24 | 1 | 1004 | CSV | 13.0521 | 13.1744 | 0.00166268 | 0.00167826 | 0.701027 | 0.678298 | 3496.38
CSV | 4607.43 | 67789.9 | 51485.5 | +4.409 | +4.787 | C27 | C27 | 1 | 1004 | CSV | 13.692 | 13.8211 | 0.00174421 | 0.00176065 | 0.735353 | 0.711595 | 3668.02
CSV | 4247.8 | 65066.3 | 54429.8 | +4.046 | +4.430 | C26 | C26 | 1 | 1004 | CSV | 13.953 | 14.0848 | 0.00177746 | 0.00179425 | 0.749353 | 0.725175 | 3738.02
CSV | 5323.55 | 67813.6 | 45622.4 | +5.122 | +5.506 | C26 | C26 | 1 | 1004 | CSV | 13.953 | 14.0848 | 0.00177746 | 0.00179425 | 0.749353 | 0.725175 | 3738.02
CSV | 4963.93 | 65089.9 | 48566.7 | +4.765 | +5.143 | C27 | C27 | 1 | 1004 | CSV | 13.692 | 13.8211 | 0.00174421 | 0.00176065 | 0.735353 | 0.711595 | 3668.02
CSV | 5323.58 | 25937 | 45622.1 | +5.122 | +5.506 | C28 | C28 | 1 | 1004 | CSV | 13.7034 | 13.8326 | 0.00174566 | 0.00176211 | 0.735964 | 0.712188 | 3671.07
CSV | 5140.37 | 62412.4 | 47122.2 | +4.776 | +5.484 | C96 | C96 | 1 | 1004 | CSV | 22.1901 | 22.4086 | 0.00282676 | 0.00285459 | 1.19116 | 1.15373 | 5947.07
CSV | 4961.77 | 8819.35 | 48584.4 | +4.763 | +5.141 | C30 | C30 | 1 | 1004 | CSV | 12.791 | 12.9106 | 0.00162943 | 0.00164466 | 0.687027 | 0.664718 | 3426.38
CSV | 4961.77 | 11200.7 | 48584.4 | +4.763 | +5.141 | C30 | C30 | 1 | 1004 | CSV | 12.791 | 12.9106 | 0.00162943 | 0.00164466 | 0.687027 | 0.664718 | 3426.38
CSV | 4643.8 | 3814.68 | 51490.2 | +4.463 | +4.844 | C54 | C54 | 1 | 1004 | CSV | 13.3196 | 13.4447 | 0.00169676 | 0.0017127 | 0.715376 | 0.692218 | 3568.13
CSV | 4961.72 | 1285.32 | 48584.8 | +4.762 | +5.142 | C23 | C23 | 1 | 1004 | CSV | 13.3196 | 13.4447 | 0.00169676 | 0.0017127 | 0.715376 | 0.692218 | 3568.13
CSV | 4961.72 | 3814.68 | 48584.8 | +4.762 | +5.142 | C54 | C54 | 1 | 1004 | CSV | 13.3196 | 13.4447 | 0.00169676 | 0.0017127 | 0.715376 | 0.692218 | 3568.13
CSV | 4247.69 | 1241.75 | 54430.8 | +4.046 | +4.430 | C55 | C55 | 1 | 1004 | CSV | 13.5806 | 13.7085 | 0.00173001 | 0.0017463 | 0.729376 | 0.705798 | 3638.13
CSV | 5357.84 | 1241.75 | 45644.2 | +5.176 | +5.559 | C55 | C55 | 1 | 1004 | CSV | 13.5806 | 13.7085 | 0.00173001 | 0.0017463 | 0.729376 | 0.705798 | 3638.13
CSV | 5320.4 | 18294.7 | 45648.2 | +5.120 | +5.502 | C35 | C35 | 1 | 1004 | CSV | 12.9588 | 13.0802 | 0.00165081 | 0.00166626 | 0.696027 | 0.673448 | 3471.38
CSV | 4284.1 | 1241.75 | 54435.2 | +4.100 | +4.487 | C55 | C55 | 1 | 1004 | CSV | 13.5806 | 13.7085 | 0.00173001 | 0.0017463 | 0.729376 | 0.705798 | 3638.13
CSV | 4607.39 | 3814.68 | 51485.8 | +4.409 | +4.786 | C54 | C54 | 1 | 1004 | CSV | 13.3196 | 13.4447 | 0.00169676 | 0.0017127 | 0.715376 | 0.692218 | 3568.13
CSV | 4961.18 | 20719.9 | 48589.2 | +4.760 | +5.143 | C29 | C29 | 1 | 1004 | CSV | 13.6661 | 13.7949 | 0.00174091 | 0.00175731 | 0.733964 | 0.710248 | 3661.07
CSV | 5323.58 | 23363 | 45622.1 | +5.122 | +5.506 | C28 | C28 | 1 | 1004 | CSV | 13.7034 | 13.8326 | 0.00174566 | 0.00176211 | 0.735964 | 0.712188 | 3671.07
CSV | 4607.43 | 65110.1 | 51485.5 | +4.409 | +4.787 | C27 | C27 | 1 | 1004 | CSV | 13.692 | 13.8211 | 0.00174421 | 0.00176065 | 0.735353 | 0.711595 | 3668.02
CSV | 4247.8 | 67833.7 | 54429.8 | +4.046 | +4.430 | C26 | C26 | 1 | 1004 | CSV | 13.953 | 14.0848 | 0.00177746 | 0.00179425 | 0.749353 | 0.725175 | 3738.02
CSV | 5321.58 | 8862.56 | 45638.5 | +5.120 | +5.504 | C24 | C24 | 1 | 1004 | CSV | 13.0521 | 13.1744 | 0.00166268 | 0.00167826 | 0.701027 | 0.678298 | 3496.38
CSV | 4961.72 | 6385.32 | 48584.8 | +4.762 | +5.142 | C23 | C23 | 1 | 1004 | CSV | 13.3196 | 13.4447 | 0.00169676 | 0.0017127 | 0.715376 | 0.692218 | 3568.13
CSV | 5188.08 | 62374.9 | 47034.1 | +4.834 | +5.562 | C95 | C95 | 1 | 1004 | CSV | 22.8613 | 23.0868 | 0.00291226 | 0.002941 | 1.22717 | 1.18865 | 6127.08
CSV | 4961.71 | 25960.2 | 48584.9 | +4.761 | +5.143 | C25 | C25 | 1 | 1004 | CSV | 13.4424 | 13.5688 | 0.00171241 | 0.00172851 | 0.721964 | 0.698608 | 3601.07
CSV | 5323.55 | 65086.4 | 45622.4 | +5.122 | +5.506 | C26 | C26 | 1 | 1004 | CSV | 13.953 | 14.0848 | 0.00177746 | 0.00179425 | 0.749353 | 0.725175 | 3738.02
CSV | 4963.93 | 67810.1 | 48566.7 | +4.765 | +5.143 | C27 | C27 | 1 | 1004 | CSV | 13.692 | 13.8211 | 0.00174421 | 0.00176065 | 0.735353 | 0.711595 | 3668.02
CSV | 5321.43 | 3858.25 | 45639.8 | +5.118 | +5.505 | C22 | C22 | 1 | 1004 | CSV | 13.5806 | 13.7085 | 0.00173001 | 0.0017463 | 0.729376 | 0.705798 | 3638.13
CSV | 5321.43 | 6341.75 | 45639.8 | +5.118 | +5.505 | C22 | C22 | 1 | 1004 | CSV | 13.5806 | 13.7085 | 0.00173001 | 0.0017463 | 0.729376 | 0.705798 | 3638.13
CSV | 5321.43 | 1241.75 | 45639.8 | +5.118 | +5.505 | C55 | C55 | 1 | 1004 | CSV | 13.5806 | 13.7085 | 0.00173001 | 0.0017463 | 0.729376 | 0.705798 | 3638.13
CSV | 4998.13 | 3814.68 | 48589.2 | +4.819 | +5.196 | C54 | C54 | 1 | 1004 | CSV | 13.3196 | 13.4447 | 0.00169676 | 0.0017127 | 0.715376 | 0.692218 | 3568.13
CSV | 5321.58 | 15877.4 | 45638.5 | +5.120 | +5.504 | C24 | C24 | 1 | 1004 | CSV | 13.0521 | 13.1744 | 0.00166268 | 0.00167826 | 0.701027 | 0.678298 | 3496.38
CSV | 4247.69 | 3858.25 | 66105.8 | +4.046 | +4.430 | C22 | C22 | 1 | 1004 | CSV | 13.5806 | 13.7085 | 0.00173001 | 0.0017463 | 0.729376 | 0.705798 | 3638.13
CSV | 4607.39 | 1285.32 | 63160.8 | +4.409 | +4.786 | C23 | C23 | 1 | 1004 | CSV | 13.3196 | 13.4447 | 0.00169676 | 0.0017127 | 0.715376 | 0.692218 | 3568.13
CSV | 4961.72 | 6385.32 | 60259.8 | +4.762 | +5.142 | C23 | C23 | 1 | 1004 | CSV | 13.3196 | 13.4447 | 0.00169676 | 0.0017127 | 0.715376 | 0.692218 | 3568.13
CSV | 5321.58 | 8862.56 | 57313.5 | +5.120 | +5.504 | C24 | C24 | 1 | 1004 | CSV | 13.0521 | 13.1744 | 0.00166268 | 0.00167826 | 0.701027 | 0.678298 | 3496.38
CSV | 5321.58 | 11157.4 | 57313.5 | +5.120 | +5.504 | C24 | C24 | 1 | 1004 | CSV | 13.0521 | 13.1744 | 0.00166268 | 0.00167826 | 0.701027 | 0.678298 | 3496.38
CSV | 4961.77 | 13539.3 | 60259.4 | +4.763 | +5.141 | C30 | C30 | 1 | 1004 | CSV | 12.791 | 12.9106 | 0.00162943 | 0.00164466 | 0.687027 | 0.664718 | 3426.38
CSV | 4961.77 | 15920.7 | 60259.4 | +4.763 | +5.141 | C30 | C30 | 1 | 1004 | CSV | 12.791 | 12.9106 | 0.00162943 | 0.00164466 | 0.687027 | 0.664718 | 3426.38
CSV | 5320.4 | 18294.7 | 57323.2 | +5.120 | +5.502 | C35 | C35 | 1 | 1004 | CSV | 12.9588 | 13.0802 | 0.00165081 | 0.00166626 | 0.696027 | 0.673448 | 3471.38
CSV | 5321.99 | 20748.6 | 57310.2 | +5.122 | +5.503 | C36 | C36 | 1 | 1004 | CSV | 13.5729 | 13.7007 | 0.00172903 | 0.00174531 | 0.728964 | 0.705398 | 3636.07
CSV | 4961.71 | 23339.8 | 60259.9 | +4.761 | +5.143 | C25 | C25 | 1 | 1004 | CSV | 13.4424 | 13.5688 | 0.00171241 | 0.00172851 | 0.721964 | 0.698608 | 3601.07
CSV | 4961.71 | 25960.2 | 60259.9 | +4.761 | +5.143 | C25 | C25 | 1 | 1004 | CSV | 13.4424 | 13.5688 | 0.00171241 | 0.00172851 | 0.721964 | 0.698608 | 3601.07
CSV | 4961.71 | 46760.2 | 60259.9 | +4.761 | +5.143 | C25 | C25 | 1 | 1004 | CSV | 13.4424 | 13.5688 | 0.00171241 | 0.00172851 | 0.721964 | 0.698608 | 3601.07
CSV | 4961.71 | 59739.8 | 60259.9 | +4.761 | +5.143 | C25 | C25 | 1 | 1004 | CSV | 13.4424 | 13.5688 | 0.00171241 | 0.00172851 | 0.721964 | 0.698608 | 3601.07
CSV | 4961.71 | 51960.2 | 60259.9 | +4.761 | +5.143 | C25 | C25 | 1 | 1004 | CSV | 13.4424 | 13.5688 | 0.00171241 | 0.00172851 | 0.721964 | 0.698608 | 3601.07
CSV | 5321.99 | 41548.6 | 57310.2 | +5.122 | +5.503 | C36 | C36 | 1 | 1004 | CSV | 13.5729 | 13.7007 | 0.00172903 | 0.00174531 | 0.728964 | 0.705398 | 3636.07
CSV | 5188.08 | 62374.9 | 58709.1 | +4.834 | +5.562 | C95 | C95 | 1 | 1004 | CSV | 22.8613 | 23.0868 | 0.00291226 | 0.002941 | 1.22717 | 1.18865 | 6127.08
CSV | 4247.8 | 65066.3 | 66104.8 | +4.046 | +4.430 | C26 | C26 | 1 | 1004 | CSV | 13.953 | 14.0848 | 0.00177746 | 0.00179425 | 0.749353 | 0.725175 | 3738.02
CSV | 4607.43 | 67789.9 | 63160.5 | +4.409 | +4.787 | C27 | C27 | 1 | 1004 | CSV | 13.692 | 13.8211 | 0.00174421 | 0.00176065 | 0.735353 | 0.711595 | 3668.02
CSV | 4247.8 | 67833.7 | 66104.8 | +4.046 | +4.430 | C26 | C26 | 1 | 1004 | CSV | 13.953 | 14.0848 | 0.00177746 | 0.00179425 | 0.749353 | 0.725175 | 3738.02
CSV | 4607.43 | 65110.1 | 63160.5 | +4.409 | +4.787 | C27 | C27 | 1 | 1004 | CSV | 13.692 | 13.8211 | 0.00174421 | 0.00176065 | 0.735353 | 0.711595 | 3668.02
CSV | 4963.93 | 65089.9 | 60241.7 | +4.765 | +5.143 | C27 | C27 | 1 | 1004 | CSV | 13.692 | 13.8211 | 0.00174421 | 0.00176065 | 0.735353 | 0.711595 | 3668.02
CSV | 5323.55 | 67813.6 | 57297.4 | +5.122 | +5.506 | C26 | C26 | 1 | 1004 | CSV | 13.953 | 14.0848 | 0.00177746 | 0.00179425 | 0.749353 | 0.725175 | 3738.02
CSV | 4963.93 | 67810.1 | 60241.7 | +4.765 | +5.143 | C27 | C27 | 1 | 1004 | CSV | 13.692 | 13.8211 | 0.00174421 | 0.00176065 | 0.735353 | 0.711595 | 3668.02
CSV | 5323.55 | 65086.4 | 57297.4 | +5.122 | +5.506 | C26 | C26 | 1 | 1004 | CSV | 13.953 | 14.0848 | 0.00177746 | 0.00179425 | 0.749353 | 0.725175 | 3738.02
CSV | 5140.37 | 62412.4 | 58797.2 | +4.776 | +5.484 | C96 | C96 | 1 | 1004 | CSV | 22.1901 | 22.4086 | 0.00282676 | 0.00285459 | 1.19116 | 1.15373 | 5947.07
