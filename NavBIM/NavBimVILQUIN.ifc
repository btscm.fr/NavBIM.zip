Properties of the parts of a building model (IFC2X3), part 6 of 32

# IfcBeam: L60*6 (913)
Name | Material | Center of gravity Z (mm) | Center of gravity Y (mm) | Center of gravity X (mm) | Bottom elevation | Top elevation | Part mark | Assembly mark | Phase | Class | Finish | Grade | Name | Net weight (kg) = NetWeight (kg) | Gross weight (kg) = Weight (kg) | Net volume (m3) = NetVolume (m3) | Gross volume (m3) | Gross footprint area (m2) | Net surface area (m2) | Gross area (m2) = OuterSurfaceArea (m2) | Tekla Quantity, Length (mm) = BaseQuantities, Length (mm)
ATTACHE | STEEL/E24-2 | 5411.44 | -47 | 79204.7 | +5.369 | +5.429 | H12 | H12 | 1 | 1003 | GRENAILLE-PEINT | E24-2 | ATTACHE | 0.53694 | 0.542435 | 0.0000684 | 0.0000691 | 0.006 | 0.025368 | 0.0233 | 100
ATTACHE | STEEL/E24-2 | 5782.79 | -47 | 79204.7 | +5.740 | +5.800 | H12 | H12 | 1 | 1003 | GRENAILLE-PEINT | E24-2 | ATTACHE | 0.53694 | 0.542435 | 0.0000684 | 0.0000691 | 0.006 | 0.025368 | 0.0233 | 100
ATTACHE | STEEL/E24-2 | 5416.61 | 89.2105 | 79175 | +5.374 | +5.434 | H11 | H11 | 1 | 1003 | GRENAILLE-PEINT | E24-2 | ATTACHE | 1.28866 | 1.30184 | 0.00016416 | 0.00016584 | 0.0144 | 0.058968 | 0.05592 | 240
 | STEEL/E24-2 | 5153.5 | 54.7896 | 32407.2 | +4.417 | +5.890 | 436 | P113 | 3 | 3001 | GRENAILLE-PEINT | E24-2 |  | 7.90913 | 7.99007 | 0.00100753 | 0.00101784 | 0.000684 | 0.354888 | 0.343209 | 1473
 | STEEL/E24-2 | 5153.5 | 21918.7 | 44082.2 | +4.417 | +5.890 | 436 | N10 | 1 | 1006 | GRENAILLE-PEINT | E24-2 |  | 7.90913 | 7.99007 | 0.00100753 | 0.00101784 | 0.000684 | 0.354888 | 0.343209 | 1473
 | STEEL/E24-2 | 5667.21 | 27415.7 | 44095 | +5.650 | +5.710 | 442 | N10 | 1 | 1006 | GRENAILLE-PEINT | E24-2 |  | 0.26847 | 0.271218 | 0.0000342 | 0.00003455 | 0.0003 | 0.013368 | 0.01165 | 50
 | STEEL/E24-2 | 5667.21 | 29684.3 | 44095 | +5.650 | +5.710 | 442 | N8 | 1 | 1006 | GRENAILLE-PEINT | E24-2 |  | 0.26847 | 0.271218 | 0.0000342 | 0.00003455 | 0.0003 | 0.013368 | 0.01165 | 50
 | STEEL/E24-2 | 4712.79 | 27415.7 | 44095 | +4.670 | +4.730 | 442 | N10 | 1 | 1006 | GRENAILLE-PEINT | E24-2 |  | 0.26847 | 0.271218 | 0.0000342 | 0.00003455 | 0.003 | 0.013368 | 0.01165 | 50
 | STEEL/E24-2 | 4712.79 | 21884.3 | 44095 | +4.670 | +4.730 | 442 | N10 | 1 | 1006 | GRENAILLE-PEINT | E24-2 |  | 0.26847 | 0.271218 | 0.0000342 | 0.00003455 | 0.003 | 0.013368 | 0.01165 | 50
 | STEEL/E24-2 | 5153.5 | 45318.7 | 55757.2 | +4.417 | +5.890 | 436 | N41 | 1 | 1006 | GRENAILLE-PEINT | E24-2 |  | 7.90913 | 7.99007 | 0.00100753 | 0.00101784 | 0.000684 | 0.354888 | 0.343209 | 1473
 | STEEL/E24-2 | 4712.79 | 21884.3 | 32420 | +4.670 | +4.730 | 441 | N9 | 3 | 3006 | GRENAILLE-PEINT | E24-2 |  | 0.26847 | 0.271218 | 0.0000342 | 0.00003455 | 0.003 | 0.013368 | 0.01165 | 50
 | STEEL/E24-2 | 4712.79 | 19615.7 | 32420 | +4.670 | +4.730 | 441 | P32 | 3 | 3001 | GRENAILLE-PEINT | E24-2 |  | 0.26847 | 0.271218 | 0.0000342 | 0.00003455 | 0.003 | 0.013368 | 0.01165 | 50
 | STEEL/E24-2 | 5667.21 | 19615.7 | 32420 | +5.650 | +5.710 | 441 | P32 | 3 | 3001 | GRENAILLE-PEINT | E24-2 |  | 0.26847 | 0.271218 | 0.0000342 | 0.00003455 | 0.0003 | 0.013368 | 0.01165 | 50
 | STEEL/E24-2 | 5153.5 | 14598.7 | 32407.2 | +4.417 | +5.890 | 436 | N48 | 3 | 3006 | GRENAILLE-PEINT | E24-2 |  | 7.90913 | 7.99007 | 0.00100753 | 0.00101784 | 0.000684 | 0.354888 | 0.343209 | 1473
 | STEEL/E24-2 | 5667.21 | 29684.3 | 32420 | +5.650 | +5.710 | 441 | N40 | 3 | 3006 | GRENAILLE-PEINT | E24-2 |  | 0.26847 | 0.271218 | 0.0000342 | 0.00003455 | 0.0003 | 0.013368 | 0.01165 | 50
 | STEEL/E24-2 | 5667.21 | 27415.7 | 32420 | +5.650 | +5.710 | 441 | N9 | 3 | 3006 | GRENAILLE-PEINT | E24-2 |  | 0.26847 | 0.271218 | 0.0000342 | 0.00003455 | 0.0003 | 0.013368 | 0.01165 | 50
 | STEEL/E24-2 | 4712.79 | 29684.3 | 32420 | +4.670 | +4.730 | 441 | N40 | 3 | 3006 | GRENAILLE-PEINT | E24-2 |  | 0.26847 | 0.271218 | 0.0000342 | 0.00003455 | 0.003 | 0.013368 | 0.01165 | 50
 | STEEL/E24-2 | 4712.79 | 27415.7 | 32420 | +4.670 | +4.730 | 441 | N9 | 3 | 3006 | GRENAILLE-PEINT | E24-2 |  | 0.26847 | 0.271218 | 0.0000342 | 0.00003455 | 0.003 | 0.013368 | 0.01165 | 50
ATTACHE | STEEL/S235JR | 5833 | 19517.2 | 71669.2 | +5.720 | +5.946 | H23 | H23 | 1 | 1008 | GALVANISE | S235JR | ATTACHE | 1.21348 | 1.2259 | 0.000154584 | 0.000156166 | 0.000684 | 0.055608 | 0.052658 | 226
ATTACHE | STEEL/S235JR | 5833 | 20767.2 | 71669.2 | +5.720 | +5.946 | H29 | H29 | 1 | 1008 | GALVANISE | S235JR | ATTACHE | 1.21348 | 1.2259 | 0.000154584 | 0.000156166 | 0.000684 | 0.055608 | 0.052658 | 226
 | STEEL/E24-2 | 4712.79 | 40072.8 | 20745 | +4.670 | +4.730 | 441 | P30 | 2 | 2001 | GRENAILLE-PEINT | E24-2 |  | 0.26847 | 0.271218 | 0.0000342 | 0.00003455 | 0.003 | 0.013368 | 0.01165 | 50
 | STEEL/E24-2 | 4712.79 | 37815.7 | 20745 | +4.670 | +4.730 | 441 | N44 | 2 | 2006 | GRENAILLE-PEINT | E24-2 |  | 0.26847 | 0.271218 | 0.0000342 | 0.00003455 | 0.003 | 0.013368 | 0.01165 | 50
 | STEEL/E24-2 | 5667.21 | 37815.7 | 20745 | +5.650 | +5.710 | 441 | N44 | 2 | 2006 | GRENAILLE-PEINT | E24-2 |  | 0.26847 | 0.271218 | 0.0000342 | 0.00003455 | 0.0003 | 0.013368 | 0.01165 | 50
 | STEEL/E24-2 | 4712.79 | 29684.3 | 20745 | +4.670 | +4.730 | 441 | N44 | 2 | 2006 | GRENAILLE-PEINT | E24-2 |  | 0.26847 | 0.271218 | 0.0000342 | 0.00003455 | 0.003 | 0.013368 | 0.01165 | 50
 | STEEL/E24-2 | 4712.79 | 27415.7 | 20745 | +4.670 | +4.730 | 441 | N45 | 2 | 2006 | GRENAILLE-PEINT | E24-2 |  | 0.26847 | 0.271218 | 0.0000342 | 0.00003455 | 0.003 | 0.013368 | 0.01165 | 50
 | STEEL/E24-2 | 5667.21 | 27415.7 | 20745 | +5.650 | +5.710 | 441 | N45 | 2 | 2006 | GRENAILLE-PEINT | E24-2 |  | 0.26847 | 0.271218 | 0.0000342 | 0.00003455 | 0.0003 | 0.013368 | 0.01165 | 50
 | STEEL/E24-2 | 5667.21 | 29684.3 | 20745 | +5.650 | +5.710 | 441 | N44 | 2 | 2006 | GRENAILLE-PEINT | E24-2 |  | 0.26847 | 0.271218 | 0.0000342 | 0.00003455 | 0.0003 | 0.013368 | 0.01165 | 50
LISSE | STEEL/S235JR | 4954.96 | 13541.8 | 71950.2 | +4.096 | +5.814 | L12 | L12 | 1 | 1003 | GRENAILLE-PEINT | S235JR | LISSE | 9.22495 | 9.31936 | 0.00117515 | 0.00118718 | 0.000684 | 0.413702 | 0.400308 | 1718.06
 | STEEL/E24-2 | 5153.5 | 2418.71 | 44082.2 | +4.417 | +5.890 | 436 | N16 | 1 | 1006 | GRENAILLE-PEINT | E24-2 |  | 7.90913 | 7.99007 | 0.00100753 | 0.00101784 | 0.000684 | 0.354888 | 0.343209 | 1473
 | STEEL/E24-2 | 5153.5 | 24518.7 | 44082.2 | +4.417 | +5.890 | 436 | N10 | 1 | 1006 | GRENAILLE-PEINT | E24-2 |  | 7.90913 | 7.99007 | 0.00100753 | 0.00101784 | 0.000684 | 0.354888 | 0.343209 | 1473
 | STEEL/E24-2 | 5153.5 | 32581.3 | 44082.2 | +4.417 | +5.890 | 436 | N8 | 1 | 1006 | GRENAILLE-PEINT | E24-2 |  | 7.90913 | 7.99007 | 0.00100753 | 0.00101784 | 0.000684 | 0.354888 | 0.343209 | 1473
 | STEEL/E24-2 | 5153.5 | 17221.3 | 44082.2 | +4.417 | +5.890 | 436 | N47 | 1 | 1006 | GRENAILLE-PEINT | E24-2 |  | 7.90913 | 7.99007 | 0.00100753 | 0.00101784 | 0.000684 | 0.354888 | 0.343209 | 1473
 | STEEL/E24-2 | 5153.5 | 4968.71 | 44082.2 | +4.417 | +5.890 | 436 | N16 | 1 | 1006 | GRENAILLE-PEINT | E24-2 |  | 7.90913 | 7.99007 | 0.00100753 | 0.00101784 | 0.000684 | 0.354888 | 0.343209 | 1473
STABILITE | STEEL/E24-2 | 605.088 | 42337.8 | -21.2105 | -0.379 | +1.612 | V1 | V1 | 2 | 2002 | GRENAILLE-PEINT | E24-2 | STABILITE | 23.702 | 23.9229 | 0.00301936 | 0.0030475 | 0 | 1.06079 | 1.02759 | 4410.27
STABILITE | STEEL/E24-2 | 2611.93 | 46448.4 | -21.2105 | +1.628 | +3.619 | V1 | V1 | 2 | 2002 | GRENAILLE-PEINT | E24-2 | STABILITE | 23.702 | 23.9229 | 0.00301936 | 0.0030475 | 0 | 1.06079 | 1.02759 | 4410.27
STABILITE | STEEL/E24-2 | 2611.93 | 42326.6 | -21.2105 | +1.628 | +3.619 | V1 | V1 | 2 | 2002 | GRENAILLE-PEINT | E24-2 | STABILITE | 23.702 | 23.9229 | 0.00301936 | 0.0030475 | 0 | 1.06079 | 1.02759 | 4410.27
STABILITE | STEEL/E24-2 | 605.088 | 46437.2 | -21.2105 | -0.379 | +1.612 | V1 | V1 | 2 | 2002 | GRENAILLE-PEINT | E24-2 | STABILITE | 23.702 | 23.9229 | 0.00301936 | 0.0030475 | 0 | 1.06079 | 1.02759 | 4410.27
 | STEEL/E24-2 | 5153.5 | 45581.3 | 32407.2 | +4.417 | +5.890 | 436 | N43 | 3 | 3003 | GRENAILLE-PEINT | E24-2 |  | 7.90913 | 7.99007 | 0.00100753 | 0.00101784 | 0.000684 | 0.354888 | 0.343209 | 1473
 | STEEL/E24-2 | 5667.21 | 19615.7 | 44095 | +5.650 | +5.710 | 442 | P36 | 1 | 1001 | GRENAILLE-PEINT | E24-2 |  | 0.26847 | 0.271218 | 0.0000342 | 0.00003455 | 0.0003 | 0.013368 | 0.01165 | 50
 | STEEL/E24-2 | 5153.5 | 47918.7 | 67432.2 | +4.417 | +5.890 | 436 | N6 | 1 | 1006 | GRENAILLE-PEINT | E24-2 |  | 7.90913 | 7.99007 | 0.00100753 | 0.00101784 | 0.000684 | 0.354888 | 0.343209 | 1473
 | STEEL/E24-2 | 5153.5 | 45581.3 | 67432.2 | +4.417 | +5.890 | 436 | N6 | 1 | 1006 | GRENAILLE-PEINT | E24-2 |  | 7.90913 | 7.99007 | 0.00100753 | 0.00101784 | 0.000684 | 0.354888 | 0.343209 | 1473
 | STEEL/E24-2 | 5153.5 | 58318.7 | 67432.2 | +4.417 | +5.890 | 436 | N13 | 1 | 1006 | GRENAILLE-PEINT | E24-2 |  | 7.90913 | 7.99007 | 0.00100753 | 0.00101784 | 0.000684 | 0.354888 | 0.343209 | 1473
 | STEEL/E24-2 | 5153.5 | 66318.7 | 67432.2 | +4.417 | +5.890 | 436 | N17 | 1 | 1006 | GRENAILLE-PEINT | E24-2 |  | 7.90913 | 7.99007 | 0.00100753 | 0.00101784 | 0.000684 | 0.354888 | 0.343209 | 1473
 | STEEL/E24-2 | 5153.5 | 42981.3 | 67432.2 | +4.417 | +5.890 | 436 | N6 | 1 | 1006 | GRENAILLE-PEINT | E24-2 |  | 7.90913 | 7.99007 | 0.00100753 | 0.00101784 | 0.000684 | 0.354888 | 0.343209 | 1473
 | STEEL/E24-2 | 5153.5 | 37781.3 | 67432.2 | +4.417 | +5.890 | 436 | N7 | 1 | 1006 | GRENAILLE-PEINT | E24-2 |  | 7.90913 | 7.99007 | 0.00100753 | 0.00101784 | 0.000684 | 0.354888 | 0.343209 | 1473
 | STEEL/E24-2 | 5153.5 | 55718.7 | 67432.2 | +4.417 | +5.890 | 436 | N13 | 1 | 1006 | GRENAILLE-PEINT | E24-2 |  | 7.90913 | 7.99007 | 0.00100753 | 0.00101784 | 0.000684 | 0.354888 | 0.343209 | 1473
 | STEEL/E24-2 | 5153.5 | 63881.3 | 67432.2 | +4.417 | +5.890 | 436 | N17 | 1 | 1006 | GRENAILLE-PEINT | E24-2 |  | 7.90913 | 7.99007 | 0.00100753 | 0.00101784 | 0.000684 | 0.354888 | 0.343209 | 1473
 | STEEL/E24-2 | 5153.5 | 50518.7 | 67432.2 | +4.417 | +5.890 | 436 | N6 | 1 | 1006 | GRENAILLE-PEINT | E24-2 |  | 7.90913 | 7.99007 | 0.00100753 | 0.00101784 | 0.000684 | 0.354888 | 0.343209 | 1473
 | STEEL/E24-2 | 5153.5 | 53381.3 | 67432.2 | +4.417 | +5.890 | 436 | N13 | 1 | 1006 | GRENAILLE-PEINT | E24-2 |  | 7.90913 | 7.99007 | 0.00100753 | 0.00101784 | 0.000684 | 0.354888 | 0.343209 | 1473
 | STEEL/E24-2 | 5153.5 | 10141.3 | 44082.2 | +4.417 | +5.890 | 436 | N47 | 1 | 1006 | GRENAILLE-PEINT | E24-2 |  | 7.90913 | 7.99007 | 0.00100753 | 0.00101784 | 0.000684 | 0.354888 | 0.343209 | 1473
 | STEEL/E24-2 | 5153.5 | 12501.3 | 44082.2 | +4.417 | +5.890 | 436 | N47 | 1 | 1006 | GRENAILLE-PEINT | E24-2 |  | 7.90913 | 7.99007 | 0.00100753 | 0.00101784 | 0.000684 | 0.354888 | 0.343209 | 1473
 | STEEL/E24-2 | 5153.5 | 14598.7 | 44082.2 | +4.417 | +5.890 | 436 | N47 | 1 | 1006 | GRENAILLE-PEINT | E24-2 |  | 7.90913 | 7.99007 | 0.00100753 | 0.00101784 | 0.000684 | 0.354888 | 0.343209 | 1473
 | STEEL/E24-2 | 5153.5 | 34918.7 | 44082.2 | +4.417 | +5.890 | 436 | N8 | 1 | 1006 | GRENAILLE-PEINT | E24-2 |  | 7.90913 | 7.99007 | 0.00100753 | 0.00101784 | 0.000684 | 0.354888 | 0.343209 | 1473
 | STEEL/E24-2 | 5153.5 | 27381.3 | 44082.2 | +4.417 | +5.890 | 436 | N10 | 1 | 1006 | GRENAILLE-PEINT | E24-2 |  | 7.90913 | 7.99007 | 0.00100753 | 0.00101784 | 0.000684 | 0.354888 | 0.343209 | 1473
 | STEEL/E24-2 | 5153.5 | 37781.3 | 44082.2 | +4.417 | +5.890 | 436 | N8 | 1 | 1006 | GRENAILLE-PEINT | E24-2 |  | 7.90913 | 7.99007 | 0.00100753 | 0.00101784 | 0.000684 | 0.354888 | 0.343209 | 1473
 | STEEL/E24-2 | 5575.79 | 61268.5 | 44142.2 | +5.533 | +5.593 | 440 | N39 | 1 | 1006 | GRENAILLE-PEINT | E24-2 |  | 0.26847 | 0.271218 | 0.0000342 | 0.00003455 | 0.003 | 0.013368 | 0.01165 | 50
 | STEEL/E24-2 | 5153.5 | 47918.7 | 44082.2 | +4.417 | +5.890 | 436 | N41 | 1 | 1006 | GRENAILLE-PEINT | E24-2 |  | 7.90913 | 7.99007 | 0.00100753 | 0.00101784 | 0.000684 | 0.354888 | 0.343209 | 1473
 | STEEL/E24-2 | 5153.5 | 45318.7 | 44082.2 | +4.417 | +5.890 | 436 | N41 | 1 | 1006 | GRENAILLE-PEINT | E24-2 |  | 7.90913 | 7.99007 | 0.00100753 | 0.00101784 | 0.000684 | 0.354888 | 0.343209 | 1473
 | STEEL/E24-2 | 5153.5 | 42981.3 | 44082.2 | +4.417 | +5.890 | 436 | N41 | 1 | 1006 | GRENAILLE-PEINT | E24-2 |  | 7.90913 | 7.99007 | 0.00100753 | 0.00101784 | 0.000684 | 0.354888 | 0.343209 | 1473
 | STEEL/E24-2 | 5153.5 | 53381.3 | 44082.2 | +4.417 | +5.890 | 436 | N42 | 1 | 1006 | GRENAILLE-PEINT | E24-2 |  | 7.90913 | 7.99007 | 0.00100753 | 0.00101784 | 0.000684 | 0.354888 | 0.343209 | 1473
 | STEEL/E24-2 | 5153.5 | 55718.7 | 44082.2 | +4.417 | +5.890 | 436 | N42 | 1 | 1006 | GRENAILLE-PEINT | E24-2 |  | 7.90913 | 7.99007 | 0.00100753 | 0.00101784 | 0.000684 | 0.354888 | 0.343209 | 1473
 | STEEL/E24-2 | 5153.5 | 50518.7 | 44082.2 | +4.417 | +5.890 | 436 | N41 | 1 | 1006 | GRENAILLE-PEINT | E24-2 |  | 7.90913 | 7.99007 | 0.00100753 | 0.00101784 | 0.000684 | 0.354888 | 0.343209 | 1473
 | STEEL/E24-2 | 5153.5 | 58318.7 | 44082.2 | +4.417 | +5.890 | 436 | N42 | 1 | 1006 | GRENAILLE-PEINT | E24-2 |  | 7.90913 | 7.99007 | 0.00100753 | 0.00101784 | 0.000684 | 0.354888 | 0.343209 | 1473
 | STEEL/E24-2 | 5153.5 | 66318.7 | 44082.2 | +4.417 | +5.890 | 436 | N39 | 1 | 1006 | GRENAILLE-PEINT | E24-2 |  | 7.90913 | 7.99007 | 0.00100753 | 0.00101784 | 0.000684 | 0.354888 | 0.343209 | 1473
 | STEEL/E24-2 | 4254.21 | 61268.5 | 44142.2 | +4.237 | +4.297 | 440 | N39 | 1 | 1006 | GRENAILLE-PEINT | E24-2 |  | 0.26847 | 0.271218 | 0.0000342 | 0.00003455 | 0.0003 | 0.013368 | 0.01165 | 50
 | STEEL/E24-2 | 5153.5 | 63618.7 | 44082.2 | +4.417 | +5.890 | 436 | N39 | 1 | 1006 | GRENAILLE-PEINT | E24-2 |  | 7.90913 | 7.99007 | 0.00100753 | 0.00101784 | 0.000684 | 0.354888 | 0.343209 | 1473
 | STEEL/E24-2 | 5153.5 | 42981.3 | 55757.2 | +4.417 | +5.890 | 436 | N41 | 1 | 1006 | GRENAILLE-PEINT | E24-2 |  | 7.90913 | 7.99007 | 0.00100753 | 0.00101784 | 0.000684 | 0.354888 | 0.343209 | 1473
 | STEEL/E24-2 | 5153.5 | 2418.71 | 55757.2 | +4.417 | +5.890 | 436 | N16 | 1 | 1006 | GRENAILLE-PEINT | E24-2 |  | 7.90913 | 7.99007 | 0.00100753 | 0.00101784 | 0.000684 | 0.354888 | 0.343209 | 1473
 | STEEL/E24-2 | 5153.5 | 4968.71 | 55757.2 | +4.417 | +5.890 | 436 | N16 | 1 | 1006 | GRENAILLE-PEINT | E24-2 |  | 7.90913 | 7.99007 | 0.00100753 | 0.00101784 | 0.000684 | 0.354888 | 0.343209 | 1473
 | STEEL/E24-2 | 5153.5 | 10141.3 | 55757.2 | +4.417 | +5.890 | 436 | N47 | 1 | 1006 | GRENAILLE-PEINT | E24-2 |  | 7.90913 | 7.99007 | 0.00100753 | 0.00101784 | 0.000684 | 0.354888 | 0.343209 | 1473
 | STEEL/E24-2 | 4254.21 | 61268.5 | 55817.2 | +4.237 | +4.297 | 440 | N38 | 1 | 1006 | GRENAILLE-PEINT | E24-2 |  | 0.26847 | 0.271218 | 0.0000342 | 0.00003455 | 0.0003 | 0.013368 | 0.01165 | 50
 | STEEL/E24-2 | 5153.5 | 14598.7 | 55757.2 | +4.417 | +5.890 | 436 | N47 | 1 | 1006 | GRENAILLE-PEINT | E24-2 |  | 7.90913 | 7.99007 | 0.00100753 | 0.00101784 | 0.000684 | 0.354888 | 0.343209 | 1473
 | STEEL/E24-2 | 5153.5 | 17221.3 | 55757.2 | +4.417 | +5.890 | 436 | N47 | 1 | 1006 | GRENAILLE-PEINT | E24-2 |  | 7.90913 | 7.99007 | 0.00100753 | 0.00101784 | 0.000684 | 0.354888 | 0.343209 | 1473
 | STEEL/E24-2 | 5667.21 | 29684.3 | 55770 | +5.650 | +5.710 | 442 | N8 | 1 | 1006 | GRENAILLE-PEINT | E24-2 |  | 0.26847 | 0.271218 | 0.0000342 | 0.00003455 | 0.0003 | 0.013368 | 0.01165 | 50
 | STEEL/E24-2 | 5153.5 | 24518.7 | 55757.2 | +4.417 | +5.890 | 436 | N10 | 1 | 1006 | GRENAILLE-PEINT | E24-2 |  | 7.90913 | 7.99007 | 0.00100753 | 0.00101784 | 0.000684 | 0.354888 | 0.343209 | 1473
 | STEEL/E24-2 | 4712.79 | 29684.3 | 44095 | +4.670 | +4.730 | 442 | N8 | 1 | 1006 | GRENAILLE-PEINT | E24-2 |  | 0.26847 | 0.271218 | 0.0000342 | 0.00003455 | 0.003 | 0.013368 | 0.01165 | 50
 | STEEL/E24-2 | 5153.5 | 29718.7 | 44082.2 | +4.417 | +5.890 | 436 | N8 | 1 | 1006 | GRENAILLE-PEINT | E24-2 |  | 7.90913 | 7.99007 | 0.00100753 | 0.00101784 | 0.000684 | 0.354888 | 0.343209 | 1473
 | STEEL/E24-2 | 5153.5 | 32581.3 | 55757.2 | +4.417 | +5.890 | 436 | N8 | 1 | 1006 | GRENAILLE-PEINT | E24-2 |  | 7.90913 | 7.99007 | 0.00100753 | 0.00101784 | 0.000684 | 0.354888 | 0.343209 | 1473
 | STEEL/E24-2 | 5153.5 | 34918.7 | 55757.2 | +4.417 | +5.890 | 436 | N8 | 1 | 1006 | GRENAILLE-PEINT | E24-2 |  | 7.90913 | 7.99007 | 0.00100753 | 0.00101784 | 0.000684 | 0.354888 | 0.343209 | 1473
 | STEEL/E24-2 | 5153.5 | 37781.3 | 55757.2 | +4.417 | +5.890 | 436 | N8 | 1 | 1006 | GRENAILLE-PEINT | E24-2 |  | 7.90913 | 7.99007 | 0.00100753 | 0.00101784 | 0.000684 | 0.354888 | 0.343209 | 1473
 | STEEL/E24-2 | 5667.21 | 21884.3 | 44095 | +5.650 | +5.710 | 442 | N10 | 1 | 1006 | GRENAILLE-PEINT | E24-2 |  | 0.26847 | 0.271218 | 0.0000342 | 0.00003455 | 0.0003 | 0.013368 | 0.01165 | 50
 | STEEL/E24-2 | 5153.5 | 47918.7 | 55757.2 | +4.417 | +5.890 | 436 | N41 | 1 | 1006 | GRENAILLE-PEINT | E24-2 |  | 7.90913 | 7.99007 | 0.00100753 | 0.00101784 | 0.000684 | 0.354888 | 0.343209 | 1473
 | STEEL/E24-2 | 5153.5 | 50518.7 | 55757.2 | +4.417 | +5.890 | 436 | N41 | 1 | 1006 | GRENAILLE-PEINT | E24-2 |  | 7.90913 | 7.99007 | 0.00100753 | 0.00101784 | 0.000684 | 0.354888 | 0.343209 | 1473
 | STEEL/E24-2 | 5153.5 | 53381.3 | 55757.2 | +4.417 | +5.890 | 436 | N13 | 1 | 1006 | GRENAILLE-PEINT | E24-2 |  | 7.90913 | 7.99007 | 0.00100753 | 0.00101784 | 0.000684 | 0.354888 | 0.343209 | 1473
 | STEEL/E24-2 | 4712.79 | 19615.7 | 44095 | +4.670 | +4.730 | 442 | P36 | 1 | 1001 | GRENAILLE-PEINT | E24-2 |  | 0.26847 | 0.271218 | 0.0000342 | 0.00003455 | 0.003 | 0.013368 | 0.01165 | 50
 | STEEL/E24-2 | 5153.5 | 55718.7 | 55757.2 | +4.417 | +5.890 | 436 | N13 | 1 | 1006 | GRENAILLE-PEINT | E24-2 |  | 7.90913 | 7.99007 | 0.00100753 | 0.00101784 | 0.000684 | 0.354888 | 0.343209 | 1473
 | STEEL/E24-2 | 5153.5 | 58318.7 | 55757.2 | +4.417 | +5.890 | 436 | N13 | 1 | 1006 | GRENAILLE-PEINT | E24-2 |  | 7.90913 | 7.99007 | 0.00100753 | 0.00101784 | 0.000684 | 0.354888 | 0.343209 | 1473
 | STEEL/E24-2 | 5153.5 | 63618.7 | 55757.2 | +4.417 | +5.890 | 436 | N38 | 1 | 1006 | GRENAILLE-PEINT | E24-2 |  | 7.90913 | 7.99007 | 0.00100753 | 0.00101784 | 0.000684 | 0.354888 | 0.343209 | 1473
 | STEEL/E24-2 | 5153.5 | 66318.7 | 55757.2 | +4.417 | +5.890 | 436 | N38 | 1 | 1006 | GRENAILLE-PEINT | E24-2 |  | 7.90913 | 7.99007 | 0.00100753 | 0.00101784 | 0.000684 | 0.354888 | 0.343209 | 1473
 | STEEL/E24-2 | 5153.5 | 2418.71 | 32407.2 | +4.417 | +5.890 | 436 | N15 | 3 | 3006 | GRENAILLE-PEINT | E24-2 |  | 7.90913 | 7.99007 | 0.00100753 | 0.00101784 | 0.000684 | 0.354888 | 0.343209 | 1473
 | STEEL/E24-2 | 5153.5 | 4968.71 | 32407.2 | +4.417 | +5.890 | 436 | N15 | 3 | 3006 | GRENAILLE-PEINT | E24-2 |  | 7.90913 | 7.99007 | 0.00100753 | 0.00101784 | 0.000684 | 0.354888 | 0.343209 | 1473
 | STEEL/E24-2 | 5153.5 | 10141.3 | 32407.2 | +4.417 | +5.890 | 436 | N48 | 3 | 3006 | GRENAILLE-PEINT | E24-2 |  | 7.90913 | 7.99007 | 0.00100753 | 0.00101784 | 0.000684 | 0.354888 | 0.343209 | 1473
 | STEEL/E24-2 | 5153.5 | 12501.3 | 32407.2 | +4.417 | +5.890 | 436 | N48 | 3 | 3006 | GRENAILLE-PEINT | E24-2 |  | 7.90913 | 7.99007 | 0.00100753 | 0.00101784 | 0.000684 | 0.354888 | 0.343209 | 1473
 | STEEL/E24-2 | 5153.5 | 16958.7 | 32407.2 | +4.417 | +5.890 | 436 | N48 | 3 | 3006 | GRENAILLE-PEINT | E24-2 |  | 7.90913 | 7.99007 | 0.00100753 | 0.00101784 | 0.000684 | 0.354888 | 0.343209 | 1473
 | STEEL/E24-2 | 5153.5 | 37518.7 | 32407.2 | +4.417 | +5.890 | 436 | N40 | 3 | 3006 | GRENAILLE-PEINT | E24-2 |  | 7.90913 | 7.99007 | 0.00100753 | 0.00101784 | 0.000684 | 0.354888 | 0.343209 | 1473
 | STEEL/E24-2 | 5153.5 | 24518.7 | 32407.2 | +4.417 | +5.890 | 436 | N9 | 3 | 3006 | GRENAILLE-PEINT | E24-2 |  | 7.90913 | 7.99007 | 0.00100753 | 0.00101784 | 0.000684 | 0.354888 | 0.343209 | 1473
 | STEEL/E24-2 | 5153.5 | 27381.3 | 32407.2 | +4.417 | +5.890 | 436 | N9 | 3 | 3006 | GRENAILLE-PEINT | E24-2 |  | 7.90913 | 7.99007 | 0.00100753 | 0.00101784 | 0.000684 | 0.354888 | 0.343209 | 1473
 | STEEL/E24-2 | 5153.5 | 32581.3 | 32407.2 | +4.417 | +5.890 | 436 | N40 | 3 | 3006 | GRENAILLE-PEINT | E24-2 |  | 7.90913 | 7.99007 | 0.00100753 | 0.00101784 | 0.000684 | 0.354888 | 0.343209 | 1473
 | STEEL/E24-2 | 5153.5 | 45318.7 | 32407.2 | +4.417 | +5.890 | 436 | N43 | 3 | 3003 | GRENAILLE-PEINT | E24-2 |  | 7.90913 | 7.99007 | 0.00100753 | 0.00101784 | 0.000684 | 0.354888 | 0.343209 | 1473
 | STEEL/E24-2 | 5153.5 | 42981.3 | 32407.2 | +4.417 | +5.890 | 436 | N43 | 3 | 3003 | GRENAILLE-PEINT | E24-2 |  | 7.90913 | 7.99007 | 0.00100753 | 0.00101784 | 0.000684 | 0.354888 | 0.343209 | 1473
 | STEEL/E24-2 | 5153.5 | 47918.7 | 32407.2 | +4.417 | +5.890 | 436 | N43 | 3 | 3003 | GRENAILLE-PEINT | E24-2 |  | 7.90913 | 7.99007 | 0.00100753 | 0.00101784 | 0.000684 | 0.354888 | 0.343209 | 1473
 | STEEL/E24-2 | 4853.5 | 27381.3 | 20732.2 | +3.817 | +5.890 | 437 | N45 | 2 | 2006 | GRENAILLE-PEINT | E24-2 |  | 11.1308 | 11.2447 | 0.00141793 | 0.00143244 | 0.000684 | 0.498888 | 0.483009 | 2073
 | STEEL/E24-2 | 4853.5 | 16958.7 | 20732.2 | +3.817 | +5.890 | 437 | N49 | 2 | 2006 | GRENAILLE-PEINT | E24-2 |  | 11.1308 | 11.2447 | 0.00141793 | 0.00143244 | 0.000684 | 0.498888 | 0.483009 | 2073
 | STEEL/E24-2 | 4853.5 | 29718.7 | 20732.2 | +3.817 | +5.890 | 437 | N44 | 2 | 2006 | GRENAILLE-PEINT | E24-2 |  | 11.1308 | 11.2447 | 0.00141793 | 0.00143244 | 0.000684 | 0.498888 | 0.483009 | 2073
 | STEEL/E24-2 | 4853.5 | 14861.3 | 20732.2 | +3.817 | +5.890 | 437 | N49 | 2 | 2006 | GRENAILLE-PEINT | E24-2 |  | 11.1308 | 11.2447 | 0.00141793 | 0.00143244 | 0.000684 | 0.498888 | 0.483009 | 2073
 | STEEL/E24-2 | 5153.5 | 29718.7 | 32407.2 | +4.417 | +5.890 | 436 | N40 | 3 | 3006 | GRENAILLE-PEINT | E24-2 |  | 7.90913 | 7.99007 | 0.00100753 | 0.00101784 | 0.000684 | 0.354888 | 0.343209 | 1473
 | STEEL/E24-2 | 5667.21 | 21884.3 | 32420 | +5.650 | +5.710 | 441 | N9 | 3 | 3006 | GRENAILLE-PEINT | E24-2 |  | 0.26847 | 0.271218 | 0.0000342 | 0.00003455 | 0.0003 | 0.013368 | 0.01165 | 50
 | STEEL/E24-2 | 4853.5 | 12238.7 | 20732.2 | +3.817 | +5.890 | 437 | N49 | 2 | 2006 | GRENAILLE-PEINT | E24-2 |  | 11.1308 | 11.2447 | 0.00141793 | 0.00143244 | 0.000684 | 0.498888 | 0.483009 | 2073
 | STEEL/E24-2 | 4853.5 | 22181.3 | 20732.2 | +3.817 | +5.890 | 437 | N45 | 2 | 2006 | GRENAILLE-PEINT | E24-2 |  | 11.1308 | 11.2447 | 0.00141793 | 0.00143244 | 0.000684 | 0.498888 | 0.483009 | 2073
 | STEEL/E24-2 | 4853.5 | 24518.7 | 20732.2 | +3.817 | +5.890 | 437 | N45 | 2 | 2006 | GRENAILLE-PEINT | E24-2 |  | 11.1308 | 11.2447 | 0.00141793 | 0.00143244 | 0.000684 | 0.498888 | 0.483009 | 2073
 | STEEL/E24-2 | 4853.5 | 32581.3 | 20732.2 | +3.817 | +5.890 | 437 | N44 | 2 | 2006 | GRENAILLE-PEINT | E24-2 |  | 11.1308 | 11.2447 | 0.00141793 | 0.00143244 | 0.000684 | 0.498888 | 0.483009 | 2073
 | STEEL/E24-2 | 4853.5 | 34918.7 | 20732.2 | +3.817 | +5.890 | 437 | N44 | 2 | 2006 | GRENAILLE-PEINT | E24-2 |  | 11.1308 | 11.2447 | 0.00141793 | 0.00143244 | 0.000684 | 0.498888 | 0.483009 | 2073
 | STEEL/E24-2 | 4853.5 | 37781.3 | 20732.2 | +3.817 | +5.890 | 437 | N44 | 2 | 2006 | GRENAILLE-PEINT | E24-2 |  | 11.1308 | 11.2447 | 0.00141793 | 0.00143244 | 0.000684 | 0.498888 | 0.483009 | 2073
 | STEEL/E24-2 | 5667.21 | 40072.8 | 20745 | +5.650 | +5.710 | 441 | P30 | 2 | 2001 | GRENAILLE-PEINT | E24-2 |  | 0.26847 | 0.271218 | 0.0000342 | 0.00003455 | 0.0003 | 0.013368 | 0.01165 | 50
 | STEEL/E24-2 | 5190 | 40107.2 | 20732.2 | +4.665 | +5.715 | 438 | P30 | 2 | 2001 | GRENAILLE-PEINT | E24-2 |  | 5.63787 | 5.69557 | 0.0007182 | 0.00072555 | 0.000684 | 0.253368 | 0.24465 | 1050
 | STEEL/E24-2 | 4853.5 | 42981.3 | 20732.2 | +3.817 | +5.890 | 437 | N46 | 2 | 2006 | GRENAILLE-PEINT | E24-2 |  | 11.1308 | 11.2447 | 0.00141793 | 0.00143244 | 0.000684 | 0.498888 | 0.483009 | 2073
 | STEEL/E24-2 | 4853.5 | 45581.3 | 20732.2 | +3.817 | +5.890 | 437 | N46 | 2 | 2006 | GRENAILLE-PEINT | E24-2 |  | 11.1308 | 11.2447 | 0.00141793 | 0.00143244 | 0.000684 | 0.498888 | 0.483009 | 2073
ATTACHE | STEEL/E24-2 | 5782.79 | 89.2105 | 79175 | +5.740 | +5.800 | H11 | H11 | 1 | 1003 | GRENAILLE-PEINT | E24-2 | ATTACHE | 1.28866 | 1.30184 | 0.00016416 | 0.00016584 | 0.0144 | 0.058968 | 0.05592 | 240
 | STEEL/E24-2 | 5153.5 | 34918.7 | 67432.2 | +4.417 | +5.890 | 436 | N7 | 1 | 1006 | GRENAILLE-PEINT | E24-2 |  | 7.90913 | 7.99007 | 0.00100753 | 0.00101784 | 0.000684 | 0.354888 | 0.343209 | 1473
 | STEEL/E24-2 | 5153.5 | 32581.3 | 67432.2 | +4.417 | +5.890 | 436 | N7 | 1 | 1006 | GRENAILLE-PEINT | E24-2 |  | 7.90913 | 7.99007 | 0.00100753 | 0.00101784 | 0.000684 | 0.354888 | 0.343209 | 1473
 | STEEL/E24-2 | 5153.5 | 29981.3 | 67432.2 | +4.417 | +5.890 | 436 | N7 | 1 | 1006 | GRENAILLE-PEINT | E24-2 |  | 7.90913 | 7.99007 | 0.00100753 | 0.00101784 | 0.000684 | 0.354888 | 0.343209 | 1473
 | STEEL/E24-2 | 5153.5 | 27381.3 | 67432.2 | +4.417 | +5.890 | 436 | N11 | 1 | 1006 | GRENAILLE-PEINT | E24-2 |  | 7.90913 | 7.99007 | 0.00100753 | 0.00101784 | 0.000684 | 0.354888 | 0.343209 | 1473
 | STEEL/E24-2 | 5153.5 | 24518.7 | 67432.2 | +4.417 | +5.890 | 436 | N11 | 1 | 1006 | GRENAILLE-PEINT | E24-2 |  | 7.90913 | 7.99007 | 0.00100753 | 0.00101784 | 0.000684 | 0.354888 | 0.343209 | 1473
 | STEEL/E24-2 | 5153.5 | 22181.3 | 67432.2 | +4.417 | +5.890 | 436 | N11 | 1 | 1006 | GRENAILLE-PEINT | E24-2 |  | 7.90913 | 7.99007 | 0.00100753 | 0.00101784 | 0.000684 | 0.354888 | 0.343209 | 1473
 | STEEL/E24-2 | 5153.5 | 17221.3 | 67432.2 | +4.417 | +5.890 | 436 | N12 | 1 | 1006 | GRENAILLE-PEINT | E24-2 |  | 7.90913 | 7.99007 | 0.00100753 | 0.00101784 | 0.000684 | 0.354888 | 0.343209 | 1473
 | STEEL/E24-2 | 5153.5 | 14598.7 | 67432.2 | +4.417 | +5.890 | 436 | N12 | 1 | 1006 | GRENAILLE-PEINT | E24-2 |  | 7.90913 | 7.99007 | 0.00100753 | 0.00101784 | 0.000684 | 0.354888 | 0.343209 | 1473
 | STEEL/E24-2 | 5153.5 | 12238.7 | 67432.2 | +4.417 | +5.890 | 436 | N12 | 1 | 1006 | GRENAILLE-PEINT | E24-2 |  | 7.90913 | 7.99007 | 0.00100753 | 0.00101784 | 0.000684 | 0.354888 | 0.343209 | 1473
 | STEEL/E24-2 | 5153.5 | 10141.3 | 67432.2 | +4.417 | +5.890 | 436 | N12 | 1 | 1006 | GRENAILLE-PEINT | E24-2 |  | 7.90913 | 7.99007 | 0.00100753 | 0.00101784 | 0.000684 | 0.354888 | 0.343209 | 1473
 | STEEL/E24-2 | 5153.5 | 4968.71 | 67432.2 | +4.417 | +5.890 | 436 | N14 | 1 | 1006 | GRENAILLE-PEINT | E24-2 |  | 7.90913 | 7.99007 | 0.00100753 | 0.00101784 | 0.000684 | 0.354888 | 0.343209 | 1473
 | STEEL/E24-2 | 5153.5 | 2418.71 | 67432.2 | +4.417 | +5.890 | 436 | N14 | 1 | 1006 | GRENAILLE-PEINT | E24-2 |  | 7.90913 | 7.99007 | 0.00100753 | 0.00101784 | 0.000684 | 0.354888 | 0.343209 | 1473
ATTACHE | STEEL/S235JR | 5867.21 | 10027.2 | 68125 | +5.850 | +5.910 | H24 | H24 | 1 | 1008 | GALVANISE | S235JR | ATTACHE | 1.12757 | 1.13911 | 0.00014364 | 0.00014511 | 0.00126 | 0.051768 | 0.04893 | 210
ATTACHE | STEEL/S235JR | 5867.21 | 7667.21 | 75550 | +5.850 | +5.910 | H24 | H24 | 1 | 1008 | GALVANISE | S235JR | ATTACHE | 1.12757 | 1.13911 | 0.00014364 | 0.00014511 | 0.00126 | 0.051768 | 0.04893 | 210
ATTACHE | STEEL/S235JR | 5900 | 3842.21 | 73057.8 | +5.854 | +5.946 | H26 | H26 | 1 | 1008 | GALVANISE | S235JR | ATTACHE | 0.493985 | 0.49904 | 0.000062928 | 0.000063572 | 0.000684 | 0.023448 | 0.021436 | 92
 | STEEL/E24-2 | 5060.56 | 1682.79 | 79234.5 | +5.015 | +5.081 | 439 | P7 | 1 | 1011 | GRENAILLE-PEINT | E24-2 |  | 1.0207 | 1.03115 | 0.000130026 | 0.000131356 | 0 | 0.0469911 | 0.0442924 | 190.096
 | STEEL/E24-2 | 5060.56 | 1817.21 | 79234.5 | +5.015 | +5.081 | 439 | P7 | 1 | 1011 | GRENAILLE-PEINT | E24-2 |  | 1.0207 | 1.03115 | 0.000130026 | 0.000131356 | 0 | 0.0469911 | 0.0442924 | 190.096
ATTACHE | STEEL/E24-2 | 5060.86 | 89.2105 | 79247.5 | +5.018 | +5.078 | H33 | H33 | 1 | 1010 | GRENAILLE-PEINT | E24-2 | ATTACHE | 1.04703 | 1.05775 | 0.00013338 | 0.000134745 | 0.0117 | 0.048168 | 0.045435 | 195
 | STEEL/E24-2 | 4374.44 | 40182.8 | 79235 | +4.320 | +4.403 | 444 | P13 | 1 | 1001 | GRENAILLE-PEINT | E24-2 |  | 1.02777 | 1.07804 | 0.000130926 | 0.00013733 | 0 | 0.0473171 | 0.0463065 | 198.741
 | STEEL/E24-2 | 4374.44 | 40317.2 | 79235 | +4.320 | +4.403 | 445 | P13 | 1 | 1001 | GRENAILLE-PEINT | E24-2 |  | 1.02777 | 1.07804 | 0.000130926 | 0.00013733 | 0 | 0.0473171 | 0.0463065 | 198.741
 | STEEL/E24-2 | 4374.44 | 45382.8 | 79235 | +4.320 | +4.403 | 444 | P13 | 1 | 1001 | GRENAILLE-PEINT | E24-2 |  | 1.02777 | 1.07804 | 0.000130926 | 0.00013733 | 0 | 0.0473171 | 0.0463065 | 198.741
 | STEEL/E24-2 | 4374.44 | 45517.2 | 79235 | +4.320 | +4.403 | 445 | P13 | 1 | 1001 | GRENAILLE-PEINT | E24-2 |  | 1.02777 | 1.07804 | 0.000130926 | 0.00013733 | 0 | 0.0473171 | 0.0463065 | 198.741
 | STEEL/E24-2 | 4374.44 | 50582.8 | 79235 | +4.320 | +4.403 | 444 | P13 | 1 | 1001 | GRENAILLE-PEINT | E24-2 |  | 1.02777 | 1.07804 | 0.000130926 | 0.00013733 | 0 | 0.0473171 | 0.0463065 | 198.741
 | STEEL/E24-2 | 4374.44 | 50717.2 | 79235 | +4.320 | +4.403 | 445 | P13 | 1 | 1001 | GRENAILLE-PEINT | E24-2 |  | 1.02777 | 1.07804 | 0.000130926 | 0.00013733 | 0 | 0.0473171 | 0.0463065 | 198.741
 | STEEL/E24-2 | 4374.44 | 55782.8 | 79235 | +4.320 | +4.403 | 444 | P16 | 1 | 1001 | GRENAILLE-PEINT | E24-2 |  | 1.02777 | 1.07804 | 0.000130926 | 0.00013733 | 0 | 0.0473171 | 0.0463065 | 198.741
 | STEEL/E24-2 | 4374.44 | 55917.2 | 79235 | +4.320 | +4.403 | 445 | P16 | 1 | 1001 | GRENAILLE-PEINT | E24-2 |  | 1.02777 | 1.07804 | 0.000130926 | 0.00013733 | 0 | 0.0473171 | 0.0463065 | 198.741
 | STEEL/E24-2 | 4374.44 | 60982.8 | 79235 | +4.320 | +4.403 | 444 | P14 | 1 | 1001 | GRENAILLE-PEINT | E24-2 |  | 1.02777 | 1.07804 | 0.000130926 | 0.00013733 | 0 | 0.0473171 | 0.0463065 | 198.741
 | STEEL/E24-2 | 4374.44 | 61117.2 | 79235 | +4.320 | +4.403 | 445 | P14 | 1 | 1001 | GRENAILLE-PEINT | E24-2 |  | 1.02777 | 1.07804 | 0.000130926 | 0.00013733 | 0 | 0.0473171 | 0.0463065 | 198.741
 | STEEL/E24-2 | 4374.44 | 64457.8 | 79235 | +4.320 | +4.403 | 444 | P15 | 1 | 1001 | GRENAILLE-PEINT | E24-2 |  | 1.02777 | 1.07804 | 0.000130926 | 0.00013733 | 0 | 0.0473171 | 0.0463065 | 198.741
 | STEEL/E24-2 | 4374.44 | 64592.2 | 79235 | +4.320 | +4.403 | 445 | P15 | 1 | 1001 | GRENAILLE-PEINT | E24-2 |  | 1.02777 | 1.07804 | 0.000130926 | 0.00013733 | 0 | 0.0473171 | 0.0463065 | 198.741
ATTACHE | STEEL/S235JR | 5867.21 | 2567.21 | 78025 | +5.850 | +5.910 | H24 | H24 | 1 | 1008 | GALVANISE | S235JR | ATTACHE | 1.12757 | 1.13911 | 0.00014364 | 0.00014511 | 0.00126 | 0.051768 | 0.04893 | 210
ATTACHE | STEEL/S235JR | 5867.21 | 2567.21 | 75550 | +5.850 | +5.910 | H24 | H24 | 1 | 1008 | GALVANISE | S235JR | ATTACHE | 1.12757 | 1.13911 | 0.00014364 | 0.00014511 | 0.00126 | 0.051768 | 0.04893 | 210
ATTACHE | STEEL/S235JR | 5867.21 | 2567.21 | 73075 | +5.850 | +5.910 | H20 | H20 | 1 | 1008 | GALVANISE | S235JR | ATTACHE | 1.12757 | 1.13911 | 0.00014364 | 0.00014511 | 0.00126 | 0.051768 | 0.04893 | 210
ATTACHE | STEEL/S235JR | 5867.21 | 2567.21 | 70600 | +5.850 | +5.910 | H24 | H24 | 1 | 1008 | GALVANISE | S235JR | ATTACHE | 1.12757 | 1.13911 | 0.00014364 | 0.00014511 | 0.00126 | 0.051768 | 0.04893 | 210
ATTACHE | STEEL/S235JR | 5867.21 | 2567.21 | 68125 | +5.850 | +5.910 | H24 | H24 | 1 | 1008 | GALVANISE | S235JR | ATTACHE | 1.12757 | 1.13911 | 0.00014364 | 0.00014511 | 0.00126 | 0.051768 | 0.04893 | 210
ATTACHE | STEEL/S235JR | 5867.21 | 5117.21 | 75550 | +5.850 | +5.910 | H24 | H24 | 1 | 1008 | GALVANISE | S235JR | ATTACHE | 1.12757 | 1.13911 | 0.00014364 | 0.00014511 | 0.00126 | 0.051768 | 0.04893 | 210
ATTACHE | STEEL/S235JR | 5867.21 | 5117.21 | 73075 | +5.850 | +5.910 | H20 | H20 | 1 | 1008 | GALVANISE | S235JR | ATTACHE | 1.12757 | 1.13911 | 0.00014364 | 0.00014511 | 0.00126 | 0.051768 | 0.04893 | 210
ATTACHE | STEEL/S235JR | 5867.21 | 5117.21 | 70600 | +5.850 | +5.910 | H24 | H24 | 1 | 1008 | GALVANISE | S235JR | ATTACHE | 1.12757 | 1.13911 | 0.00014364 | 0.00014511 | 0.00126 | 0.051768 | 0.04893 | 210
ATTACHE | STEEL/S235JR | 5867.21 | 5117.21 | 68125 | +5.850 | +5.910 | H24 | H24 | 1 | 1008 | GALVANISE | S235JR | ATTACHE | 1.12757 | 1.13911 | 0.00014364 | 0.00014511 | 0.00126 | 0.051768 | 0.04893 | 210
ATTACHE | STEEL/S235JR | 5867.21 | 7667.21 | 78025 | +5.850 | +5.910 | H24 | H24 | 1 | 1008 | GALVANISE | S235JR | ATTACHE | 1.12757 | 1.13911 | 0.00014364 | 0.00014511 | 0.00126 | 0.051768 | 0.04893 | 210
ATTACHE | STEEL/S235JR | 5867.21 | 12387.2 | 68125 | +5.850 | +5.910 | H24 | H24 | 1 | 1008 | GALVANISE | S235JR | ATTACHE | 1.12757 | 1.13911 | 0.00014364 | 0.00014511 | 0.00126 | 0.051768 | 0.04893 | 210
ATTACHE | STEEL/S235JR | 5867.21 | 12387.2 | 70600 | +5.850 | +5.910 | H24 | H24 | 1 | 1008 | GALVANISE | S235JR | ATTACHE | 1.12757 | 1.13911 | 0.00014364 | 0.00014511 | 0.00126 | 0.051768 | 0.04893 | 210
ATTACHE | STEEL/S235JR | 5767.21 | 12370 | 78042.2 | +5.750 | +5.810 | H24 | H24 | 1 | 1008 | GALVANISE | S235JR | ATTACHE | 1.12757 | 1.13911 | 0.00014364 | 0.00014511 | 0.00126 | 0.051768 | 0.04893 | 210
ATTACHE | STEEL/S235JR | 5867.21 | 12387.2 | 73075 | +5.850 | +5.910 | H32 | H32 | 1 | 1008 | GALVANISE | S235JR | ATTACHE | 1.12757 | 1.13911 | 0.00014364 | 0.00014511 | 0.00126 | 0.051768 | 0.04893 | 210
ATTACHE | STEEL/S235JR | 5867.21 | 14747.2 | 68125 | +5.850 | +5.910 | H24 | H24 | 1 | 1008 | GALVANISE | S235JR | ATTACHE | 1.12757 | 1.13911 | 0.00014364 | 0.00014511 | 0.00126 | 0.051768 | 0.04893 | 210
ATTACHE | STEEL/S235JR | 5767.21 | 12370 | 73092.2 | +5.750 | +5.810 | H24 | H24 | 1 | 1008 | GALVANISE | S235JR | ATTACHE | 1.12757 | 1.13911 | 0.00014364 | 0.00014511 | 0.00126 | 0.051768 | 0.04893 | 210
ATTACHE | STEEL/S235JR | 5767.21 | 12370 | 75567.2 | +5.750 | +5.810 | H24 | H24 | 1 | 1008 | GALVANISE | S235JR | ATTACHE | 1.12757 | 1.13911 | 0.00014364 | 0.00014511 | 0.00126 | 0.051768 | 0.04893 | 210
ATTACHE | STEEL/S235JR | 5900 | 1367.21 | 73057.8 | +5.854 | +5.946 | H26 | H26 | 1 | 1008 | GALVANISE | S235JR | ATTACHE | 0.493985 | 0.49904 | 0.000062928 | 0.000063572 | 0.000684 | 0.023448 | 0.021436 | 92
ATTACHE | STEEL/S235JR | 5850 | 1367.21 | 78042.2 | +5.754 | +5.946 | H25 | H25 | 1 | 1008 | GALVANISE | S235JR | ATTACHE | 1.03092 | 1.04148 | 0.000131328 | 0.000132672 | 0.000684 | 0.047448 | 0.044736 | 192
ATTACHE | STEEL/S235JR | 5850 | 1367.21 | 68142.2 | +5.754 | +5.946 | H25 | H25 | 1 | 1008 | GALVANISE | S235JR | ATTACHE | 1.03092 | 1.04148 | 0.000131328 | 0.000132672 | 0.000684 | 0.047448 | 0.044736 | 192
ATTACHE | STEEL/S235JR | 5850 | 1367.21 | 70617.2 | +5.754 | +5.946 | H25 | H25 | 1 | 1008 | GALVANISE | S235JR | ATTACHE | 1.03092 | 1.04148 | 0.000131328 | 0.000132672 | 0.000684 | 0.047448 | 0.044736 | 192
ATTACHE | STEEL/S235JR | 5850 | 1367.21 | 73092.2 | +5.754 | +5.946 | H21 | H21 | 1 | 1008 | GALVANISE | S235JR | ATTACHE | 1.03092 | 1.04148 | 0.000131328 | 0.000132672 | 0.000684 | 0.047448 | 0.044736 | 192
ATTACHE | STEEL/S235JR | 5850 | 1367.21 | 75567.2 | +5.754 | +5.946 | H25 | H25 | 1 | 1008 | GALVANISE | S235JR | ATTACHE | 1.03092 | 1.04148 | 0.000131328 | 0.000132672 | 0.000684 | 0.047448 | 0.044736 | 192
ATTACHE | STEEL/S235JR | 5900 | 167.211 | 73057.8 | +5.854 | +5.946 | H26 | H26 | 1 | 1008 | GALVANISE | S235JR | ATTACHE | 0.493985 | 0.49904 | 0.000062928 | 0.000063572 | 0.000684 | 0.023448 | 0.021436 | 92
ATTACHE | STEEL/S235JR | 5850 | 167.211 | 73092.2 | +5.754 | +5.946 | H21 | H21 | 1 | 1008 | GALVANISE | S235JR | ATTACHE | 1.03092 | 1.04148 | 0.000131328 | 0.000132672 | 0.000684 | 0.047448 | 0.044736 | 192
ATTACHE | STEEL/S235JR | 5850 | 167.211 | 78042.2 | +5.754 | +5.946 | H25 | H25 | 1 | 1008 | GALVANISE | S235JR | ATTACHE | 1.03092 | 1.04148 | 0.000131328 | 0.000132672 | 0.000684 | 0.047448 | 0.044736 | 192
ATTACHE | STEEL/S235JR | 5850 | 167.211 | 68142.2 | +5.754 | +5.946 | H25 | H25 | 1 | 1008 | GALVANISE | S235JR | ATTACHE | 1.03092 | 1.04148 | 0.000131328 | 0.000132672 | 0.000684 | 0.047448 | 0.044736 | 192
ATTACHE | STEEL/S235JR | 5850 | 167.211 | 70617.2 | +5.754 | +5.946 | H25 | H25 | 1 | 1008 | GALVANISE | S235JR | ATTACHE | 1.03092 | 1.04148 | 0.000131328 | 0.000132672 | 0.000684 | 0.047448 | 0.044736 | 192
ATTACHE | STEEL/S235JR | 5850 | 167.211 | 75567.2 | +5.754 | +5.946 | H25 | H25 | 1 | 1008 | GALVANISE | S235JR | ATTACHE | 1.03092 | 1.04148 | 0.000131328 | 0.000132672 | 0.000684 | 0.047448 | 0.044736 | 192
ATTACHE | STEEL/S235JR | 5850 | 3842.21 | 70617.2 | +5.754 | +5.946 | H25 | H25 | 1 | 1008 | GALVANISE | S235JR | ATTACHE | 1.03092 | 1.04148 | 0.000131328 | 0.000132672 | 0.000684 | 0.047448 | 0.044736 | 192
ATTACHE | STEEL/S235JR | 5850 | 3842.21 | 68142.2 | +5.754 | +5.946 | H25 | H25 | 1 | 1008 | GALVANISE | S235JR | ATTACHE | 1.03092 | 1.04148 | 0.000131328 | 0.000132672 | 0.000684 | 0.047448 | 0.044736 | 192
ATTACHE | STEEL/S235JR | 5850 | 3842.21 | 78042.2 | +5.754 | +5.946 | H25 | H25 | 1 | 1008 | GALVANISE | S235JR | ATTACHE | 1.03092 | 1.04148 | 0.000131328 | 0.000132672 | 0.000684 | 0.047448 | 0.044736 | 192
ATTACHE | STEEL/S235JR | 5850 | 3842.21 | 75567.2 | +5.754 | +5.946 | H25 | H25 | 1 | 1008 | GALVANISE | S235JR | ATTACHE | 1.03092 | 1.04148 | 0.000131328 | 0.000132672 | 0.000684 | 0.047448 | 0.044736 | 192
ATTACHE | STEEL/S235JR | 5850 | 13271.8 | 78042.2 | +5.754 | +5.946 | H27 | H27 | 1 | 1008 | GALVANISE | S235JR | ATTACHE | 1.03092 | 1.04148 | 0.000131328 | 0.000132672 | 0.000684 | 0.047448 | 0.044736 | 192
ATTACHE | STEEL/S235JR | 5850 | 13271.8 | 73092.2 | +5.754 | +5.946 | H22 | H22 | 1 | 1008 | GALVANISE | S235JR | ATTACHE | 1.03092 | 1.04148 | 0.000131328 | 0.000132672 | 0.000684 | 0.047448 | 0.044736 | 192
ATTACHE | STEEL/S235JR | 5850 | 13271.8 | 75567.2 | +5.754 | +5.946 | H27 | H27 | 1 | 1008 | GALVANISE | S235JR | ATTACHE | 1.03092 | 1.04148 | 0.000131328 | 0.000132672 | 0.000684 | 0.047448 | 0.044736 | 192
ATTACHE | STEEL/S235JR | 5767.21 | 650 | 78042.2 | +5.750 | +5.810 | H24 | H24 | 1 | 1008 | GALVANISE | S235JR | ATTACHE | 1.12757 | 1.13911 | 0.00014364 | 0.00014511 | 0.00126 | 0.051768 | 0.04893 | 210
ATTACHE | STEEL/S235JR | 5767.21 | 650 | 75567.2 | +5.750 | +5.810 | H24 | H24 | 1 | 1008 | GALVANISE | S235JR | ATTACHE | 1.12757 | 1.13911 | 0.00014364 | 0.00014511 | 0.00126 | 0.051768 | 0.04893 | 210
ATTACHE | STEEL/S235JR | 5767.21 | 650 | 73092.2 | +5.750 | +5.810 | H24 | H24 | 1 | 1008 | GALVANISE | S235JR | ATTACHE | 1.12757 | 1.13911 | 0.00014364 | 0.00014511 | 0.00126 | 0.051768 | 0.04893 | 210
ATTACHE | STEEL/S235JR | 5767.21 | 650 | 70617.2 | +5.750 | +5.810 | H24 | H24 | 1 | 1008 | GALVANISE | S235JR | ATTACHE | 1.12757 | 1.13911 | 0.00014364 | 0.00014511 | 0.00126 | 0.051768 | 0.04893 | 210
ATTACHE | STEEL/S235JR | 5767.21 | 650 | 68142.2 | +5.750 | +5.810 | 428 | P102 | 1 | 1008 | GALVANISE | S235JR | ATTACHE | 1.12757 | 1.13911 | 0.00014364 | 0.00014511 | 0.00126 | 0.051768 | 0.04893 | 210
ATTACHE | STEEL/S235JR | 5867.21 | 22067.2 | 70902 | +5.850 | +5.910 | H24 | H24 | 1 | 1008 | GALVANISE | S235JR | ATTACHE | 1.12757 | 1.13911 | 0.00014364 | 0.00014511 | 0.00126 | 0.051768 | 0.04893 | 210
ATTACHE | STEEL/S235JR | 5867.21 | 24667.2 | 70902 | +5.850 | +5.910 | H24 | H24 | 1 | 1008 | GALVANISE | S235JR | ATTACHE | 1.12757 | 1.13911 | 0.00014364 | 0.00014511 | 0.00126 | 0.051768 | 0.04893 | 210
ATTACHE | STEEL/S235JR | 5850 | 20767.2 | 70919.2 | +5.754 | +5.946 | H25 | H25 | 1 | 1008 | GALVANISE | S235JR | ATTACHE | 1.03092 | 1.04148 | 0.000131328 | 0.000132672 | 0.000684 | 0.047448 | 0.044736 | 192
ATTACHE | STEEL/S235JR | 5867.21 | 26562.2 | 70902 | +5.850 | +5.910 | H24 | H24 | 1 | 1008 | GALVANISE | S235JR | ATTACHE | 1.12757 | 1.13911 | 0.00014364 | 0.00014511 | 0.00126 | 0.051768 | 0.04893 | 210
ATTACHE | STEEL/S235JR | 5867.21 | 29145 | 72675.9 | +5.850 | +5.910 | 428 | P97 | 1 | 1008 | GALVANISE | S235JR | ATTACHE | 1.12757 | 1.13911 | 0.00014364 | 0.00014511 | 0.00126 | 0.051768 | 0.04893 | 210
ATTACHE | STEEL/S235JR | 5867.21 | 27745 | 72675.9 | +5.850 | +5.910 | 428 | P97 | 1 | 1008 | GALVANISE | S235JR | ATTACHE | 1.12757 | 1.13911 | 0.00014364 | 0.00014511 | 0.00126 | 0.051768 | 0.04893 | 210
ATTACHE | STEEL/S235JR | 5867.21 | 26895 | 72675.9 | +5.850 | +5.910 | 428 | P104 | 1 | 1008 | GALVANISE | S235JR | ATTACHE | 1.12757 | 1.13911 | 0.00014364 | 0.00014511 | 0.00126 | 0.051768 | 0.04893 | 210
ATTACHE | STEEL/S235JR | 5867.21 | 26895 | 75375.9 | +5.850 | +5.910 | 428 | P105 | 1 | 1008 | GALVANISE | S235JR | ATTACHE | 1.12757 | 1.13911 | 0.00014364 | 0.00014511 | 0.00126 | 0.051768 | 0.04893 | 210
ATTACHE | STEEL/S235JR | 5867.21 | 27745 | 75375.9 | +5.850 | +5.910 | 428 | P98 | 1 | 1008 | GALVANISE | S235JR | ATTACHE | 1.12757 | 1.13911 | 0.00014364 | 0.00014511 | 0.00126 | 0.051768 | 0.04893 | 210
ATTACHE | STEEL/S235JR | 5867.21 | 29145 | 75375.9 | +5.850 | +5.910 | 428 | P98 | 1 | 1008 | GALVANISE | S235JR | ATTACHE | 1.12757 | 1.13911 | 0.00014364 | 0.00014511 | 0.00126 | 0.051768 | 0.04893 | 210
ATTACHE | STEEL/S235JR | 5867.21 | 30545 | 75375.9 | +5.850 | +5.910 | 428 | P98 | 1 | 1008 | GALVANISE | S235JR | ATTACHE | 1.12757 | 1.13911 | 0.00014364 | 0.00014511 | 0.00126 | 0.051768 | 0.04893 | 210
ATTACHE | STEEL/S235JR | 5867.21 | 31395 | 75375.9 | +5.850 | +5.910 | 428 | P105 | 1 | 1008 | GALVANISE | S235JR | ATTACHE | 1.12757 | 1.13911 | 0.00014364 | 0.00014511 | 0.00126 | 0.051768 | 0.04893 | 210
ATTACHE | STEEL/S235JR | 5767.21 | 30545 | 78062.2 | +5.750 | +5.810 | 428 | P99 | 1 | 1008 | GALVANISE | S235JR | ATTACHE | 1.12757 | 1.13911 | 0.00014364 | 0.00014511 | 0.00126 | 0.051768 | 0.04893 | 210
ATTACHE | STEEL/S235JR | 5767.21 | 26895 | 78062.2 | +5.750 | +5.810 | 428 | P106 | 1 | 1008 | GALVANISE | S235JR | ATTACHE | 1.12757 | 1.13911 | 0.00014364 | 0.00014511 | 0.00126 | 0.051768 | 0.04893 | 210
ATTACHE | STEEL/S235JR | 5767.21 | 27745 | 78062.2 | +5.750 | +5.810 | 428 | P99 | 1 | 1008 | GALVANISE | S235JR | ATTACHE | 1.12757 | 1.13911 | 0.00014364 | 0.00014511 | 0.00126 | 0.051768 | 0.04893 | 210
ATTACHE | STEEL/S235JR | 5767.21 | 29145 | 78062.2 | +5.750 | +5.810 | 428 | P99 | 1 | 1008 | GALVANISE | S235JR | ATTACHE | 1.12757 | 1.13911 | 0.00014364 | 0.00014511 | 0.00126 | 0.051768 | 0.04893 | 210
ATTACHE | STEEL/S235JR | 5767.21 | 31395 | 78062.2 | +5.750 | +5.810 | 428 | P106 | 1 | 1008 | GALVANISE | S235JR | ATTACHE | 1.12757 | 1.13911 | 0.00014364 | 0.00014511 | 0.00126 | 0.051768 | 0.04893 | 210
ATTACHE | STEEL/E24-2 | 4233.26 | 13519 | 79062.2 | +4.216 | +4.276 | 399 | L89 | 1 | 1003 | GRENAILLE-PEINT | E24-2 | ATTACHE | 0.26847 | 0.271217 | 0.0000342 | 0.00003455 | 0.0003 | 0.013368 | 0.01165 | 50
ATTACHE | STEEL/E24-2 | 5416.6 | 13519 | 79062.2 | +5.374 | +5.434 | 399 | L88 | 1 | 1003 | GRENAILLE-PEINT | E24-2 | ATTACHE | 0.26847 | 0.271217 | 0.0000342 | 0.00003455 | 0.003 | 0.013368 | 0.01165 | 50
ATTACHE | STEEL/E24-2 | 5415.42 | 13453.3 | 79044.7 | +5.374 | +5.434 | 434 | L88 | 1 | 1003 | GRENAILLE-PEINT | E24-2 | ATTACHE | 0.817313 | 0.894909 | 0.000104116 | 0.000114001 | 0.0084438 | 0.0380532 | 0.0384403 | 164.98
CSV | STEEL/E24-2 | 10354.6 | 62384.2 | 21393.3 | +10.264 | +10.420 | C3 | C3 | 2 | 2004 | GRENAILLE-PEINT | E24-2 | CSV | 21.9499 | 22.1529 | 0.00279617 | 0.00282202 | 0 | 0.98248 | 0.951564 | 4083.97
CSV | STEEL/E24-2 | 10256.4 | 59604.5 | 24560.1 | +10.166 | +10.322 | C1 | C1 | 2 | 2004 | GRENAILLE-PEINT | E24-2 | CSV | 21.8157 | 22.0172 | 0.00277906 | 0.00280474 | 0 | 0.976478 | 0.945737 | 4058.96
CSV | STEEL/E24-2 | 10354.6 | 59585.8 | 21393.3 | +10.264 | +10.420 | C3 | C3 | 2 | 2004 | GRENAILLE-PEINT | E24-2 | CSV | 21.9499 | 22.1529 | 0.00279617 | 0.00282202 | 0 | 0.98248 | 0.951564 | 4083.97
CSV | STEEL/E24-2 | 10354.6 | 56854.2 | 21393.3 | +10.264 | +10.420 | C3 | C3 | 2 | 2004 | GRENAILLE-PEINT | E24-2 | CSV | 21.9499 | 22.1529 | 0.00279617 | 0.00282202 | 0 | 0.98248 | 0.951564 | 4083.97
CSV | STEEL/E24-2 | 10256.4 | 62365.5 | 24560.1 | +10.166 | +10.322 | C1 | C1 | 2 | 2004 | GRENAILLE-PEINT | E24-2 | CSV | 21.8156 | 22.0172 | 0.00277906 | 0.00280474 | 0 | 0.976478 | 0.945737 | 4058.96
CSV | STEEL/E24-2 | 10256.4 | 56835.5 | 24560.1 | +10.166 | +10.322 | C1 | C1 | 2 | 2004 | GRENAILLE-PEINT | E24-2 | CSV | 21.8157 | 22.0172 | 0.00277906 | 0.00280474 | 0 | 0.976478 | 0.945737 | 4058.96
CSV | STEEL/E24-2 | 10353.6 | 65134.5 | 21426.1 | +10.263 | +10.419 | C1 | C1 | 2 | 2004 | GRENAILLE-PEINT | E24-2 | CSV | 21.8156 | 22.0172 | 0.00277906 | 0.00280474 | 0 | 0.976478 | 0.945737 | 4058.96
CSV | STEEL/E24-2 | 10059.1 | 51305.5 | 30927.6 | +9.969 | +10.124 | C1 | C1 | 2 | 2004 | GRENAILLE-PEINT | E24-2 | CSV | 21.8157 | 22.0172 | 0.00277906 | 0.00280474 | 0 | 0.976478 | 0.945737 | 4058.96
ATTACHE | STEEL/S235JR | 4382.21 | 43025.5 | 8340 | +4.365 | +4.425 | H24 | H24 | 2 | 2007 | GALVANISE | S235JR | ATTACHE | 1.12757 | 1.13911 | 0.00014364 | 0.00014511 | 0.00126 | 0.051768 | 0.04893 | 210
ATTACHE | STEEL/S235JR | 4382.21 | 43025.5 | 5691.67 | +4.365 | +4.425 | H20 | H20 | 2 | 2007 | GALVANISE | S235JR | ATTACHE | 1.12757 | 1.13911 | 0.00014364 | 0.00014511 | 0.00126 | 0.051768 | 0.04893 | 210
ATTACHE | STEEL/S235JR | 4382.21 | 43025.5 | 395 | +4.365 | +4.425 | 428 | P96 | 2 | 2007 | GALVANISE | S235JR | ATTACHE | 1.12757 | 1.13911 | 0.00014364 | 0.00014511 | 0.00126 | 0.051768 | 0.04893 | 210
ATTACHE | STEEL/S235JR | 4382.21 | 45783.9 | 8340 | +4.365 | +4.425 | H24 | H24 | 2 | 2007 | GALVANISE | S235JR | ATTACHE | 1.12757 | 1.13911 | 0.00014364 | 0.00014511 | 0.00126 | 0.051768 | 0.04893 | 210
ATTACHE | STEEL/S235JR | 4382.21 | 45783.9 | 5691.67 | +4.365 | +4.425 | H20 | H20 | 2 | 2007 | GALVANISE | S235JR | ATTACHE | 1.12757 | 1.13911 | 0.00014364 | 0.00014511 | 0.00126 | 0.051768 | 0.04893 | 210
ATTACHE | STEEL/S235JR | 4382.21 | 45783.9 | 395 | +4.365 | +4.425 | 428 | P96 | 2 | 2007 | GALVANISE | S235JR | ATTACHE | 1.12757 | 1.13911 | 0.00014364 | 0.00014511 | 0.00126 | 0.051768 | 0.04893 | 210
ATTACHE | STEEL/S235JR | 4365 | 41646.4 | 602.211 | +4.269 | +4.461 | H25 | H25 | 2 | 2007 | GALVANISE | S235JR | ATTACHE | 1.03092 | 1.04148 | 0.000131328 | 0.000132672 | 0.000684 | 0.047448 | 0.044736 | 192
ATTACHE | STEEL/S235JR | 4282.21 | 48525 | 8357.21 | +4.265 | +4.325 | H24 | H24 | 2 | 2007 | GALVANISE | S235JR | ATTACHE | 1.12757 | 1.13911 | 0.00014364 | 0.00014511 | 0.00126 | 0.051768 | 0.04893 | 210
ATTACHE | STEEL/S235JR | 4282.21 | 48525 | 5708.88 | +4.265 | +4.325 | H24 | H24 | 2 | 2007 | GALVANISE | S235JR | ATTACHE | 1.12757 | 1.13911 | 0.00014364 | 0.00014511 | 0.00126 | 0.051768 | 0.04893 | 210
ATTACHE | STEEL/S235JR | 4282.21 | 48525 | 602.211 | +4.265 | +4.325 | 428 | P94 | 2 | 2007 | GALVANISE | S235JR | ATTACHE | 1.12757 | 1.13911 | 0.00014364 | 0.00014511 | 0.00126 | 0.051768 | 0.04893 | 210
ATTACHE | STEEL/S235JR | 4415 | 14142.2 | 5674.46 | +4.369 | +4.461 | H26 | H26 | 2 | 2007 | GALVANISE | S235JR | ATTACHE | 0.493985 | 0.49904 | 0.000062928 | 0.000063572 | 0.000684 | 0.023448 | 0.021436 | 92
ATTACHE | STEEL/S235JR | 4365 | 14142.2 | 5708.88 | +4.269 | +4.461 | H21 | H21 | 2 | 2007 | GALVANISE | S235JR | ATTACHE | 1.03092 | 1.04148 | 0.000131328 | 0.000132672 | 0.000684 | 0.047448 | 0.044736 | 192
ATTACHE | STEEL/S235JR | 4365 | 14142.2 | 8357.21 | +4.269 | +4.461 | H25 | H25 | 2 | 2007 | GALVANISE | S235JR | ATTACHE | 1.03092 | 1.04148 | 0.000131328 | 0.000132672 | 0.000684 | 0.047448 | 0.044736 | 192
ATTACHE | STEEL/S235JR | 4415 | 16272.2 | 5674.46 | +4.369 | +4.461 | H26 | H26 | 2 | 2007 | GALVANISE | S235JR | ATTACHE | 0.493985 | 0.49904 | 0.000062928 | 0.000063572 | 0.000684 | 0.023448 | 0.021436 | 92
ATTACHE | STEEL/S235JR | 4365 | 16272.2 | 5708.88 | +4.269 | +4.461 | H21 | H21 | 2 | 2007 | GALVANISE | S235JR | ATTACHE | 1.03092 | 1.04148 | 0.000131328 | 0.000132672 | 0.000684 | 0.047448 | 0.044736 | 192
ATTACHE | STEEL/S235JR | 4365 | 16272.2 | 8357.21 | +4.269 | +4.461 | H25 | H25 | 2 | 2007 | GALVANISE | S235JR | ATTACHE | 1.03092 | 1.04148 | 0.000131328 | 0.000132672 | 0.000684 | 0.047448 | 0.044736 | 192
ATTACHE | STEEL/S235JR | 4415 | 18402.2 | 5674.46 | +4.369 | +4.461 | H26 | H26 | 2 | 2007 | GALVANISE | S235JR | ATTACHE | 0.493985 | 0.49904 | 0.000062928 | 0.000063572 | 0.000684 | 0.023448 | 0.021436 | 92
ATTACHE | STEEL/S235JR | 4365 | 18402.2 | 5708.88 | +4.269 | +4.461 | H21 | H21 | 2 | 2007 | GALVANISE | S235JR | ATTACHE | 1.03092 | 1.04148 | 0.000131328 | 0.000132672 | 0.000684 | 0.047448 | 0.044736 | 192
ATTACHE | STEEL/S235JR | 4365 | 18402.2 | 8357.21 | +4.269 | +4.461 | H25 | H25 | 2 | 2007 | GALVANISE | S235JR | ATTACHE | 1.03092 | 1.04148 | 0.000131328 | 0.000132672 | 0.000684 | 0.047448 | 0.044736 | 192
ATTACHE | STEEL/S235JR | 4415 | 20732.8 | 5674.46 | +4.369 | +4.461 | H26 | H26 | 2 | 2007 | GALVANISE | S235JR | ATTACHE | 0.493985 | 0.49904 | 0.000062928 | 0.000063572 | 0.000684 | 0.023448 | 0.021436 | 92
ATTACHE | STEEL/S235JR | 4365 | 20732.8 | 5708.88 | +4.269 | +4.461 | H21 | H21 | 2 | 2007 | GALVANISE | S235JR | ATTACHE | 1.03092 | 1.04148 | 0.000131328 | 0.000132672 | 0.000684 | 0.047448 | 0.044736 | 192
ATTACHE | STEEL/S235JR | 4365 | 20732.8 | 8357.21 | +4.269 | +4.461 | H25 | H25 | 2 | 2007 | GALVANISE | S235JR | ATTACHE | 1.03092 | 1.04148 | 0.000131328 | 0.000132672 | 0.000684 | 0.047448 | 0.044736 | 192
ATTACHE | STEEL/S235JR | 4415 | 23264.1 | 5674.46 | +4.369 | +4.461 | H26 | H26 | 2 | 2007 | GALVANISE | S235JR | ATTACHE | 0.493985 | 0.49904 | 0.000062928 | 0.000063572 | 0.000684 | 0.023448 | 0.021436 | 92
ATTACHE | STEEL/S235JR | 4365 | 23264.1 | 5708.88 | +4.269 | +4.461 | H21 | H21 | 2 | 2007 | GALVANISE | S235JR | ATTACHE | 1.03092 | 1.04148 | 0.000131328 | 0.000132672 | 0.000684 | 0.047448 | 0.044736 | 192
ATTACHE | STEEL/S235JR | 4365 | 23264.1 | 8357.21 | +4.269 | +4.461 | H25 | H25 | 2 | 2007 | GALVANISE | S235JR | ATTACHE | 1.03092 | 1.04148 | 0.000131328 | 0.000132672 | 0.000684 | 0.047448 | 0.044736 | 192
ATTACHE | STEEL/S235JR | 4415 | 25795.3 | 5674.46 | +4.369 | +4.461 | H26 | H26 | 2 | 2007 | GALVANISE | S235JR | ATTACHE | 0.493985 | 0.49904 | 0.000062928 | 0.000063572 | 0.000684 | 0.023448 | 0.021436 | 92
ATTACHE | STEEL/S235JR | 4365 | 25795.3 | 5708.88 | +4.269 | +4.461 | H21 | H21 | 2 | 2007 | GALVANISE | S235JR | ATTACHE | 1.03092 | 1.04148 | 0.000131328 | 0.000132672 | 0.000684 | 0.047448 | 0.044736 | 192
ATTACHE | STEEL/S235JR | 4365 | 25795.3 | 8357.21 | +4.269 | +4.461 | H25 | H25 | 2 | 2007 | GALVANISE | S235JR | ATTACHE | 1.03092 | 1.04148 | 0.000131328 | 0.000132672 | 0.000684 | 0.047448 | 0.044736 | 192
ATTACHE | STEEL/S235JR | 4415 | 28326.6 | 5674.46 | +4.369 | +4.461 | H26 | H26 | 2 | 2007 | GALVANISE | S235JR | ATTACHE | 0.493985 | 0.49904 | 0.000062928 | 0.000063572 | 0.000684 | 0.023448 | 0.021436 | 92
ATTACHE | STEEL/S235JR | 4365 | 28326.6 | 5708.88 | +4.269 | +4.461 | H21 | H21 | 2 | 2007 | GALVANISE | S235JR | ATTACHE | 1.03092 | 1.04148 | 0.000131328 | 0.000132672 | 0.000684 | 0.047448 | 0.044736 | 192
ATTACHE | STEEL/S235JR | 4365 | 28326.6 | 8357.21 | +4.269 | +4.461 | H25 | H25 | 2 | 2007 | GALVANISE | S235JR | ATTACHE | 1.03092 | 1.04148 | 0.000131328 | 0.000132672 | 0.000684 | 0.047448 | 0.044736 | 192
ATTACHE | STEEL/S235JR | 4415 | 30926.6 | 5674.46 | +4.369 | +4.461 | H26 | H26 | 2 | 2007 | GALVANISE | S235JR | ATTACHE | 0.493985 | 0.49904 | 0.000062928 | 0.000063572 | 0.000684 | 0.023448 | 0.021436 | 92
ATTACHE | STEEL/S235JR | 4365 | 30926.6 | 5708.88 | +4.269 | +4.461 | H21 | H21 | 2 | 2007 | GALVANISE | S235JR | ATTACHE | 1.03092 | 1.04148 | 0.000131328 | 0.000132672 | 0.000684 | 0.047448 | 0.044736 | 192
ATTACHE | STEEL/S235JR | 4365 | 30926.6 | 8357.21 | +4.269 | +4.461 | H25 | H25 | 2 | 2007 | GALVANISE | S235JR | ATTACHE | 1.03092 | 1.04148 | 0.000131328 | 0.000132672 | 0.000684 | 0.047448 | 0.044736 | 192
ATTACHE | STEEL/S235JR | 4415 | 33595.3 | 5674.46 | +4.369 | +4.461 | H26 | H26 | 2 | 2007 | GALVANISE | S235JR | ATTACHE | 0.493985 | 0.49904 | 0.000062928 | 0.000063572 | 0.000684 | 0.023448 | 0.021436 | 92
ATTACHE | STEEL/S235JR | 4365 | 33595.3 | 5708.88 | +4.269 | +4.461 | H21 | H21 | 2 | 2007 | GALVANISE | S235JR | ATTACHE | 1.03092 | 1.04148 | 0.000131328 | 0.000132672 | 0.000684 | 0.047448 | 0.044736 | 192
ATTACHE | STEEL/S235JR | 4365 | 33595.3 | 8357.21 | +4.269 | +4.461 | H25 | H25 | 2 | 2007 | GALVANISE | S235JR | ATTACHE | 1.03092 | 1.04148 | 0.000131328 | 0.000132672 | 0.000684 | 0.047448 | 0.044736 | 192
ATTACHE | STEEL/S235JR | 4365 | 30926.6 | 602.211 | +4.269 | +4.461 | H25 | H25 | 2 | 2007 | GALVANISE | S235JR | ATTACHE | 1.03092 | 1.04148 | 0.000131328 | 0.000132672 | 0.000684 | 0.047448 | 0.044736 | 192
ATTACHE | STEEL/S235JR | 4365 | 32261 | 602.211 | +4.269 | +4.461 | H25 | H25 | 2 | 2007 | GALVANISE | S235JR | ATTACHE | 1.03092 | 1.04148 | 0.000131328 | 0.000132672 | 0.000684 | 0.047448 | 0.044736 | 192
ATTACHE | STEEL/S235JR | 4415 | 36264.1 | 5674.46 | +4.369 | +4.461 | H26 | H26 | 2 | 2007 | GALVANISE | S235JR | ATTACHE | 0.493985 | 0.49904 | 0.000062928 | 0.000063572 | 0.000684 | 0.023448 | 0.021436 | 92
ATTACHE | STEEL/S235JR | 4365 | 36264.1 | 5708.88 | +4.269 | +4.461 | H21 | H21 | 2 | 2007 | GALVANISE | S235JR | ATTACHE | 1.03092 | 1.04148 | 0.000131328 | 0.000132672 | 0.000684 | 0.047448 | 0.044736 | 192
ATTACHE | STEEL/S235JR | 4365 | 36264.1 | 8357.21 | +4.269 | +4.461 | H25 | H25 | 2 | 2007 | GALVANISE | S235JR | ATTACHE | 1.03092 | 1.04148 | 0.000131328 | 0.000132672 | 0.000684 | 0.047448 | 0.044736 | 192
ATTACHE | STEEL/S235JR | 4415 | 38932.8 | 5674.46 | +4.369 | +4.461 | H26 | H26 | 2 | 2007 | GALVANISE | S235JR | ATTACHE | 0.493985 | 0.49904 | 0.000062928 | 0.000063572 | 0.000684 | 0.023448 | 0.021436 | 92
ATTACHE | STEEL/S235JR | 4365 | 38932.8 | 5708.88 | +4.269 | +4.461 | H21 | H21 | 2 | 2007 | GALVANISE | S235JR | ATTACHE | 1.03092 | 1.04148 | 0.000131328 | 0.000132672 | 0.000684 | 0.047448 | 0.044736 | 192
ATTACHE | STEEL/S235JR | 4365 | 38932.8 | 8357.21 | +4.269 | +4.461 | H25 | H25 | 2 | 2007 | GALVANISE | S235JR | ATTACHE | 1.03092 | 1.04148 | 0.000131328 | 0.000132672 | 0.000684 | 0.047448 | 0.044736 | 192
ATTACHE | STEEL/S235JR | 4365 | 36264.1 | 602.211 | +4.269 | +4.461 | H25 | H25 | 2 | 2007 | GALVANISE | S235JR | ATTACHE | 1.03092 | 1.04148 | 0.000131328 | 0.000132672 | 0.000684 | 0.047448 | 0.044736 | 192
ATTACHE | STEEL/S235JR | 4415 | 41646.4 | 5674.46 | +4.369 | +4.461 | H26 | H26 | 2 | 2007 | GALVANISE | S235JR | ATTACHE | 0.493985 | 0.49904 | 0.000062928 | 0.000063572 | 0.000684 | 0.023448 | 0.021436 | 92
ATTACHE | STEEL/S235JR | 4365 | 41646.4 | 5708.88 | +4.269 | +4.461 | H21 | H21 | 2 | 2007 | GALVANISE | S235JR | ATTACHE | 1.03092 | 1.04148 | 0.000131328 | 0.000132672 | 0.000684 | 0.047448 | 0.044736 | 192
ATTACHE | STEEL/S235JR | 4365 | 41646.4 | 8357.21 | +4.269 | +4.461 | H25 | H25 | 2 | 2007 | GALVANISE | S235JR | ATTACHE | 1.03092 | 1.04148 | 0.000131328 | 0.000132672 | 0.000684 | 0.047448 | 0.044736 | 192
ATTACHE | STEEL/S235JR | 4365 | 38932.8 | 602.211 | +4.269 | +4.461 | H25 | H25 | 2 | 2007 | GALVANISE | S235JR | ATTACHE | 1.03092 | 1.04148 | 0.000131328 | 0.000132672 | 0.000684 | 0.047448 | 0.044736 | 192
ATTACHE | STEEL/S235JR | 4415 | 44404.7 | 5674.46 | +4.369 | +4.461 | H26 | H26 | 2 | 2007 | GALVANISE | S235JR | ATTACHE | 0.493985 | 0.49904 | 0.000062928 | 0.000063572 | 0.000684 | 0.023448 | 0.021436 | 92
ATTACHE | STEEL/S235JR | 4365 | 44404.7 | 5708.88 | +4.269 | +4.461 | H21 | H21 | 2 | 2007 | GALVANISE | S235JR | ATTACHE | 1.03092 | 1.04148 | 0.000131328 | 0.000132672 | 0.000684 | 0.047448 | 0.044736 | 192
ATTACHE | STEEL/S235JR | 4365 | 44404.7 | 8357.21 | +4.269 | +4.461 | H25 | H25 | 2 | 2007 | GALVANISE | S235JR | ATTACHE | 1.03092 | 1.04148 | 0.000131328 | 0.000132672 | 0.000684 | 0.047448 | 0.044736 | 192
ATTACHE | STEEL/S235JR | 4365 | 44404.7 | 602.211 | +4.269 | +4.461 | H25 | H25 | 2 | 2007 | GALVANISE | S235JR | ATTACHE | 1.03092 | 1.04148 | 0.000131328 | 0.000132672 | 0.000684 | 0.047448 | 0.044736 | 192
ATTACHE | STEEL/S235JR | 4415 | 48353.9 | -347.789 | +4.369 | +4.461 | H26 | H26 | 2 | 2007 | GALVANISE | S235JR | ATTACHE | 0.493985 | 0.49904 | 0.000062928 | 0.000063572 | 0.000684 | 0.023448 | 0.021436 | 92
ATTACHE | STEEL/S235JR | 4365 | 48353.9 | 10422.2 | +4.269 | +4.461 | H25 | H25 | 2 | 2007 | GALVANISE | S235JR | ATTACHE | 1.03092 | 1.04148 | 0.000131328 | 0.000132672 | 0.000684 | 0.047448 | 0.044736 | 192
ATTACHE | STEEL/S235JR | 4365 | 48353.9 | 8357.21 | +4.269 | +4.461 | H25 | H25 | 2 | 2007 | GALVANISE | S235JR | ATTACHE | 1.03092 | 1.04148 | 0.000131328 | 0.000132672 | 0.000684 | 0.047448 | 0.044736 | 192
ATTACHE | STEEL/S235JR | 4365 | 48353.9 | 602.211 | +4.269 | +4.461 | H25 | H25 | 2 | 2007 | GALVANISE | S235JR | ATTACHE | 1.03092 | 1.04148 | 0.000131328 | 0.000132672 | 0.000684 | 0.047448 | 0.044736 | 192
ATTACHE | STEEL/S235JR | 4415 | 48353.9 | 5674.46 | +4.369 | +4.461 | H26 | H26 | 2 | 2007 | GALVANISE | S235JR | ATTACHE | 0.493985 | 0.49904 | 0.000062928 | 0.000063572 | 0.000684 | 0.023448 | 0.021436 | 92
ATTACHE | STEEL/S235JR | 4365 | 48353.9 | 3060.54 | +4.269 | +4.461 | H25 | H25 | 2 | 2007 | GALVANISE | S235JR | ATTACHE | 1.03092 | 1.04148 | 0.000131328 | 0.000132672 | 0.000684 | 0.047448 | 0.044736 | 192
ATTACHE | STEEL/S235JR | 4365 | 48353.9 | 5708.88 | +4.269 | +4.461 | H21 | H21 | 2 | 2007 | GALVANISE | S235JR | ATTACHE | 1.03092 | 1.04148 | 0.000131328 | 0.000132672 | 0.000684 | 0.047448 | 0.044736 | 192
ATTACHE | STEEL/S235JR | 4282.21 | 48065 | 10422.2 | +4.265 | +4.325 | H24 | H24 | 2 | 2007 | GALVANISE | S235JR | ATTACHE | 1.12757 | 1.13911 | 0.00014364 | 0.00014511 | 0.00126 | 0.051768 | 0.04893 | 210
ATTACHE | STEEL/S235JR | 10782.2 | 65860 | 23173.8 | +10.765 | +10.825 | 428 | P100 | 2 | 2007 | GALVANISE | S235JR | ATTACHE | 1.12757 | 1.13911 | 0.00014364 | 0.00014511 | 0.00126 | 0.051768 | 0.04893 | 210
ATTACHE | STEEL/S235JR | 10882.2 | 65987.2 | 20360 | +10.865 | +10.925 | 428 | P101 | 2 | 2007 | GALVANISE | S235JR | ATTACHE | 1.12757 | 1.13911 | 0.00014364 | 0.00014511 | 0.00126 | 0.051768 | 0.04893 | 210
ATTACHE | STEEL/S235JR | 10865 | 56854.7 | 31692.2 | +10.769 | +10.961 | H25 | H25 | 2 | 2007 | GALVANISE | S235JR | ATTACHE | 1.03092 | 1.04148 | 0.000131328 | 0.000132672 | 0.000684 | 0.047448 | 0.044736 | 192
ATTACHE | STEEL/S235JR | 10865 | 56854.7 | 28864.2 | +10.769 | +10.961 | H25 | H25 | 2 | 2007 | GALVANISE | S235JR | ATTACHE | 1.03092 | 1.04148 | 0.000131328 | 0.000132672 | 0.000684 | 0.047448 | 0.044736 | 192
ATTACHE | STEEL/S235JR | 10782.2 | 65970 | 31692.2 | +10.765 | +10.825 | H24 | H24 | 2 | 2007 | GALVANISE | S235JR | ATTACHE | 1.12757 | 1.13911 | 0.00014364 | 0.00014511 | 0.00126 | 0.051768 | 0.04893 | 210
ATTACHE | STEEL/S235JR | 10782.2 | 65970 | 28864.2 | +10.765 | +10.825 | H24 | H24 | 2 | 2007 | GALVANISE | S235JR | ATTACHE | 1.12757 | 1.13911 | 0.00014364 | 0.00014511 | 0.00126 | 0.051768 | 0.04893 | 210
ATTACHE | STEEL/S235JR | 10782.2 | 65970 | 26036.2 | +10.765 | +10.825 | H24 | H24 | 2 | 2007 | GALVANISE | S235JR | ATTACHE | 1.12757 | 1.13911 | 0.00014364 | 0.00014511 | 0.00126 | 0.051768 | 0.04893 | 210
ATTACHE | STEEL/S235JR | 10882.2 | 63767.2 | 31675 | +10.865 | +10.925 | H24 | H24 | 2 | 2007 | GALVANISE | S235JR | ATTACHE | 1.12757 | 1.13911 | 0.00014364 | 0.00014511 | 0.00126 | 0.051768 | 0.04893 | 210
ATTACHE | STEEL/S235JR | 10882.2 | 63767.2 | 26019 | +10.865 | +10.925 | H20 | H20 | 2 | 2007 | GALVANISE | S235JR | ATTACHE | 1.12757 | 1.13911 | 0.00014364 | 0.00014511 | 0.00126 | 0.051768 | 0.04893 | 210
ATTACHE | STEEL/S235JR | 10865 | 65097.2 | 28864.2 | +10.769 | +10.961 | H25 | H25 | 2 | 2007 | GALVANISE | S235JR | ATTACHE | 1.03092 | 1.04148 | 0.000131328 | 0.000132672 | 0.000684 | 0.047448 | 0.044736 | 192
ATTACHE | STEEL/S235JR | 10915 | 65097.2 | 26001.8 | +10.869 | +10.961 | H26 | H26 | 2 | 2007 | GALVANISE | S235JR | ATTACHE | 0.493985 | 0.49904 | 0.000062928 | 0.000063572 | 0.000684 | 0.023448 | 0.021436 | 92
ATTACHE | STEEL/S235JR | 10865 | 65097.2 | 26036.2 | +10.769 | +10.961 | H21 | H21 | 2 | 2007 | GALVANISE | S235JR | ATTACHE | 1.03092 | 1.04148 | 0.000131328 | 0.000132672 | 0.000684 | 0.047448 | 0.044736 | 192
ATTACHE | STEEL/S235JR | 10865 | 65097.2 | 31692.2 | +10.769 | +10.961 | H25 | H25 | 2 | 2007 | GALVANISE | S235JR | ATTACHE | 1.03092 | 1.04148 | 0.000131328 | 0.000132672 | 0.000684 | 0.047448 | 0.044736 | 192
