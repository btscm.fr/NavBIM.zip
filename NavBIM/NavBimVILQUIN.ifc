Properties of the parts of a building model (IFC2X3), part 20 of 32

# IfcColumn: L100*10 (15)
Name | Material | BaseQuantities, Length (mm) = Tekla Quantity, Length (mm) | OuterSurfaceArea (m2) = Gross area (m2) | NetVolume (m3) = Net volume (m3) | NetWeight (kg) = Net weight (kg) | Center of gravity Z (mm) | Center of gravity Y (mm) | Center of gravity X (mm) | Bottom elevation | Top elevation | Part mark | Assembly mark | Phase | Class | Grade | Name | Gross weight (kg) = Weight (kg) | Gross volume (m3) | Net surface area (m2)
ATTACHE | STEEL/S235JR | 210 | 0.5922 | 0.000399 | 3.13215 | 3566.58 | 48556.7 | 20511.2 | +3.462 | +3.672 | H73 | H73 | 2 | 2005 | S235JR | ATTACHE | 3.16512 | 0.0004032 | 0.0878
ATTACHE | STEEL/E24-2 | 210 | 0.5922 | 0.000399 | 3.13215 | 5621.02 | 50682.4 | 32753.7 | +5.516 | +5.726 | H71 | H71 | 3 | 3005 | E24-2 | ATTACHE | 3.16512 | 0.0004032 | 0.0878
ATTACHE | STEEL/E24-2 | 210 | 0.5922 | 0.000399 | 3.13215 | 5621.02 | 53282.4 | 32753.7 | +5.516 | +5.726 | H71 | H71 | 3 | 3005 | E24-2 | ATTACHE | 3.16512 | 0.0004032 | 0.0878
ATTACHE | STEEL/E24-2 | 210 | 0.5922 | 0.000399 | 3.13215 | 5621.02 | 55882.4 | 32753.7 | +5.516 | +5.726 | H71 | H71 | 3 | 3005 | E24-2 | ATTACHE | 3.16512 | 0.0004032 | 0.0878
ATTACHE | STEEL/E24-2 | 210 | 0.5922 | 0.000399 | 3.13215 | 5621.02 | 58482.4 | 32753.7 | +5.516 | +5.726 | H71 | H71 | 3 | 3005 | E24-2 | ATTACHE | 3.16512 | 0.0004032 | 0.0878
ATTACHE | STEEL/E24-2 | 210 | 0.5922 | 0.000399 | 3.13215 | 5621.02 | 63782.4 | 32753.7 | +5.516 | +5.726 | H71 | H71 | 3 | 3005 | E24-2 | ATTACHE | 3.16512 | 0.0004032 | 0.0878
ATTACHE | STEEL/E24-2 | 210 | 0.5922 | 0.000399 | 3.13215 | 5637.64 | 69182.4 | 32753.7 | +5.533 | +5.743 | H71 | H71 | 3 | 3005 | E24-2 | ATTACHE | 3.16512 | 0.0004032 | 0.0878
ATTACHE | STEEL/E24-2 | 210 | 0.5922 | 0.000399 | 3.13215 | 5621.02 | 66482.4 | 32753.7 | +5.516 | +5.726 | H71 | H71 | 3 | 3005 | E24-2 | ATTACHE | 3.16512 | 0.0004032 | 0.0878

# IfcColumn: L40*4, CV
In: Undefined
Description: L40*4; Material: STEEL/S235JR
Tekla Common - Center of gravity Z: 4525 mm; Center of gravity Y: 44398 mm; Center of gravity X: -746.474 mm; Bottom elevation: +4.260; Top elevation: +4.790; Part mark: W2; Assembly mark: W2; Phase: 4; Class: 4000; Finish: GALVANISE; Grade: S235JR; Profile: L40*4; Name: CV; sets with these values: 2
Tekla Quantity - Net weight: 1.26479 kg; Gross weight: 1.27176 kg; Weight: 1.27176 kg; Net volume: 0.00016112 m3; Gross volume: 0.000162008 m3; Gross footprint area: 0.000304 m2; Area per tons: 64.1079 m2; Net surface area: 0.085408 m2; Gross area: 0.08153 m2; Height: 40 mm; Width: 40 mm; Length: 526 mm; sets with these values: 2
BaseQuantities - Length: 526 mm; OuterSurfaceArea: 0.08153 m2; NetVolume: 0.00016112 m3; NetWeight: 1.26479 kg

# IfcColumn: L60*6 (59)
In: Undefined
Description: L60*6
Tekla Common - Profile: L60*6; sets with these values: 2
Tekla Quantity - Gross footprint area: 0.000684 m2; Area per tons: 42.9545 m2; Height: 60 mm; Width: 60 mm; sets with these values: 2
Name | Material | Center of gravity Z (mm) | Center of gravity Y (mm) | Center of gravity X (mm) | Bottom elevation | Top elevation | Part mark | Assembly mark | Phase | Class | Finish | Grade | Name | Net weight (kg) = NetWeight (kg) | Gross weight (kg) = Weight (kg) | Net volume (m3) = NetVolume (m3) | Gross volume (m3) | Net surface area (m2) | Gross area (m2) = OuterSurfaceArea (m2) | Tekla Quantity, Length (mm) = BaseQuantities, Length (mm)
ATTACHE | STEEL/E24-2 | 5230.5 | 27862.8 | 58352.8 | +5.148 | +5.313 | 402 | L18 | 4 | 4001 | GRENAILLE-PEINT | E24-2 | ATTACHE | 0.885949 | 0.895015 | 0.00011286 | 0.000114015 | 0.0409679 | 0.0384449 | 165
ATTACHE | STEEL/E24-2 | 3535 | 27862.8 | 58287.8 | +3.505 | +3.565 | 400 | L18 | 4 | 4001 | GRENAILLE-PEINT | E24-2 | ATTACHE | 0.322164 | 0.325461 | 0.00004104 | 0.00004146 | 0.015768 | 0.01398 | 60.0001
ATTACHE | STEEL/E24-2 | 3535 | 24037.2 | 54462.2 | +3.505 | +3.565 | 400 | L19 | 4 | 4001 | GRENAILLE-PEINT | E24-2 | ATTACHE | 0.322164 | 0.325461 | 0.00004104 | 0.00004146 | 0.015768 | 0.01398 | 60
ATTACHE | STEEL/S235JR | 7255 | 68057.7 | 23672.3 | +7.170 | +7.340 | H28 | H28 | 2 | 2007 | GALVANISE | S235JR | ATTACHE | 0.912798 | 0.92214 | 0.00011628 | 0.00011747 | 0.042168 | 0.03961 | 170
ATTACHE | STEEL/S235JR | 7255 | 68057.7 | 27549.8 | +7.170 | +7.340 | H28 | H28 | 2 | 2007 | GALVANISE | S235JR | ATTACHE | 0.912798 | 0.92214 | 0.00011628 | 0.00011747 | 0.042168 | 0.03961 | 170
ATTACHE | STEEL/S235JR | 7255 | 68017.3 | 23712.7 | +7.170 | +7.340 | H28 | H28 | 2 | 2007 | GALVANISE | S235JR | ATTACHE | 0.912798 | 0.92214 | 0.00011628 | 0.00011747 | 0.042168 | 0.03961 | 170
ATTACHE | STEEL/S235JR | 7615 | 68017.3 | 27700.2 | +7.530 | +7.700 | H28 | H28 | 2 | 2007 | GALVANISE | S235JR | ATTACHE | 0.912798 | 0.92214 | 0.00011628 | 0.00011747 | 0.042168 | 0.03961 | 170
ATTACHE | STEEL/S235JR | 4415 | 15122.8 | -347.789 | +4.367 | +4.463 | 430 | S53 | 2 | 2007 | GALVANISE | S235JR | ATTACHE | 0.515462 | 0.520738 | 0.000065664 | 0.000066336 | 0.024408 | 0.022368 | 96
ATTACHE | STEEL/S235JR | 4415 | 19382.8 | -347.789 | +4.367 | +4.463 | 430 | S53 | 2 | 2007 | GALVANISE | S235JR | ATTACHE | 0.515462 | 0.520738 | 0.000065664 | 0.000066336 | 0.024408 | 0.022368 | 96
ATTACHE | STEEL/S235JR | 4415 | 24445.3 | -347.789 | +4.367 | +4.463 | 430 | S53 | 2 | 2007 | GALVANISE | S235JR | ATTACHE | 0.515462 | 0.520738 | 0.000065664 | 0.000066336 | 0.024408 | 0.022368 | 96
ATTACHE | STEEL/S235JR | 4415 | 29507.8 | -347.789 | +4.367 | +4.463 | 430 | S53 | 2 | 2007 | GALVANISE | S235JR | ATTACHE | 0.515462 | 0.520738 | 0.000065664 | 0.000066336 | 0.024408 | 0.022368 | 96
ATTACHE | STEEL/S235JR | 4415 | 34845.3 | -347.789 | +4.367 | +4.463 | 430 | S53 | 2 | 2007 | GALVANISE | S235JR | ATTACHE | 0.515462 | 0.520738 | 0.000065664 | 0.000066336 | 0.024408 | 0.022368 | 96
ATTACHE | STEEL/S235JR | 4415 | 40182.8 | -347.789 | +4.367 | +4.463 | 430 | S53 | 2 | 2007 | GALVANISE | S235JR | ATTACHE | 0.515462 | 0.520738 | 0.000065664 | 0.000066336 | 0.024408 | 0.022368 | 96
ATTACHE | STEEL/S235JR | 4415 | 45699.4 | -347.789 | +4.367 | +4.463 | 430 | S53 | 2 | 2007 | GALVANISE | S235JR | ATTACHE | 0.515462 | 0.520738 | 0.000065664 | 0.000066336 | 0.024408 | 0.022368 | 96
ATTACHE | STEEL/S235JR | 4315 | 15172.8 | 602.211 | +4.269 | +4.361 | H26 | H26 | 2 | 2007 | GALVANISE | S235JR | ATTACHE | 0.493985 | 0.49904 | 0.000062928 | 0.000063572 | 0.023448 | 0.021436 | 92
ATTACHE | STEEL/S235JR | 4365 | 15207.2 | 602.211 | +4.269 | +4.461 | H21 | H21 | 2 | 2007 | GALVANISE | S235JR | ATTACHE | 1.03092 | 1.04148 | 0.000131328 | 0.000132672 | 0.047448 | 0.044736 | 192
ATTACHE | STEEL/S235JR | 4315 | 19432.8 | 602.211 | +4.269 | +4.361 | H26 | H26 | 2 | 2007 | GALVANISE | S235JR | ATTACHE | 0.493985 | 0.49904 | 0.000062928 | 0.000063572 | 0.023448 | 0.021436 | 92
ATTACHE | STEEL/S235JR | 4365 | 19467.2 | 602.211 | +4.269 | +4.461 | H21 | H21 | 2 | 2007 | GALVANISE | S235JR | ATTACHE | 1.03092 | 1.04148 | 0.000131328 | 0.000132672 | 0.047448 | 0.044736 | 192
ATTACHE | STEEL/S235JR | 4365 | 24529.7 | 602.211 | +4.269 | +4.461 | H21 | H21 | 2 | 2007 | GALVANISE | S235JR | ATTACHE | 1.03092 | 1.04148 | 0.000131328 | 0.000132672 | 0.047448 | 0.044736 | 192
ATTACHE | STEEL/S235JR | 4315 | 24495.3 | 602.211 | +4.269 | +4.361 | H26 | H26 | 2 | 2007 | GALVANISE | S235JR | ATTACHE | 0.493985 | 0.49904 | 0.000062928 | 0.000063572 | 0.023448 | 0.021436 | 92
ATTACHE | STEEL/S235JR | 4365 | 29592.2 | 602.211 | +4.269 | +4.461 | H21 | H21 | 2 | 2007 | GALVANISE | S235JR | ATTACHE | 1.03092 | 1.04148 | 0.000131328 | 0.000132672 | 0.047448 | 0.044736 | 192
ATTACHE | STEEL/S235JR | 4315 | 29557.8 | 602.211 | +4.269 | +4.361 | H26 | H26 | 2 | 2007 | GALVANISE | S235JR | ATTACHE | 0.493985 | 0.49904 | 0.000062928 | 0.000063572 | 0.023448 | 0.021436 | 92
ATTACHE | STEEL/S235JR | 10865 | 50502.8 | 20652.2 | +10.769 | +10.961 | H27 | H27 | 2 | 2007 | GALVANISE | S235JR | ATTACHE | 1.03092 | 1.04148 | 0.000131328 | 0.000132672 | 0.047448 | 0.044736 | 192
ATTACHE | STEEL/S235JR | 10915 | 50062.8 | 26001.8 | +10.869 | +10.961 | H26 | H26 | 2 | 2007 | GALVANISE | S235JR | ATTACHE | 0.493985 | 0.49904 | 0.000062928 | 0.000063572 | 0.023448 | 0.021436 | 92
ATTACHE | STEEL/S235JR | 10865 | 50062.8 | 26036.2 | +10.769 | +10.961 | H22 | H22 | 2 | 2007 | GALVANISE | S235JR | ATTACHE | 1.03092 | 1.04148 | 0.000131328 | 0.000132672 | 0.047448 | 0.044736 | 192
ATTACHE | STEEL/S235JR | 10865 | 50062.8 | 28864.2 | +10.769 | +10.961 | H27 | H27 | 2 | 2007 | GALVANISE | S235JR | ATTACHE | 1.03092 | 1.04148 | 0.000131328 | 0.000132672 | 0.047448 | 0.044736 | 192
ATTACHE | STEEL/S235JR | 10865 | 50062.8 | 31692.2 | +10.769 | +10.961 | H27 | H27 | 2 | 2007 | GALVANISE | S235JR | ATTACHE | 1.03092 | 1.04148 | 0.000131328 | 0.000132672 | 0.047448 | 0.044736 | 192
ATTACHE | STEEL/S235JR | 10865 | 50062.8 | 20652.2 | +10.769 | +10.961 | H27 | H27 | 2 | 2007 | GALVANISE | S235JR | ATTACHE | 1.03092 | 1.04148 | 0.000131328 | 0.000132672 | 0.047448 | 0.044736 | 192
ATTACHE | STEEL/S235JR | 10865 | 54089.7 | 23173.8 | +10.769 | +10.961 | H27 | H27 | 2 | 2007 | GALVANISE | S235JR | ATTACHE | 1.03092 | 1.04148 | 0.000131328 | 0.000132672 | 0.047448 | 0.044736 | 192
ATTACHE | STEEL/S235JR | 10865 | 56854.7 | 23173.8 | +10.769 | +10.961 | H27 | H27 | 2 | 2007 | GALVANISE | S235JR | ATTACHE | 1.03092 | 1.04148 | 0.000131328 | 0.000132672 | 0.047448 | 0.044736 | 192
ATTACHE | STEEL/S235JR | 10865 | 51342.8 | 20652.2 | +10.769 | +10.961 | H27 | H27 | 2 | 2007 | GALVANISE | S235JR | ATTACHE | 1.03092 | 1.04148 | 0.000131328 | 0.000132672 | 0.047448 | 0.044736 | 192
ATTACHE | STEEL/S235JR | 10815 | 55437.8 | 20652.2 | +10.769 | +10.861 | H26 | H26 | 2 | 2007 | GALVANISE | S235JR | ATTACHE | 0.493985 | 0.49904 | 0.000062928 | 0.000063572 | 0.023448 | 0.021436 | 92
ATTACHE | STEEL/S235JR | 10865 | 55472.2 | 20652.2 | +10.769 | +10.961 | H21 | H21 | 2 | 2007 | GALVANISE | S235JR | ATTACHE | 1.03092 | 1.04148 | 0.000131328 | 0.000132672 | 0.047448 | 0.044736 | 192
ATTACHE | STEEL/S235JR | 10815 | 60967.8 | 20652.2 | +10.769 | +10.861 | H26 | H26 | 2 | 2007 | GALVANISE | S235JR | ATTACHE | 0.493985 | 0.49904 | 0.000062928 | 0.000063572 | 0.023448 | 0.021436 | 92
ATTACHE | STEEL/S235JR | 10865 | 61002.2 | 20652.2 | +10.769 | +10.961 | H21 | H21 | 2 | 2007 | GALVANISE | S235JR | ATTACHE | 1.03092 | 1.04148 | 0.000131328 | 0.000132672 | 0.047448 | 0.044736 | 192
ATTACHE | STEEL/S235JR | 10865 | 59619.7 | 23173.8 | +10.769 | +10.961 | H27 | H27 | 2 | 2007 | GALVANISE | S235JR | ATTACHE | 1.03092 | 1.04148 | 0.000131328 | 0.000132672 | 0.047448 | 0.044736 | 192
ATTACHE | STEEL/S235JR | 4365 | 40267.2 | 602.211 | +4.269 | +4.461 | H21 | H21 | 2 | 2007 | GALVANISE | S235JR | ATTACHE | 1.03092 | 1.04148 | 0.000131328 | 0.000132672 | 0.047448 | 0.044736 | 192
ATTACHE | STEEL/S235JR | 4315 | 34895.3 | 602.211 | +4.269 | +4.361 | H26 | H26 | 2 | 2007 | GALVANISE | S235JR | ATTACHE | 0.493985 | 0.49904 | 0.000062928 | 0.000063572 | 0.023448 | 0.021436 | 92
ATTACHE | STEEL/S235JR | 4365 | 34929.7 | 602.211 | +4.269 | +4.461 | H21 | H21 | 2 | 2007 | GALVANISE | S235JR | ATTACHE | 1.03092 | 1.04148 | 0.000131328 | 0.000132672 | 0.047448 | 0.044736 | 192
POTEAUX | STEEL/E24-2 | 1197.5 | 60962.2 | 79309.3 | +0.000 | +2.395 | 435 | P14 | 1 | 1001 | GRENAILLE-PEINT | E24-2 | POTEAUX | 12.8597 | 12.9913 | 0.00163818 | 0.00165494 | 0.576168 | 0.558035 | 2395
POTEAUX | STEEL/E24-2 | 1197.5 | 64617.8 | 79317.8 | +0.000 | +2.395 | 435 | P15 | 1 | 1001 | GRENAILLE-PEINT | E24-2 | POTEAUX | 12.8597 | 12.9913 | 0.00163818 | 0.00165494 | 0.576168 | 0.558035 | 2395
ATTACHE | STEEL/S235JR | 4315 | 40232.8 | 602.211 | +4.269 | +4.361 | H26 | H26 | 2 | 2007 | GALVANISE | S235JR | ATTACHE | 0.493985 | 0.49904 | 0.000062928 | 0.000063572 | 0.023448 | 0.021436 | 92
ATTACHE | STEEL/S235JR | 10865 | 65987.2 | 23173.8 | +10.769 | +10.961 | H27 | H27 | 2 | 2007 | GALVANISE | S235JR | ATTACHE | 1.03092 | 1.04148 | 0.000131328 | 0.000132672 | 0.047448 | 0.044736 | 192
ATTACHE | STEEL/S235JR | 4365 | 45783.9 | 602.211 | +4.269 | +4.461 | H21 | H21 | 2 | 2007 | GALVANISE | S235JR | ATTACHE | 1.03092 | 1.04148 | 0.000131328 | 0.000132672 | 0.047448 | 0.044736 | 192
ATTACHE | STEEL/S235JR | 4315 | 45749.4 | 602.211 | +4.269 | +4.361 | H26 | H26 | 2 | 2007 | GALVANISE | S235JR | ATTACHE | 0.493985 | 0.49904 | 0.000062928 | 0.000063572 | 0.023448 | 0.021436 | 92
ATTACHE | STEEL/S235JR | 4365 | 49342.8 | 8357.21 | +4.269 | +4.461 | H27 | H27 | 2 | 2007 | GALVANISE | S235JR | ATTACHE | 1.03092 | 1.04148 | 0.000131328 | 0.000132672 | 0.047448 | 0.044736 | 192
ATTACHE | STEEL/S235JR | 4365 | 49342.8 | 5708.88 | +4.269 | +4.461 | H22 | H22 | 2 | 2007 | GALVANISE | S235JR | ATTACHE | 1.03092 | 1.04148 | 0.000131328 | 0.000132672 | 0.047448 | 0.044736 | 192
ATTACHE | STEEL/S235JR | 4415 | 49342.8 | 5674.46 | +4.369 | +4.461 | H26 | H26 | 2 | 2007 | GALVANISE | S235JR | ATTACHE | 0.493985 | 0.49904 | 0.000062928 | 0.000063572 | 0.023448 | 0.021436 | 92
ATTACHE | STEEL/S235JR | 4365 | 49342.8 | 602.211 | +4.269 | +4.461 | H27 | H27 | 2 | 2007 | GALVANISE | S235JR | ATTACHE | 1.03092 | 1.04148 | 0.000131328 | 0.000132672 | 0.047448 | 0.044736 | 192
ATTACHE | STEEL/S235JR | 10865 | 66427.2 | 23173.8 | +10.769 | +10.961 | H27 | H27 | 2 | 2007 | GALVANISE | S235JR | ATTACHE | 1.03092 | 1.04148 | 0.000131328 | 0.000132672 | 0.047448 | 0.044736 | 192
ATTACHE | STEEL/S235JR | 10865 | 65097.2 | 23173.8 | +10.769 | +10.961 | H27 | H27 | 2 | 2007 | GALVANISE | S235JR | ATTACHE | 1.03092 | 1.04148 | 0.000131328 | 0.000132672 | 0.047448 | 0.044736 | 192
ATTACHE | STEEL/S235JR | 10865 | 51342.8 | 28864.2 | +10.769 | +10.961 | H27 | H27 | 2 | 2007 | GALVANISE | S235JR | ATTACHE | 1.03092 | 1.04148 | 0.000131328 | 0.000132672 | 0.047448 | 0.044736 | 192
ATTACHE | STEEL/S235JR | 10865 | 51342.8 | 31692.2 | +10.769 | +10.961 | H27 | H27 | 2 | 2007 | GALVANISE | S235JR | ATTACHE | 1.03092 | 1.04148 | 0.000131328 | 0.000132672 | 0.047448 | 0.044736 | 192
ATTACHE | STEEL/S235JR | 10865 | 51342.8 | 26036.2 | +10.769 | +10.961 | H22 | H22 | 2 | 2007 | GALVANISE | S235JR | ATTACHE | 1.03092 | 1.04148 | 0.000131328 | 0.000132672 | 0.047448 | 0.044736 | 192
ATTACHE | STEEL/S235JR | 10915 | 51342.8 | 26001.8 | +10.869 | +10.961 | H26 | H26 | 2 | 2007 | GALVANISE | S235JR | ATTACHE | 0.493985 | 0.49904 | 0.000062928 | 0.000063572 | 0.023448 | 0.021436 | 92
ATTACHE | STEEL/S235JR | 10865 | 62384.7 | 23173.8 | +10.769 | +10.961 | H27 | H27 | 2 | 2007 | GALVANISE | S235JR | ATTACHE | 1.03092 | 1.04148 | 0.000131328 | 0.000132672 | 0.047448 | 0.044736 | 192
ATTACHE | STEEL/S235JR | 4365 | 49342.8 | 3060.54 | +4.269 | +4.461 | H27 | H27 | 2 | 2007 | GALVANISE | S235JR | ATTACHE | 1.03092 | 1.04148 | 0.000131328 | 0.000132672 | 0.047448 | 0.044736 | 192
ATTACHE | STEEL/S235JR | 4415 | 49342.8 | -347.789 | +4.369 | +4.461 | H26 | H26 | 2 | 2007 | GALVANISE | S235JR | ATTACHE | 0.493985 | 0.49904 | 0.000062928 | 0.000063572 | 0.023448 | 0.021436 | 92
MONTANT | STEEL/E24-2 | 4744 | 26151.3 | 55757.2 | +3.880 | +5.608 | 407 | M6 | 4 | 4001 | GRENAILLE-PEINT | E24-2 | MONTANT | 9.27832 | 9.37328 | 0.00118195 | 0.00119405 | 0.416088 | 0.402624 | 1728

# IfcColumn: L70*50*6 (6)
In: Undefined
Description: L70*50*6; Material: STEEL/E24-2
Tekla Common - Center of gravity Z: 3170 mm; Bottom elevation: +3.020; Top elevation: +3.320; Part mark: H92; Assembly mark: H92; Phase: 2; Class: 2003; Finish: GRENAILLE-PEINT; Grade: E24-2; Profile: L70*50*6; Name: ATTACHE; sets with these values: 2
Tekla Quantity - Net weight: 1.61081 kg; Gross weight: 1.62023 kg; Weight: 1.62023 kg; Net volume: 0.000205199 m3; Gross volume: 0.000206399 m3; Gross footprint area: 0.000684 m2; Area per tons: 42.5863 m2; Net surface area: 0.0733677 m2; Gross area: 0.0689997 m2; Height: 70 mm; Width: 50 mm; Length: 299.999 mm; sets with these values: 2
BaseQuantities - Length: 299.999 mm; OuterSurfaceArea: 0.0689997 m2; NetVolume: 0.000205199 m3; NetWeight: 1.61081 kg
Name | Center of gravity Y (mm) | Center of gravity X (mm)
ATTACHE | 10792.7 | 8660.4
ATTACHE | 17174.4 | 5541.06
ATTACHE | 32092.8 | 2480.3
ATTACHE | 26892.8 | 2943.79
ATTACHE | 12919.4 | 7478.35
ATTACHE | 21832.1 | 4000.81

# IfcColumn: L70*7 (49)
In: Undefined
Description: L70*7
Tekla Common - Finish: GRENAILLE-PEINT; Profile: L70*7; sets with these values: 2
Tekla Quantity - Area per tons: 36.8614 m2; Height: 70 mm; sets with these values: 2
Name | Material | BaseQuantities, Length (mm) = Tekla Quantity, Length (mm) | OuterSurfaceArea (m2) = Gross area (m2) | NetVolume (m3) = Net volume (m3) | NetWeight (kg) = Net weight (kg) | Center of gravity Z (mm) | Center of gravity Y (mm) | Center of gravity X (mm) | Bottom elevation | Top elevation | Part mark | Assembly mark | Phase | Class | Grade | Gross weight (kg) = Weight (kg) | Gross volume (m3) | Gross footprint area (m2) | Net surface area (m2) | Width (mm) | Name
 | STEEL/E24-2 | 60 | 0.01632 | 0.00005586 | 0.438501 | 3468.43 | 13120.1 | 629.921 | +3.438 | +3.498 | 668 | S7 | 6 | 6001 | E24-2 | 0.44274 | 0.0000564 | 0.000931 | 0.018662 | 70
 | STEEL/E24-2 | 60 | 0.01632 | 0.00005586 | 0.438501 | 3468.43 | 13120.1 | 3294.92 | +3.438 | +3.498 | 668 | S5 | 6 | 6001 | E24-2 | 0.44274 | 0.0000564 | 0.000931 | 0.018662 | 70
ATTACHE | STEEL/S235JR | 160.003 | 0.0435207 | 0.000148962 | 1.16936 | 3911.87 | 49341.9 | 24.3726 | +3.832 | +3.992 | H37 | H37 | 2 | 2005 | S235JR | 1.18066 | 0.000150403 | 0.000931 | 0.0466627 | 70 | ATTACHE
ATTACHE | STEEL/S235JR | 180.003 | 0.0489607 | 0.000167582 | 1.31552 | 3901.87 | 48501.9 | 24.3726 | +3.812 | +3.992 | H35 | H35 | 2 | 2005 | S235JR | 1.32824 | 0.000169202 | 0.000931 | 0.0522627 | 70 | ATTACHE
ATTACHE | STEEL/S235JR | 180.003 | 0.0489607 | 0.000167582 | 1.31552 | 3588.83 | 45789.8 | 20753.9 | +3.499 | +3.679 | H35 | H35 | 2 | 2005 | S235JR | 1.32824 | 0.000169202 | 0.000931 | 0.0522627 | 70 | ATTACHE
ATTACHE | STEEL/S235JR | 180.003 | 0.0489607 | 0.000167582 | 1.31552 | 3901.87 | 45743.6 | 24.3726 | +3.812 | +3.992 | H35 | H35 | 2 | 2005 | S235JR | 1.32824 | 0.000169202 | 0.000931 | 0.0522627 | 70 | ATTACHE
ATTACHE | STEEL/S235JR | 180.003 | 0.0489607 | 0.000167582 | 1.31552 | 3901.87 | 42985.2 | 24.3726 | +3.812 | +3.992 | H35 | H35 | 2 | 2005 | S235JR | 1.32824 | 0.000169202 | 0.000931 | 0.0522627 | 70 | ATTACHE
ATTACHE | STEEL/S235JR | 180.003 | 0.0489607 | 0.000167582 | 1.31552 | 3588.83 | 43031.4 | 20753.9 | +3.499 | +3.679 | H35 | H35 | 2 | 2005 | S235JR | 1.32824 | 0.000169202 | 0.000931 | 0.0522627 | 70 | ATTACHE
ATTACHE | STEEL/S235JR | 180.003 | 0.0489607 | 0.000167582 | 1.31552 | 3901.87 | 40226.9 | 24.3726 | +3.812 | +3.992 | H35 | H35 | 2 | 2005 | S235JR | 1.32824 | 0.000169202 | 0.000931 | 0.0522627 | 70 | ATTACHE
ATTACHE | STEEL/S235JR | 180.003 | 0.0489607 | 0.000167582 | 1.31552 | 3587 | 40273.1 | 20694.9 | +3.497 | +3.677 | H35 | H35 | 2 | 2005 | S235JR | 1.32824 | 0.000169202 | 0.000931 | 0.0522627 | 70 | ATTACHE
ATTACHE | STEEL/S235JR | 180.003 | 0.0489607 | 0.000167582 | 1.31552 | 3901.87 | 10906.9 | 24.3726 | +3.812 | +3.992 | H35 | H35 | 2 | 2005 | S235JR | 1.32824 | 0.000169202 | 0.000931 | 0.0522627 | 70 | ATTACHE
ATTACHE | STEEL/S235JR | 180.003 | 0.0489607 | 0.000167582 | 1.31552 | 3588.83 | 10953.1 | 20753.9 | +3.499 | +3.679 | H35 | H35 | 2 | 2005 | S235JR | 1.32824 | 0.000169202 | 0.000931 | 0.0522627 | 70 | ATTACHE
ATTACHE | STEEL/S235JR | 180.003 | 0.0489607 | 0.000167582 | 1.31552 | 3901.87 | 13036.9 | 24.3726 | +3.812 | +3.992 | H35 | H35 | 2 | 2005 | S235JR | 1.32824 | 0.000169202 | 0.000931 | 0.0522627 | 70 | ATTACHE
ATTACHE | STEEL/S235JR | 180.003 | 0.0489607 | 0.000167582 | 1.31552 | 3588.83 | 13083.1 | 20753.9 | +3.499 | +3.679 | H35 | H35 | 2 | 2005 | S235JR | 1.32824 | 0.000169202 | 0.000931 | 0.0522627 | 70 | ATTACHE
ATTACHE | STEEL/S235JR | 180.003 | 0.0489607 | 0.000167582 | 1.31552 | 3588.83 | 15213.1 | 20753.9 | +3.499 | +3.679 | H35 | H35 | 2 | 2005 | S235JR | 1.32824 | 0.000169202 | 0.000931 | 0.0522627 | 70 | ATTACHE
ATTACHE | STEEL/S235JR | 180.003 | 0.0489607 | 0.000167582 | 1.31552 | 3901.87 | 15166.9 | 24.3726 | +3.812 | +3.992 | H35 | H35 | 2 | 2005 | S235JR | 1.32824 | 0.000169202 | 0.000931 | 0.0522627 | 70 | ATTACHE
ATTACHE | STEEL/S235JR | 180.003 | 0.0489607 | 0.000167582 | 1.31552 | 3588.83 | 17343.1 | 20753.9 | +3.499 | +3.679 | H35 | H35 | 2 | 2005 | S235JR | 1.32824 | 0.000169202 | 0.000931 | 0.0522627 | 70 | ATTACHE
ATTACHE | STEEL/S235JR | 180.003 | 0.0489607 | 0.000167582 | 1.31552 | 3901.87 | 17296.9 | 24.3726 | +3.812 | +3.992 | H35 | H35 | 2 | 2005 | S235JR | 1.32824 | 0.000169202 | 0.000931 | 0.0522627 | 70 | ATTACHE
ATTACHE | STEEL/S235JR | 180.003 | 0.0489607 | 0.000167582 | 1.31552 | 3587 | 19473.1 | 20694.9 | +3.497 | +3.677 | H35 | H35 | 2 | 2005 | S235JR | 1.32824 | 0.000169202 | 0.000931 | 0.0522627 | 70 | ATTACHE
ATTACHE | STEEL/S235JR | 180.003 | 0.0489607 | 0.000167582 | 1.31552 | 3901.87 | 19426.9 | 24.3726 | +3.812 | +3.992 | H35 | H35 | 2 | 2005 | S235JR | 1.32824 | 0.000169202 | 0.000931 | 0.0522627 | 70 | ATTACHE
ATTACHE | STEEL/S235JR | 180.003 | 0.0489607 | 0.000167582 | 1.31552 | 3901.87 | 27020.6 | 24.3726 | +3.812 | +3.992 | H35 | H35 | 2 | 2005 | S235JR | 1.32824 | 0.000169202 | 0.000931 | 0.0522627 | 70 | ATTACHE
ATTACHE | STEEL/S235JR | 180.003 | 0.0489607 | 0.000167582 | 1.31552 | 3901.87 | 32220.6 | 24.3726 | +3.812 | +3.992 | H35 | H35 | 2 | 2005 | S235JR | 1.32824 | 0.000169202 | 0.000931 | 0.0522627 | 70 | ATTACHE
ATTACHE | STEEL/S235JR | 180.003 | 0.0489607 | 0.000167582 | 1.31552 | 3901.87 | 37558.1 | 24.3726 | +3.812 | +3.992 | H35 | H35 | 2 | 2005 | S235JR | 1.32824 | 0.000169202 | 0.000931 | 0.0522627 | 70 | ATTACHE
 | STEEL/E24-2 | 274 | 0.074528 | 0.000255094 | 2.00249 | 5741.5 | 69131.9 | 44085.1 | +5.604 | +5.878 | 613 | P26 | 1 | 1001 | E24-2 | 2.02185 | 0.00025756 | 0.000931 | 0.078582 | 70
 | STEEL/E24-2 | 274 | 0.074528 | 0.000255094 | 2.00249 | 5741.5 | 69131.9 | 55760.1 | +5.604 | +5.878 | 613 | P27 | 1 | 1001 | E24-2 | 2.02185 | 0.00025756 | 0.000931 | 0.078582 | 70
 | STEEL/E24-2 | 274 | 0.074528 | 0.000255094 | 2.00249 | 5741.5 | 69131.9 | 67435.1 | +5.604 | +5.878 | 613 | P23 | 1 | 1001 | E24-2 | 2.02185 | 0.00025756 | 0.000931 | 0.078582 | 70
ATTACHE | STEEL/S235JR | 180.003 | 0.0489607 | 0.000167582 | 1.31552 | 3588.83 | 24535.6 | 20753.9 | +3.499 | +3.679 | H35 | H35 | 2 | 2005 | S235JR | 1.32824 | 0.000169202 | 0.000931 | 0.0522627 | 70 | ATTACHE
ATTACHE | STEEL/S235JR | 180.003 | 0.0489607 | 0.000167582 | 1.31552 | 3901.87 | 21958.1 | 24.3726 | +3.812 | +3.992 | H35 | H35 | 2 | 2005 | S235JR | 1.32824 | 0.000169202 | 0.000931 | 0.0522627 | 70 | ATTACHE
ATTACHE | STEEL/S235JR | 180.003 | 0.0489607 | 0.000167582 | 1.31552 | 3901.87 | 24489.4 | 24.3726 | +3.812 | +3.992 | H35 | H35 | 2 | 2005 | S235JR | 1.32824 | 0.000169202 | 0.000931 | 0.0522627 | 70 | ATTACHE
ATTACHE | STEEL/S235JR | 180.003 | 0.0489607 | 0.000167582 | 1.31552 | 3588.83 | 27066.9 | 20753.9 | +3.499 | +3.679 | H35 | H35 | 2 | 2005 | S235JR | 1.32824 | 0.000169202 | 0.000931 | 0.0522627 | 70 | ATTACHE
ATTACHE | STEEL/S235JR | 180.003 | 0.0489607 | 0.000167582 | 1.31552 | 3588.83 | 22004.4 | 20753.9 | +3.499 | +3.679 | H35 | H35 | 2 | 2005 | S235JR | 1.32824 | 0.000169202 | 0.000931 | 0.0522627 | 70 | ATTACHE
ATTACHE | STEEL/S235JR | 220 | 0.05984 | 0.00020482 | 1.60784 | -110 | 7625.92 | 44485.1 | -0.220 | -0.000 | H36 | H36 | 1 | 1002 | S235JR | 1.62338 | 0.0002068 | 0.000931 | 0.063462 | 70 | ATTACHE
ATTACHE | STEEL/S235JR | 220 | 0.05984 | 0.00020482 | 1.60784 | 3990.28 | 7674.08 | 55719.9 | +3.880 | +4.100 | H36 | H36 | 1 | 1002 | S235JR | 1.62338 | 0.0002068 | 0.000931 | 0.063462 | 70 | ATTACHE
ATTACHE | STEEL/S235JR | 220 | 0.05984 | 0.00020482 | 1.60784 | 5349.37 | 7625.92 | 44485.1 | +5.239 | +5.459 | H36 | H36 | 1 | 1002 | S235JR | 1.62338 | 0.0002068 | 0.000931 | 0.063462 | 70 | ATTACHE
ATTACHE | STEEL/S235JR | 220 | 0.05984 | 0.00020482 | 1.60784 | -110 | 7674.08 | 55719.9 | -0.220 | -0.000 | H36 | H36 | 1 | 1002 | S235JR | 1.62338 | 0.0002068 | 0.000931 | 0.063462 | 70 | ATTACHE
ATTACHE | STEEL/S235JR | 220 | 0.05984 | 0.00020482 | 1.60784 | 5349.37 | 61025.9 | 44485.1 | +5.239 | +5.459 | H36 | H36 | 1 | 1002 | S235JR | 1.62338 | 0.0002068 | 0.000931 | 0.063462 | 70 | ATTACHE
ATTACHE | STEEL/S235JR | 220 | 0.05984 | 0.00020482 | 1.60784 | 3990.28 | 61074.1 | 55719.9 | +3.880 | +4.100 | H36 | H36 | 1 | 1002 | S235JR | 1.62338 | 0.0002068 | 0.000931 | 0.063462 | 70 | ATTACHE
ATTACHE | STEEL/S235JR | 220 | 0.05984 | 0.00020482 | 1.60784 | -110 | 61074.1 | 55719.9 | -0.220 | +0.000 | H36 | H36 | 1 | 1002 | S235JR | 1.62338 | 0.0002068 | 0.000931 | 0.063462 | 70 | ATTACHE
ATTACHE | STEEL/S235JR | 220 | 0.05984 | 0.00020482 | 1.60784 | -110 | 61025.9 | 44485.1 | -0.220 | +0.000 | H36 | H36 | 1 | 1002 | S235JR | 1.62338 | 0.0002068 | 0.000931 | 0.063462 | 70 | ATTACHE
 | STEEL/E24-2 | 277.902 | 0.0755895 | 0.000256707 | 2.01515 | 5066.22 | 54.9211 | 74814.9 | +4.928 | +5.206 | 615 | K28 | 1 | 1010 | E24-2 | 2.05064 | 0.000261228 | 0 | 0.079068 | 70
 | STEEL/E24-2 | 123.6 | 0.0336192 | 0.0000804636 | 0.631639 | 4938.2 | 67.7903 | 70972.8 | +4.876 | +5.000 | 616 | P109 | 1 | 1003 | E24-2 | 0.912044 | 0.000116184 | 0.000651 | 0.026022 | 30
ATTACHE | STEEL/S235JR | 180.003 | 0.0489607 | 0.000167582 | 1.31552 | 3588.83 | 37604.4 | 20753.9 | +3.499 | +3.679 | H35 | H35 | 2 | 2005 | S235JR | 1.32824 | 0.000169202 | 0.000931 | 0.0522627 | 70 | ATTACHE
ATTACHE | STEEL/S235JR | 180.003 | 0.0489607 | 0.000167582 | 1.31552 | 3588.83 | 32266.9 | 20753.9 | +3.499 | +3.679 | H35 | H35 | 2 | 2005 | S235JR | 1.32824 | 0.000169202 | 0.000931 | 0.0522627 | 70 | ATTACHE
 | STEEL/E24-2 | 60 | 0.01632 | 0.00005586 | 0.438501 | 3468.43 | 17380.1 | 3294.92 | +3.438 | +3.498 | 668 | S5 | 6 | 6001 | E24-2 | 0.44274 | 0.0000564 | 0.000931 | 0.018662 | 70
 | STEEL/E24-2 | 60 | 0.01632 | 0.00005586 | 0.438501 | 3468.43 | 17380.1 | 629.921 | +3.438 | +3.498 | 668 | S7 | 6 | 6001 | E24-2 | 0.44274 | 0.0000564 | 0.000931 | 0.018662 | 70
 | STEEL/E24-2 | 60 | 0.01632 | 0.00005586 | 0.438501 | 3468.43 | 22041.3 | 629.921 | +3.438 | +3.498 | 668 | S7 | 6 | 6001 | E24-2 | 0.44274 | 0.0000564 | 0.000931 | 0.018662 | 70
 | STEEL/E24-2 | 60 | 0.01632 | 0.00005586 | 0.438501 | 3468.43 | 22041.3 | 3294.92 | +3.438 | +3.498 | 668 | S5 | 6 | 6001 | E24-2 | 0.44274 | 0.0000564 | 0.000931 | 0.018662 | 70
 | STEEL/E24-2 | 60 | 0.01632 | 0.00005586 | 0.438501 | 3468.43 | 27103.8 | 629.921 | +3.438 | +3.498 | 668 | S10 | 6 | 6001 | E24-2 | 0.44274 | 0.0000564 | 0.000931 | 0.018662 | 70
 | STEEL/E24-2 | 60 | 0.01632 | 0.00005586 | 0.438501 | 3468.43 | 32303.8 | 629.921 | +3.438 | +3.498 | 668 | S10 | 6 | 6001 | E24-2 | 0.44274 | 0.0000564 | 0.000931 | 0.018662 | 70

# IfcColumn: L80*8 (5)
In: Undefined
Description: L80*8; Material: STEEL/E24-2
Tekla Common - Finish: GRENAILLE-PEINT; Grade: E24-2; Profile: L80*8; sets with these values: 2
Tekla Quantity - Net weight: 0.95456 kg; Gross weight: 0.96555 kg; Weight: 0.96555 kg; Net volume: 0.0001216 m3; Gross volume: 0.000123 m3; Gross footprint area: 0.001216 m2; Area per tons: 32.2096 m2; Net surface area: 0.034432 m2; Gross area: 0.0311 m2; Height: 80 mm; Width: 80 mm; Length: 100 mm; sets with these values: 2
BaseQuantities - Length: 100 mm; OuterSurfaceArea: 0.0311 m2; NetVolume: 0.0001216 m3; NetWeight: 0.95456 kg
Name | Center of gravity Z (mm) | Center of gravity Y (mm) | Center of gravity X (mm) | Bottom elevation | Top elevation | Part mark | Assembly mark | Phase | Class
 | -150 | -202.053 | 78312.1 | -0.200 | -0.100 | 1221 | P112 | 1 | 1003
 | -150 | -202.053 | 73777.1 | -0.200 | -0.100 | 1221 | P110 | 1 | 1003
 | -150 | -202.053 | 59772.1 | -0.200 | -0.100 | 1221 | P45 | 1 | 1003
 | -150 | 31267.1 | 79312.1 | -0.200 | -0.100 | 1221 | P48 | 1 | 1003
ATTACHE | 3695.29 | 21857.3 | 78232.1 | +3.645 | +3.745 | H60 | H60 | 7 | 7001 | Tekla Common - Name: ATTACHE

# IfcColumn: L90*9, ATTACHE
In: Undefined
Description: L90*9; Material: STEEL/E24-2
Tekla Common - Center of gravity Z: 3820 mm; Center of gravity Y: 13680.8 mm; Center of gravity X: 71845.9 mm; Bottom elevation: +3.685; Top elevation: +3.955; Part mark: H75; Assembly mark: H75; Phase: 1; Class: 1011; Finish: GRENAILLE-PEINT; Grade: E24-2; Profile: L90*9; Name: ATTACHE; sets with these values: 2
Tekla Quantity - Net weight: 3.26191 kg; Gross weight: 3.28523 kg; Weight: 3.28523 kg; Net volume: 0.00041553 m3; Gross volume: 0.0004185 m3; Gross footprint area: 0.001539 m2; Area per tons: 28.8473 m2; Net surface area: 0.100278 m2; Gross area: 0.09477 m2; Height: 90 mm; Width: 90 mm; Length: 270 mm; sets with these values: 2
BaseQuantities - Length: 270 mm; OuterSurfaceArea: 0.09477 m2; NetVolume: 0.00041553 m3; NetWeight: 3.26191 kg

# IfcColumn: PL100*10 (5)
In: Undefined
Description: PL100*10; Material: STEEL/E24-2
Tekla Common - Phase: 1; Finish: GRENAILLE-PEINT; Grade: E24-2; Profile: PL100*10; sets with these values: 2
Tekla Quantity - Gross footprint area: 0.001 m2; Height: 100 mm; Width: 10 mm; sets with these values: 2
Name | Center of gravity Z (mm) | Center of gravity Y (mm) | Center of gravity X (mm) | Bottom elevation | Top elevation | Part mark | Assembly mark | Class | Net weight (kg) = Gross weight (kg) = Weight (kg) = NetWeight (kg) | Net volume (m3) = Gross volume (m3) = NetVolume (m3) | Area per tons (m2) | Net surface area (m2) = Gross area (m2) = OuterSurfaceArea (m2) | Tekla Quantity, Length (mm) = BaseQuantities, Length (mm)
 | -150 | -220 | 78465 | -0.200 | -0.100 | 190 | P112 | 1003 | 0.785 | 0.0001 | 30.5732 | 0.024 | 100
 | -150 | -220 | 73930 | -0.200 | -0.100 | 190 | P110 | 1003 | 0.785 | 0.0001 | 30.5732 | 0.024 | 100
 | -150 | -220 | 59915 | -0.200 | -0.100 | 190 | P45 | 1003 | 0.785 | 0.0001 | 30.5732 | 0.024 | 100
PLATINE | 2126.86 | 13542.2 | 79225 | +2.027 | +2.227 | 243 | B4 | 1002 | 1.57 | 0.0002 | 29.2994 | 0.046 | 200 | Tekla Common - Name: PLATINE
 | -150 | 31410 | 79330 | -0.200 | -0.100 | 190 | P48 | 1003 | 0.785 | 0.0001 | 30.5732 | 0.024 | 100

# IfcColumn: PL100*5 (11)
In: Undefined
Description: PL100*5; Material: STEEL/S235JR
Tekla Common - Part mark: 1201; Phase: 4; Class: 4000; Finish: GALVANISE; Grade: S235JR; Profile: PL100*5; Name: SUPPORT; sets with these values: 2
Tekla Quantity - Net weight: 0.712584 kg; Gross weight: 0.785 kg; Weight: 0.712584 kg; Net volume: 0.000090775 m3; Gross volume: 0.0001 m3; Gross footprint area: 0.0005 m2; Area per tons: 57.1021 m2; Net surface area: 0.04069 m2; Gross area: 0.043 m2; Height: 100 mm; Width: 5 mm; Length: 200 mm; sets with these values: 2
BaseQuantities - Length: 200 mm; OuterSurfaceArea: 0.04069 m2; NetVolume: 0.000090775 m3; NetWeight: 0.712584 kg
Name | Center of gravity Z (mm) | Center of gravity Y (mm) | Center of gravity X (mm) | Bottom elevation | Top elevation | Assembly mark
SUPPORT | 5089.91 | 18344 | 71869.5 | +4.990 | +5.190 | E1
SUPPORT | 5440 | 26056 | 55742.5 | +5.340 | +5.540 | E2
SUPPORT | 4790 | 26056 | 55742.5 | +4.690 | +4.890 | E2
SUPPORT | 4790 | 26056 | 44067.5 | +4.690 | +4.890 | E2
SUPPORT | 5440 | 26056 | 44067.5 | +5.340 | +5.540 | E2
SUPPORT | 4790 | 26056 | 32392.5 | +4.690 | +4.890 | E2
SUPPORT | 5440 | 26056 | 32392.5 | +5.340 | +5.540 | E2
SUPPORT | 4790 | 23156 | 67417.5 | +4.690 | +4.890 | E2
SUPPORT | 5440 | 23156 | 67417.5 | +5.340 | +5.540 | E2
SUPPORT | 4439.82 | 18344 | 71869.5 | +4.340 | +4.540 | E1
SUPPORT | 5740 | 18344 | 71869.5 | +5.640 | +5.840 | E1

# IfcColumn: PL120*10 (3)
In: Undefined
Description: PL120*10; Material: STEEL/E24-2
Tekla Common - Center of gravity X: 79225 mm; Part mark: 242; Phase: 1; Class: 1002; Finish: GRENAILLE-PEINT; Grade: E24-2; Profile: PL120*10; Name: PLATINE; sets with these values: 2
Tekla Quantity - Net weight: 2.2608 kg; Gross weight: 2.2608 kg; Weight: 2.2608 kg; Net volume: 0.000288 m3; Gross volume: 0.000288 m3; Gross footprint area: 0.0012 m2; Area per tons: 28.6624 m2; Net surface area: 0.0648 m2; Gross area: 0.0648 m2; Height: 120 mm; Width: 10 mm; Length: 240 mm; sets with these values: 2
BaseQuantities - Length: 240 mm; OuterSurfaceArea: 0.0648 m2; NetVolume: 0.000288 m3; NetWeight: 2.2608 kg
Name | Center of gravity Z (mm) | Center of gravity Y (mm) | Bottom elevation | Top elevation | Assembly mark
PLATINE | 3974.78 | 19442.2 | +3.855 | +4.095 | B1
PLATINE | 3974.78 | 24642.2 | +3.855 | +4.095 | B2
PLATINE | 4984.38 | 29842.2 | +4.864 | +5.104 | B3

# IfcColumn: PL140*10 (8)
In: Undefined
Description: PL140*10
Tekla Common - Center of gravity Z: 4956.4 mm; Bottom elevation: +4.871; Top elevation: +5.041; Finish: GRENAILLE-PEINT; Profile: PL140*10; Name: ATTACHE; sets with these values: 2
Tekla Quantity - Net weight: 1.86827 kg; Gross weight: 1.86827 kg; Weight: 1.86827 kg; Net volume: 0.000237996 m3; Gross volume: 0.000237996 m3; Gross footprint area: 0.0014 m2; Area per tons: 28.7963 m2; Net surface area: 0.0537992 m2; Gross area: 0.0537992 m2; Height: 140 mm; Width: 10 mm; Length: 169.997 mm; sets with these values: 2
BaseQuantities - Length: 169.997 mm; OuterSurfaceArea: 0.0537992 m2; NetVolume: 0.000237996 m3; NetWeight: 1.86827 kg
Name | Material | Center of gravity Y (mm) | Center of gravity X (mm) | Part mark | Assembly mark | Phase | Class | Grade
ATTACHE | STEEL/S235JR | 69158.1 | 50037.5 | 210 | H6 | 1 | 1001 | S235JR
ATTACHE | STEEL/S235JR | 69237 | 50037.5 | 210 | H6 | 1 | 1001 | S235JR
ATTACHE | STEEL/S235JR | 69237 | 61712.5 | 210 | H6 | 1 | 1001 | S235JR
ATTACHE | STEEL/S235JR | 69158.1 | 61712.5 | 210 | H6 | 1 | 1001 | S235JR
ATTACHE | STEEL/S235JR | 69237 | 73387.5 | 210 | H6 | 1 | 1001 | S235JR
ATTACHE | STEEL/S235JR | 69158.1 | 73387.5 | 210 | H6 | 1 | 1001 | S235JR
ATTACHE | STEEL/E24-2 | 69237 | 38362.5 | 183 | H1 | 3 | 3001 | E24-2
ATTACHE | STEEL/E24-2 | 69158.1 | 38362.5 | 183 | H1 | 3 | 3001 | E24-2

# IfcColumn: PL20*160 (32)
In: Undefined
Description: PL20*160; Material: STEEL/E36-3
Tekla Common - Finish: GRENAILLE-PEINT; Grade: E36-3; Profile: PL20*160; Name: PLATINE; sets with these values: 2
Tekla Quantity - Gross footprint area: 0.0032 m2; Height: 160 mm; Width: 20 mm; sets with these values: 2
Name | Center of gravity Z (mm) | Center of gravity Y (mm) | Center of gravity X (mm) | Bottom elevation | Top elevation | Part mark | Assembly mark | Phase | Class | Net weight (kg) = Gross weight (kg) = Weight (kg) = NetWeight (kg) | Net volume (m3) = Gross volume (m3) = NetVolume (m3) | Area per tons (m2) | Net surface area (m2) = Gross area (m2) = OuterSurfaceArea (m2) | Tekla Quantity, Length (mm) = BaseQuantities, Length (mm)
PLATINE | 4088.5 | 40265.1 | 20850 | +3.868 | +4.308 | 315 | N46 | 2 | 2006 | 11.0528 | 0.001408 | 14.9102 | 0.1648 | 440
PLATINE | 4088.5 | 40265.1 | 32525 | +3.868 | +4.308 | 316 | N43 | 3 | 3003 | 11.0528 | 0.001408 | 14.9102 | 0.1648 | 440
PLATINE | 4088.5 | 7664.3 | 20850 | +3.863 | +4.313 | 314 | N49 | 2 | 2006 | 11.304 | 0.00144 | 14.8974 | 0.1684 | 450
PLATINE | 4088.5 | 19465.1 | 20850 | +3.868 | +4.308 | 315 | N45 | 2 | 2006 | 11.0528 | 0.001408 | 14.9102 | 0.1648 | 440
PLATINE | 4088.5 | 7664.3 | 67550 | +3.863 | +4.313 | 314 | N12 | 1 | 1006 | 11.304 | 0.00144 | 14.8974 | 0.1684 | 450
PLATINE | 4088.5 | 19465.1 | 67550 | +3.868 | +4.308 | 315 | N11 | 1 | 1006 | 11.0528 | 0.001408 | 14.9102 | 0.1648 | 440
PLATINE | 4088.5 | 40265.1 | 67550 | +3.869 | +4.309 | 309 | N6 | 1 | 1006 | 11.0528 | 0.001408 | 14.9102 | 0.1648 | 440
PLATINE | 5741.5 | 68865 | 67550 | +5.582 | +5.902 | 308 | N17 | 1 | 1006 | 8.0384 | 0.001024 | 15.1274 | 0.1216 | 320
PLATINE | 4088.5 | 68865 | 67550 | +3.864 | +4.314 | 314 | N17 | 1 | 1006 | 11.304 | 0.00144 | 14.8974 | 0.1684 | 450
PLATINE | 4088.5 | 61064.3 | 67550 | +3.864 | +4.314 | 314 | N17 | 1 | 1006 | 11.304 | 0.00144 | 14.8974 | 0.1684 | 450
PLATINE | 5741.5 | 61035.7 | 67550 | +5.582 | +5.902 | 308 | N13 | 1 | 1006 | 8.0384 | 0.001024 | 15.1274 | 0.1216 | 320
PLATINE | 5741.5 | 7635.7 | 67550 | +5.581 | +5.901 | 308 | N14 | 1 | 1006 | 8.0384 | 0.001024 | 15.1274 | 0.1216 | 320
PLATINE | 4088.5 | 7664.3 | 55875 | +3.863 | +4.313 | 314 | N47 | 1 | 1006 | 11.304 | 0.00144 | 14.8974 | 0.1684 | 450
PLATINE | 4088.5 | 19465.1 | 55875 | +3.868 | +4.308 | 315 | N10 | 1 | 1006 | 11.0528 | 0.001408 | 14.9102 | 0.1648 | 440
PLATINE | 4088.5 | 40265.1 | 55875 | +3.869 | +4.309 | 315 | N41 | 1 | 1006 | 11.0528 | 0.001408 | 14.9102 | 0.1648 | 440
PLATINE | 5741.5 | 68865 | 55875 | +5.582 | +5.902 | 308 | N38 | 1 | 1006 | 8.0384 | 0.001024 | 15.1274 | 0.1216 | 320
PLATINE | 4088.5 | 68865 | 55875 | +3.864 | +4.314 | 314 | N38 | 1 | 1006 | 11.304 | 0.00144 | 14.8974 | 0.1684 | 450
PLATINE | 4088.5 | 61064.3 | 55875 | +3.864 | +4.314 | 314 | N38 | 1 | 1006 | 11.304 | 0.00144 | 14.8974 | 0.1684 | 450
PLATINE | 5741.5 | 61035.7 | 55875 | +5.582 | +5.902 | 308 | N13 | 1 | 1006 | 8.0384 | 0.001024 | 15.1274 | 0.1216 | 320
PLATINE | 5741.5 | 7635.7 | 55875 | +5.581 | +5.901 | 308 | N16 | 1 | 1006 | 8.0384 | 0.001024 | 15.1274 | 0.1216 | 320
PLATINE | 4088.5 | 7664.3 | 32525 | +3.863 | +4.313 | 314 | N48 | 3 | 3006 | 11.304 | 0.00144 | 14.8974 | 0.1684 | 450
PLATINE | 4088.5 | 19465.1 | 32525 | +3.868 | +4.308 | 315 | N9 | 3 | 3006 | 11.0528 | 0.001408 | 14.9102 | 0.1648 | 440
PLATINE | 5741.5 | 7635.7 | 32525 | +5.581 | +5.901 | 308 | N15 | 3 | 3006 | 8.0384 | 0.001024 | 15.1274 | 0.1216 | 320
PLATINE | 5741.5 | 7635.7 | 20850 | +5.581 | +5.901 | 308 | N18 | 2 | 2006 | 8.0384 | 0.001024 | 15.1274 | 0.1216 | 320
PLATINE | 4088.5 | 7664.3 | 44200 | +3.863 | +4.313 | 314 | N47 | 1 | 1006 | 11.304 | 0.00144 | 14.8974 | 0.1684 | 450
PLATINE | 4088.5 | 19465.1 | 44200 | +3.868 | +4.308 | 315 | N10 | 1 | 1006 | 11.0528 | 0.001408 | 14.9102 | 0.1648 | 440
PLATINE | 4088.5 | 40265.1 | 44200 | +3.869 | +4.309 | 315 | N41 | 1 | 1006 | 11.0528 | 0.001408 | 14.9102 | 0.1648 | 440
PLATINE | 5741.5 | 68865 | 44200 | +5.582 | +5.902 | 308 | N39 | 1 | 1006 | 8.0384 | 0.001024 | 15.1274 | 0.1216 | 320
PLATINE | 4088.5 | 68865 | 44200 | +3.864 | +4.314 | 314 | N39 | 1 | 1006 | 11.304 | 0.00144 | 14.8974 | 0.1684 | 450
PLATINE | 4088.5 | 61064.3 | 44200 | +3.864 | +4.314 | 314 | N39 | 1 | 1006 | 11.304 | 0.00144 | 14.8974 | 0.1684 | 450
PLATINE | 5741.5 | 61035.7 | 44200 | +5.582 | +5.902 | 308 | N42 | 1 | 1006 | 8.0384 | 0.001024 | 15.1274 | 0.1216 | 320
PLATINE | 5741.5 | 7635.7 | 44200 | +5.581 | +5.901 | 308 | N16 | 1 | 1006 | 8.0384 | 0.001024 | 15.1274 | 0.1216 | 320

# IfcColumn: PL25*160 (10)
In: Undefined
Description: PL25*160; Material: STEEL/E36-3
BaseQuantities - Length: 530 mm; OuterSurfaceArea: 0.2041 m2; NetVolume: 0.00212 m3; NetWeight: 16.642 kg
Tekla Common - Center of gravity Z: 5635 mm; Bottom elevation: +5.370; Top elevation: +5.900; Finish: GRENAILLE-PEINT; Grade: E36-3; Profile: PL25*160; Name: PLAT; sets with these values: 2
Tekla Quantity - Net weight: 16.642 kg; Gross weight: 16.642 kg; Weight: 16.642 kg; Net volume: 0.00212 m3; Gross volume: 0.00212 m3; Gross footprint area: 0.004 m2; Area per tons: 12.2642 m2; Net surface area: 0.2041 m2; Gross area: 0.2041 m2; Height: 160 mm; Width: 25 mm; Length: 530 mm; sets with these values: 2
Name | Center of gravity Y (mm) | Center of gravity X (mm) | Part mark | Assembly mark | Phase | Class
PLAT | 40232.4 | 20850 | 142 | N44 | 2 | 2006
PLAT | 19432.4 | 20850 | 142 | N49 | 2 | 2006
PLAT | 40232.4 | 67550 | 132 | N7 | 1 | 1006
PLAT | 19432.4 | 67550 | 142 | N12 | 1 | 1006
PLAT | 40232.4 | 55875 | 142 | N8 | 1 | 1006
PLAT | 19432.4 | 55875 | 142 | N47 | 1 | 1006
PLAT | 40232.4 | 32525 | 142 | N40 | 3 | 3006
PLAT | 19432.4 | 32525 | 142 | N48 | 3 | 3006
PLAT | 19432.4 | 44200 | 142 | N47 | 1 | 1006
PLAT | 40232.4 | 44200 | 142 | N8 | 1 | 1006

# IfcColumn: PL25*190 (16)
In: Undefined
Description: PL25*190; Material: STEEL/E24-2
Tekla Common - Finish: GRENAILLE-PEINT; Grade: E24-2; Profile: PL25*190; Name: PLATINE; sets with these values: 2
Tekla Quantity - Gross footprint area: 0.00475 m2; Height: 190 mm; Width: 25 mm; sets with these values: 2
Name | Center of gravity Z (mm) | Center of gravity Y (mm) | Center of gravity X (mm) | Bottom elevation | Top elevation | Part mark | Assembly mark | Phase | Class | Net weight (kg) = Gross weight (kg) = Weight (kg) = NetWeight (kg) | Net volume (m3) = Gross volume (m3) = NetVolume (m3) | Area per tons (m2) | Net surface area (m2) = Gross area (m2) = OuterSurfaceArea (m2) | Tekla Quantity, Length (mm) = BaseQuantities, Length (mm)
PLATINE | 5371.36 | 19450 | 44577.5 | +4.981 | +5.761 | 134 | K21 | 1 | 1005 | 29.0843 | 0.003705 | 11.8587 | 0.3449 | 780
PLATINE | 4131.54 | 19450 | 55727.5 | +3.767 | +4.497 | 133 | K21 | 1 | 1005 | 27.2199 | 0.0034675 | 11.881 | 0.3234 | 730
PLATINE | 5371.36 | 40250 | 44577.5 | +4.981 | +5.761 | 134 | K22 | 1 | 1005 | 29.0843 | 0.003705 | 11.8587 | 0.3449 | 780
PLATINE | 4131.54 | 40250 | 55727.5 | +3.767 | +4.497 | 133 | K22 | 1 | 1005 | 27.2199 | 0.0034675 | 11.881 | 0.3234 | 730
PLATINE | 4131.54 | 40250 | 67402.5 | +3.767 | +4.497 | 135 | K24 | 1 | 1005 | 27.2199 | 0.0034675 | 11.881 | 0.3234 | 730
PLATINE | 5371.36 | 40250 | 56252.5 | +4.981 | +5.761 | 134 | K24 | 1 | 1005 | 29.0843 | 0.003705 | 11.8587 | 0.3449 | 780
PLATINE | 4131.54 | 40250 | 44052.5 | +3.767 | +4.497 | 133 | K22 | 3 | 3005 | 27.2199 | 0.0034675 | 11.881 | 0.3234 | 730
PLATINE | 5371.36 | 40250 | 32902.5 | +4.981 | +5.761 | 134 | K22 | 3 | 3005 | 29.0843 | 0.003705 | 11.8587 | 0.3449 | 780
PLATINE | 4131.54 | 40250 | 32377.5 | +3.767 | +4.497 | 133 | K23 | 3 | 3005 | 27.2199 | 0.0034675 | 11.881 | 0.3234 | 730
PLATINE | 4131.54 | 19450 | 32377.5 | +3.767 | +4.497 | 133 | K21 | 3 | 3005 | 27.2199 | 0.0034675 | 11.881 | 0.3234 | 730
PLATINE | 5371.36 | 40250 | 21227.5 | +4.981 | +5.761 | 134 | K23 | 3 | 3005 | 29.0843 | 0.003705 | 11.8587 | 0.3449 | 780
PLATINE | 5371.36 | 19450 | 21227.5 | +4.981 | +5.761 | 134 | K21 | 3 | 3005 | 29.0843 | 0.003705 | 11.8587 | 0.3449 | 780
PLATINE | 5371.36 | 19450 | 32902.5 | +4.981 | +5.761 | 134 | K21 | 3 | 3005 | 29.0843 | 0.003705 | 11.8587 | 0.3449 | 780
PLATINE | 5371.36 | 19450 | 56252.5 | +4.981 | +5.761 | 134 | K21 | 1 | 1005 | 29.0843 | 0.003705 | 11.8587 | 0.3449 | 780
PLATINE | 4131.54 | 19450 | 44052.5 | +3.767 | +4.497 | 133 | K21 | 3 | 3005 | 27.2199 | 0.0034675 | 11.881 | 0.3234 | 730
PLATINE | 4131.54 | 19450 | 67402.5 | +3.767 | +4.497 | 133 | K21 | 1 | 1005 | 27.2199 | 0.0034675 | 11.881 | 0.3234 | 730

# IfcColumn: PL3*86 (33)
In: Undefined
Description: PL3*86; Material: STEEL/S235JR
Tekla Common - Finish: GRENAILLE-PEINT; Grade: S235JR; Profile: PL3*86; Name: TOLE; sets with these values: 2
Tekla Quantity - Net weight: 0.174176 kg; Gross weight: 0.174176 kg; Weight: 0.174176 kg; Net volume: 0.000022188 m3; Gross volume: 0.000022188 m3; Gross footprint area: 0.000258 m2; Area per tons: 90.8507 m2; Net surface area: 0.015824 m2; Gross area: 0.015824 m2; Height: 86 mm; Width: 3 mm; Length: 86 mm; sets with these values: 2
BaseQuantities - Length: 86 mm; OuterSurfaceArea: 0.015824 m2; NetVolume: 0.000022188 m3; NetWeight: 0.174176 kg
Name | Center of gravity Z (mm) | Center of gravity Y (mm) | Center of gravity X (mm) | Bottom elevation | Top elevation | Part mark | Assembly mark | Phase | Class
TOLE | 5845 | 13553.5 | 79090 | +5.802 | +5.888 | 1247 | L91 | 1 | 1003
TOLE | 5845 | 13546.5 | 79090 | +5.802 | +5.888 | 1247 | L90 | 1 | 1003
TOLE | 5845 | 69238.5 | 79090 | +5.802 | +5.888 | 1247 | L95 | 1 | 1003
TOLE | 4171.04 | 19446.5 | 79090 | +4.128 | +4.214 | 1247 | L89 | 1 | 1003
TOLE | 4171.04 | 19453.5 | 79090 | +4.128 | +4.214 | 1247 | L92 | 1 | 1003
TOLE | 5845 | 61053.5 | 79090 | +5.802 | +5.888 | 1247 | L95 | 1 | 1003
TOLE | 5845 | 61046.5 | 79090 | +5.802 | +5.888 | 1247 | L94 | 1 | 1003
TOLE | 5845 | 50653.5 | 79090 | +5.802 | +5.888 | 1247 | L94 | 1 | 1003
TOLE | 5845 | 50646.5 | 79090 | +5.802 | +5.888 | 1247 | L94 | 1 | 1003
TOLE | 5845 | 40253.5 | 79090 | +5.802 | +5.888 | 1247 | L94 | 1 | 1003
TOLE | 5845 | 40246.5 | 79090 | +5.802 | +5.888 | 1247 | L99 | 1 | 1003
TOLE | 5845 | 35053.5 | 79090 | +5.802 | +5.888 | 1247 | L99 | 1 | 1003
TOLE | 5845 | 35046.5 | 79090 | +5.802 | +5.888 | 1247 | L94 | 1 | 1003
TOLE | 5845 | 24653.5 | 79090 | +5.802 | +5.888 | 1247 | L94 | 1 | 1003
TOLE | 5845 | 24646.5 | 79090 | +5.802 | +5.888 | 1247 | L91 | 1 | 1003
TOLE | 5478.82 | 7653.5 | 79090 | +5.436 | +5.522 | 1247 | L88 | 1 | 1003
TOLE | 5478.82 | 7646.5 | 79090 | +5.436 | +5.522 | 1247 | L93 | 1 | 1003
TOLE | 5845 | 7646.5 | 79090 | +5.802 | +5.888 | 1247 | L93 | 1 | 1003
TOLE | 5478.82 | 9.5 | 79090 | +5.436 | +5.522 | 1247 | L93 | 1 | 1003
TOLE | 5845 | -47 | 79213.5 | +5.802 | +5.888 | 1247 | L55 | 1 | 1003
TOLE | 5845 | 9.5 | 79090 | +5.802 | +5.888 | 1247 | L93 | 1 | 1003
TOLE | 5935 | -47 | 32531.5 | +5.892 | +5.978 | 1252 | L107 | 3 | 3003
TOLE | 5935 | -47 | 44193.5 | +5.892 | +5.978 | 1252 | L107 | 3 | 3003
TOLE | 5845 | 7653.5 | 79090 | +5.802 | +5.888 | 1247 | L90 | 1 | 1003
TOLE | 5935 | -47 | 55868.5 | +5.892 | +5.978 | 1247 | L97 | 1 | 1003
TOLE | 5935 | -47 | 44206.5 | +5.892 | +5.978 | 1247 | L97 | 1 | 1003
TOLE | 5935 | -47 | 67543.5 | +5.892 | +5.978 | 1247 | L97 | 1 | 1003
TOLE | 5935 | -47 | 55881.5 | +5.892 | +5.978 | 1247 | L97 | 1 | 1003
TOLE | 5935 | -47 | 32518.5 | +5.892 | +5.978 | 1252 | L108 | 3 | 3003
TOLE | 5935 | -47 | 20856.5 | +5.892 | +5.978 | 1252 | L108 | 3 | 3003
TOLE | 4171.04 | 26126.5 | 79090 | +4.128 | +4.214 | 1247 | L92 | 1 | 1003
TOLE | 4171.04 | 13488.5 | 79090 | +4.128 | +4.214 | 1247 | L89 | 1 | 1003
TOLE | 5478.82 | 13546.5 | 79090 | +5.436 | +5.522 | 1247 | L88 | 1 | 1003

# IfcColumn: PL3*96 (8)
In: Undefined
Description: PL3*96; Material: STEEL/S235JR
BaseQuantities - Length: 96 mm; OuterSurfaceArea: 0.019584 m2; NetVolume: 0.000027648 m3; NetWeight: 0.217037 kg
Tekla Common - Center of gravity Z: 4817.58 mm; Center of gravity X: 79085 mm; Bottom elevation: +4.770; Top elevation: +4.866; Part mark: 1248; Phase: 1; Class: 1003; Finish: GRENAILLE-PEINT; Grade: S235JR; Profile: PL3*96; Name: TOLE; sets with these values: 2
Tekla Quantity - Net weight: 0.217037 kg; Gross weight: 0.217037 kg; Weight: 0.217037 kg; Net volume: 0.000027648 m3; Gross volume: 0.000027648 m3; Gross footprint area: 0.000288 m2; Area per tons: 90.2335 m2; Net surface area: 0.019584 m2; Gross area: 0.019584 m2; Height: 96 mm; Width: 3 mm; Length: 96 mm; sets with these values: 2
Name | Center of gravity Y (mm) | Assembly mark
TOLE | 34995.5 | L101
TOLE | 40246.5 | L101
TOLE | 40253.5 | L102
TOLE | 50646.5 | L102
TOLE | 50653.5 | L102
TOLE | 61046.5 | L102
TOLE | 61053.5 | L103
TOLE | 69145.5 | L103

# IfcColumn: PL300*6 (2)
In: Undefined
Description: PL300*6; Material: STEEL/E24-2
BaseQuantities - Length: 80 mm; OuterSurfaceArea: 0.05256 m2; NetVolume: 0.000144 m3; NetWeight: 1.1304 kg
Tekla Common - Center of gravity Z: 4640 mm; Center of gravity Y: -75 mm; Bottom elevation: +4.600; Top elevation: +4.680; Part mark: 321; Phase: 1; Class: 1003; Finish: GRENAILLE-PEINT; Grade: E24-2; Profile: PL300*6; sets with these values: 2
Tekla Quantity - Net weight: 1.1304 kg; Gross weight: 1.1304 kg; Weight: 1.1304 kg; Net volume: 0.000144 m3; Gross volume: 0.000144 m3; Gross footprint area: 0.0018 m2; Area per tons: 46.4968 m2; Net surface area: 0.05256 m2; Gross area: 0.05256 m2; Height: 300 mm; Width: 6 mm; Length: 80 mm; sets with these values: 2
Name | Center of gravity X (mm) | Assembly mark
 | 73797 | L4
 | 78332 | L5

# IfcColumn: PL56*3 (16)
In: Undefined
Description: PL56*3; Material: STEEL/E24-2
Tekla Common - Part mark: 1241; Finish: GRENAILLE-PEINT; Grade: E24-2; Profile: PL56*3; sets with these values: 2
Tekla Quantity - Net weight: 0.0738528 kg; Gross weight: 0.0738528 kg; Weight: 0.0738528 kg; Net volume: 0.000009408 m3; Gross volume: 0.000009408 m3; Gross footprint area: 0.000168 m2; Area per tons: 94.0249 m2; Net surface area: 0.006944 m2; Gross area: 0.006944 m2; Height: 56 mm; Width: 3 mm; Length: 56 mm; sets with these values: 2
BaseQuantities - Length: 56 mm; OuterSurfaceArea: 0.006944 m2; NetVolume: 0.000009408 m3; NetWeight: 0.0738528 kg
Name | Center of gravity Z (mm) | Center of gravity Y (mm) | Center of gravity X (mm) | Bottom elevation | Top elevation | Assembly mark | Phase | Class
 | 4760 | 27405 | 55770 | +4.732 | +4.788 | L47 | 1 | 1003
 | 5620 | 27405 | 55770 | +5.592 | +5.648 | L47 | 1 | 1003
 | 5620 | 19605 | 55770 | +5.592 | +5.648 | L47 | 1 | 1003
 | 4760 | 19605 | 55770 | +4.732 | +4.788 | L47 | 1 | 1003
 | 5620 | 27405 | 44095 | +5.592 | +5.648 | L47 | 1 | 1003
 | 4760 | 19605 | 32420 | +4.732 | +4.788 | L47 | 3 | 3003
 | 5620 | 19605 | 32420 | +5.592 | +5.648 | L47 | 3 | 3003
 | 5620 | 27405 | 32420 | +5.592 | +5.648 | L47 | 3 | 3003
 | 4760 | 27405 | 32420 | +4.732 | +4.788 | L47 | 3 | 3003
 | 4760 | 37805 | 20745 | +4.732 | +4.788 | L48 | 2 | 2003
 | 5620 | 37805 | 20745 | +5.592 | +5.648 | L48 | 2 | 2003
 | 4760 | 27405 | 20745 | +4.732 | +4.788 | L47 | 2 | 2003
 | 5620 | 27405 | 20745 | +5.592 | +5.648 | L47 | 2 | 2003
 | 5620 | 19605 | 44095 | +5.592 | +5.648 | L47 | 1 | 1003
 | 4760 | 27405 | 44095 | +4.732 | +4.788 | L47 | 1 | 1003
 | 4760 | 19605 | 44095 | +4.732 | +4.788 | L47 | 1 | 1003

# IfcColumn: PL6*86, TOLE
In: Undefined
Description: PL6*86; Material: STEEL/S235JR
Tekla Common - Center of gravity Z: 5845 mm; Center of gravity Y: -47 mm; Center of gravity X: 67663 mm; Bottom elevation: +5.802; Top elevation: +5.888; Part mark: 333; Assembly mark: L55; Phase: 1; Class: 1003; Finish: GRENAILLE-PEINT; Grade: S235JR; Profile: PL6*86; Name: TOLE; sets with these values: 2
Tekla Quantity - Net weight: 0.348352 kg; Gross weight: 0.348352 kg; Weight: 0.348352 kg; Net volume: 0.000044376 m3; Gross volume: 0.000044376 m3; Gross footprint area: 0.000516 m2; Area per tons: 48.3879 m2; Net surface area: 0.016856 m2; Gross area: 0.016856 m2; Height: 86 mm; Width: 6 mm; Length: 86 mm; sets with these values: 2
BaseQuantities - Length: 86 mm; OuterSurfaceArea: 0.016856 m2; NetVolume: 0.000044376 m3; NetWeight: 0.348352 kg

# IfcColumn: PL66*3 (2)
In: Undefined
Description: PL66*3; Material: STEEL/E24-2
BaseQuantities - Length: 66 mm; OuterSurfaceArea: 0.009504 m2; NetVolume: 0.000013068 m3; NetWeight: 0.102584 kg
Tekla Common - Center of gravity Z: 3535 mm; Bottom elevation: +3.502; Top elevation: +3.568; Part mark: 1242; Assembly mark: M19; Phase: 4; Class: 4001; Finish: GRENAILLE-PEINT; Grade: E24-2; Profile: PL66*3; sets with these values: 2
Tekla Quantity - Net weight: 0.102584 kg; Gross weight: 0.102584 kg; Weight: 0.102584 kg; Net volume: 0.000013068 m3; Gross volume: 0.000013068 m3; Gross footprint area: 0.000198 m2; Area per tons: 92.6462 m2; Net surface area: 0.009504 m2; Gross area: 0.009504 m2; Height: 66 mm; Width: 3 mm; Length: 66 mm; sets with these values: 2
Name | Center of gravity Y (mm) | Center of gravity X (mm)
 | 27915 | 58301.5
 | 23985 | 54448.5

# IfcColumn: PL70*6 (13)
In: Undefined
Description: PL70*6
Tekla Common - Profile: PL70*6; sets with these values: 2
Tekla Quantity - Height: 70 mm; Width: 6 mm; sets with these values: 2
Name | Material | Center of gravity Z (mm) | Center of gravity Y (mm) | Center of gravity X (mm) | Bottom elevation | Top elevation | Part mark | Assembly mark | Phase | Class | Finish | Grade | Name | Net weight (kg) = Weight (kg) = NetWeight (kg) | Gross weight (kg) | Net volume (m3) = NetVolume (m3) | Gross volume (m3) | Gross footprint area (m2) | Area per tons (m2) | Net surface area (m2) = OuterSurfaceArea (m2) | Gross area (m2) | Tekla Quantity, Length (mm) = BaseQuantities, Length (mm)
ATTACHE | STEEL/S235JR | 10812 | 63664.9 | 23188 | +10.765 | +10.859 | 355 | P72 | 2 | 2007 | GALVANISE | S235JR | ATTACHE | 0.308741 | 0.309918 | 0.00003933 | 0.00003948 | 0.00039 | 48.7233 | 0.0150429 | 0.015128 | 94
ATTACHE | STEEL/S235JR | 10812 | 63835.1 | 23188 | +10.765 | +10.859 | 355 | P72 | 2 | 2007 | GALVANISE | S235JR | ATTACHE | 0.30874 | 0.309918 | 0.00003933 | 0.00003948 | 0.00039 | 48.7233 | 0.0150429 | 0.015128 | 94
ATTACHE | STEEL/S235JR | 10812 | 61070.1 | 23188 | +10.765 | +10.859 | 355 | P72 | 2 | 2007 | GALVANISE | S235JR | ATTACHE | 0.30874 | 0.309918 | 0.00003933 | 0.00003948 | 0.00039 | 48.7233 | 0.0150429 | 0.015128 | 94
ATTACHE | STEEL/S235JR | 10812 | 60899.9 | 23188 | +10.765 | +10.859 | 355 | P72 | 2 | 2007 | GALVANISE | S235JR | ATTACHE | 0.308741 | 0.309918 | 0.00003933 | 0.00003948 | 0.00039 | 48.7233 | 0.0150429 | 0.015128 | 94
ATTACHE | STEEL/S235JR | 10812 | 58305.1 | 23188 | +10.765 | +10.859 | 355 | P72 | 2 | 2007 | GALVANISE | S235JR | ATTACHE | 0.30874 | 0.309918 | 0.00003933 | 0.00003948 | 0.00039 | 48.7233 | 0.0150429 | 0.015128 | 94
ATTACHE | STEEL/S235JR | 10812 | 58134.9 | 23188 | +10.765 | +10.859 | 355 | P72 | 2 | 2007 | GALVANISE | S235JR | ATTACHE | 0.308741 | 0.309918 | 0.00003933 | 0.00003948 | 0.00039 | 48.7233 | 0.0150429 | 0.015128 | 94
ATTACHE | STEEL/S235JR | 10812 | 55540.1 | 23188 | +10.765 | +10.859 | 355 | P72 | 2 | 2007 | GALVANISE | S235JR | ATTACHE | 0.30874 | 0.309918 | 0.00003933 | 0.00003948 | 0.00039 | 48.7233 | 0.0150429 | 0.015128 | 94
ATTACHE | STEEL/S235JR | 10812 | 55369.9 | 23188 | +10.765 | +10.859 | 355 | P72 | 2 | 2007 | GALVANISE | S235JR | ATTACHE | 0.308741 | 0.309918 | 0.00003933 | 0.00003948 | 0.00039 | 48.7233 | 0.0150429 | 0.015128 | 94
ATTACHE | STEEL/S235JR | 10812 | 52775.1 | 23188 | +10.765 | +10.859 | 355 | P72 | 2 | 2007 | GALVANISE | S235JR | ATTACHE | 0.30874 | 0.309918 | 0.00003933 | 0.00003948 | 0.00039 | 48.7233 | 0.0150429 | 0.015128 | 94
ATTACHE | STEEL/S235JR | 10811.9 | 52604.9 | 31678 | +10.765 | +10.859 | 331 | P63 | 2 | 2007 | GALVANISE | S235JR | ATTACHE | 0.309329 | 0.309918 | 0.000039405 | 0.00003948 | 0.00039 | 48.7682 | 0.0150854 | 0.015128 | 94
ATTACHE | STEEL/S235JR | 10811.9 | 52604.9 | 28850 | +10.765 | +10.859 | 331 | P65 | 2 | 2007 | GALVANISE | S235JR | ATTACHE | 0.309329 | 0.309918 | 0.000039405 | 0.00003948 | 0.00039 | 48.7682 | 0.0150854 | 0.015128 | 94
ATTACHE | STEEL/S235JR | 10811.9 | 52604.9 | 26022 | +10.765 | +10.859 | 331 | P64 | 2 | 2007 | GALVANISE | S235JR | ATTACHE | 0.309329 | 0.309918 | 0.000039405 | 0.00003948 | 0.00039 | 48.7682 | 0.0150854 | 0.015128 | 94
 | STEEL/E24-2 | 3478.43 | 13135 | 6322 | +3.443 | +3.513 | 332 | S3 | 6 | 6001 | GRENAILLE-PEINT | E24-2 |  | 0.23079 | 0.23079 | 0.0000294 | 0.0000294 | 0.00042 | 49.7422 | 0.01148 | 0.01148 | 70

# IfcColumn: TUBE-C-100*100*3 (183)
In: Undefined
Description: TUBE-C-100*100*3; Material: STEEL/S235JR
Tekla Common - Finish: GALVANISE; Grade: S235JR; Profile: TUBE-C-100*100*3; Name: POTEAU; sets with these values: 2
Tekla Quantity - Gross footprint area: 0.001164 m2; Area per tons: 43.1281 m2; Height: 100 mm; Width: 100 mm; sets with these values: 2
Name | Center of gravity Z (mm) | Center of gravity Y (mm) | Center of gravity X (mm) | Bottom elevation | Top elevation | Part mark | Assembly mark | Phase | Class | Net weight (kg) = NetWeight (kg) | Gross weight (kg) = Weight (kg) | Net volume (m3) = NetVolume (m3) | Gross volume (m3) | Net surface area (m2) | Gross area (m2) = OuterSurfaceArea (m2) | Tekla Quantity, Length (mm) = BaseQuantities, Length (mm)
POTEAU | 10719 | 50520 | 20360.2 | +10.576 | +10.860 | 936 | P108 | 2 | 2007 | 2.57711 | 2.55789 | 0.000328295 | 0.000325845 | 0.114016 | 0.110317 | 283.59
POTEAU | 10719 | 52690 | 20360.2 | +10.576 | +10.860 | 936 | P95 | 2 | 2007 | 2.57711 | 2.55789 | 0.000328295 | 0.000325845 | 0.114016 | 0.110317 | 283.59
POTEAU | 10719 | 55455 | 20360.2 | +10.576 | +10.860 | 936 | P95 | 2 | 2007 | 2.57711 | 2.55789 | 0.000328295 | 0.000325845 | 0.114016 | 0.110317 | 283.59
POTEAU | 10719 | 58220 | 20360.2 | +10.576 | +10.860 | 936 | P95 | 2 | 2007 | 2.57711 | 2.55789 | 0.000328295 | 0.000325845 | 0.114016 | 0.110317 | 283.59
POTEAU | 10719 | 60985 | 20360.2 | +10.576 | +10.860 | 936 | P95 | 2 | 2007 | 2.57711 | 2.55789 | 0.000328295 | 0.000325845 | 0.114016 | 0.110317 | 283.59
POTEAU | 4058.55 | 40250 | 8340.09 | +3.756 | +4.359 | 948 | P67 | 2 | 2007 | 5.49067 | 5.4357 | 0.000699448 | 0.000692446 | 0.24156 | 0.234431 | 602.651
POTEAU | 4104.89 | 40250 | 5691.78 | +3.849 | +4.359 | 947 | P66 | 2 | 2007 | 4.6437 | 4.59965 | 0.000591554 | 0.000585942 | 0.204484 | 0.198374 | 509.958
POTEAU | 4198.09 | 40250 | 395.17 | +4.034 | +4.360 | 946 | P96 | 2 | 2007 | 2.95878 | 2.93644 | 0.000376915 | 0.000374068 | 0.130724 | 0.126643 | 325.56
POTEAU | 4058.55 | 37581.2 | 8340.09 | +3.756 | +4.359 | 948 | P67 | 2 | 2007 | 5.49067 | 5.4357 | 0.000699448 | 0.000692446 | 0.24156 | 0.234431 | 602.651
POTEAU | 4104.89 | 37581.2 | 5691.78 | +3.849 | +4.359 | 947 | P66 | 2 | 2007 | 4.6437 | 4.59965 | 0.000591554 | 0.000585942 | 0.204484 | 0.198374 | 509.958
POTEAU | 4198.09 | 37581.2 | 395.17 | +4.034 | +4.360 | 946 | P96 | 2 | 2007 | 2.95878 | 2.93644 | 0.000376915 | 0.000374068 | 0.130724 | 0.126643 | 325.56
POTEAU | 4058.55 | 34912.5 | 8340.09 | +3.756 | +4.359 | 948 | P67 | 2 | 2007 | 5.49067 | 5.4357 | 0.000699448 | 0.000692446 | 0.24156 | 0.234431 | 602.651
POTEAU | 4104.89 | 34912.5 | 5691.78 | +3.849 | +4.359 | 947 | P66 | 2 | 2007 | 4.6437 | 4.59965 | 0.000591554 | 0.000585942 | 0.204484 | 0.198374 | 509.958
POTEAU | 4198.09 | 34912.5 | 395.17 | +4.034 | +4.360 | 946 | P96 | 2 | 2007 | 2.95878 | 2.93644 | 0.000376915 | 0.000374068 | 0.130724 | 0.126643 | 325.56
POTEAU | 4198.09 | 32243.7 | 395.17 | +4.034 | +4.360 | 946 | P96 | 2 | 2007 | 2.95878 | 2.93644 | 0.000376915 | 0.000374068 | 0.130724 | 0.126643 | 325.56
POTEAU | 4104.89 | 32243.8 | 5691.78 | +3.849 | +4.359 | 947 | P66 | 2 | 2007 | 4.6437 | 4.59965 | 0.000591554 | 0.000585942 | 0.204484 | 0.198374 | 509.958
POTEAU | 4058.55 | 32243.8 | 8340.09 | +3.756 | +4.359 | 948 | P67 | 2 | 2007 | 5.49067 | 5.4357 | 0.000699448 | 0.000692446 | 0.24156 | 0.234431 | 602.651
POTEAU | 4198.09 | 29575 | 395.17 | +4.034 | +4.360 | 946 | P96 | 2 | 2007 | 2.95878 | 2.93644 | 0.000376915 | 0.000374068 | 0.130724 | 0.126643 | 325.56
POTEAU | 4058.55 | 29575 | 8340.09 | +3.756 | +4.359 | 948 | P67 | 2 | 2007 | 5.49067 | 5.4357 | 0.000699448 | 0.000692446 | 0.24156 | 0.234431 | 602.651
POTEAU | 4104.89 | 29575 | 5691.78 | +3.849 | +4.359 | 947 | P66 | 2 | 2007 | 4.6437 | 4.59965 | 0.000591554 | 0.000585942 | 0.204484 | 0.198374 | 509.958
POTEAU | 4198.09 | 27043.7 | 395.17 | +4.034 | +4.360 | 946 | P96 | 2 | 2007 | 2.95878 | 2.93644 | 0.000376915 | 0.000374068 | 0.130724 | 0.126643 | 325.56
POTEAU | 4058.55 | 27043.8 | 8340.09 | +3.756 | +4.359 | 948 | P67 | 2 | 2007 | 5.49067 | 5.4357 | 0.000699448 | 0.000692446 | 0.24156 | 0.234431 | 602.651
POTEAU | 4104.89 | 27043.8 | 5691.78 | +3.849 | +4.359 | 947 | P66 | 2 | 2007 | 4.6437 | 4.59965 | 0.000591554 | 0.000585942 | 0.204484 | 0.198374 | 509.958
POTEAU | 4198.09 | 24512.5 | 395.17 | +4.034 | +4.360 | 946 | P96 | 2 | 2007 | 2.95878 | 2.93644 | 0.000376915 | 0.000374068 | 0.130724 | 0.126643 | 325.56
POTEAU | 4058.55 | 24512.5 | 8340.09 | +3.756 | +4.359 | 948 | P67 | 2 | 2007 | 5.49067 | 5.4357 | 0.000699448 | 0.000692446 | 0.24156 | 0.234431 | 602.651
POTEAU | 4104.89 | 24512.5 | 5691.78 | +3.849 | +4.359 | 947 | P66 | 2 | 2007 | 4.6437 | 4.59965 | 0.000591554 | 0.000585942 | 0.204484 | 0.198374 | 509.958
POTEAU | 3828.11 | 11385 | 10404.9 | +3.396 | +4.259 | 932 | P83 | 2 | 2007 | 7.87447 | 7.78698 | 0.00100312 | 0.000991972 | 0.345914 | 0.335837 | 863.335
POTEAU | 4198.09 | 21981.2 | 395.17 | +4.034 | +4.360 | 946 | P96 | 2 | 2007 | 2.95878 | 2.93644 | 0.000376915 | 0.000374068 | 0.130724 | 0.126643 | 325.56
POTEAU | 4104.89 | 21981.2 | 5691.78 | +3.849 | +4.359 | 947 | P66 | 2 | 2007 | 4.6437 | 4.59965 | 0.000591554 | 0.000585942 | 0.204484 | 0.198374 | 509.958
POTEAU | 4058.55 | 21981.2 | 8340.09 | +3.756 | +4.359 | 948 | P67 | 2 | 2007 | 5.49067 | 5.4357 | 0.000699448 | 0.000692446 | 0.24156 | 0.234431 | 602.651
