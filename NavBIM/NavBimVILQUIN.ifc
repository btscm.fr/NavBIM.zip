Properties of the parts of a building model (IFC2X3), part 8 of 32

# IfcBeam: L70*7 (412)
Name | Material | Center of gravity Z (mm) | Center of gravity Y (mm) | Center of gravity X (mm) | Bottom elevation | Top elevation | Part mark | Assembly mark | Phase | Class | Finish | Grade | Name | Net weight (kg) = NetWeight (kg) | Gross weight (kg) = Weight (kg) | Net volume (m3) = NetVolume (m3) | Gross volume (m3) | Gross footprint area (m2) | Net surface area (m2) | Gross area (m2) = OuterSurfaceArea (m2) | Tekla Quantity, Length (mm) = BaseQuantities, Length (mm)
SOLIVE | STEEL/S235JR | 5760 | 37586.6 | 20485.1 | +5.705 | +5.815 | 655 | S1 | 2 | 2007 | GALVANISE | S235JR | SOLIVE | 0.803918 | 0.81169 | 0.00010241 | 0.0001034 | 0.000931 | 0.032662 | 0.02992 | 110
SOLIVE | STEEL/S235JR | 5760 | 37426.4 | 20485.1 | +5.705 | +5.815 | 655 | S1 | 2 | 2007 | GALVANISE | S235JR | SOLIVE | 0.803918 | 0.81169 | 0.00010241 | 0.0001034 | 0.000931 | 0.032662 | 0.02992 | 110
SOLIVE | STEEL/S235JR | 5760 | 42786.6 | 20485.1 | +5.705 | +5.815 | 655 | S1 | 2 | 2007 | GALVANISE | S235JR | SOLIVE | 0.803918 | 0.81169 | 0.00010241 | 0.0001034 | 0.000931 | 0.032662 | 0.02992 | 110
SOLIVE | STEEL/S235JR | 5760 | 42626.4 | 20485.1 | +5.705 | +5.815 | 655 | S1 | 2 | 2007 | GALVANISE | S235JR | SOLIVE | 0.803918 | 0.81169 | 0.00010241 | 0.0001034 | 0.000931 | 0.032662 | 0.02992 | 110
SOLIVE | STEEL/S235JR | 5760 | 45226.4 | 20485.1 | +5.705 | +5.815 | 655 | S1 | 2 | 2007 | GALVANISE | S235JR | SOLIVE | 0.803918 | 0.81169 | 0.00010241 | 0.0001034 | 0.000931 | 0.032662 | 0.02992 | 110
SOLIVE | STEEL/S235JR | 5760 | 45386.6 | 20485.1 | +5.705 | +5.815 | 655 | S1 | 2 | 2007 | GALVANISE | S235JR | SOLIVE | 0.803918 | 0.81169 | 0.00010241 | 0.0001034 | 0.000931 | 0.032662 | 0.02992 | 110
ATTACHE | STEEL/E24-2 | 5468.32 | 40224.8 | 21039.8 | +5.411 | +5.496 | H39 | H39 | 3 | 3004 | GRENAILLE-PEINT | E24-2 | ATTACHE | 0.877002 | 0.88548 | 0.00011172 | 0.0001128 | 0 | 0.035462 | 0.03264 | 120
CSV | STEEL/E24-2 | 4781.28 | 46816.5 | 26664.8 | +4.733 | +4.804 | C128 | C128 | 3 | 3004 | GRENAILLE-PEINT | E24-2 | CSV | 18.7313 | 18.9124 | 0.00238615 | 0.00240922 | 0 | 0.719502 | 0.697136 | 2563
CSV | STEEL/E24-2 | 4781.28 | 42815 | 26664.8 | +4.733 | +4.804 | C117 | C117 | 3 | 3004 | GRENAILLE-PEINT | E24-2 | CSV | 37.2726 | 37.6329 | 0.0047481 | 0.004794 | 0 | 1.42986 | 1.3872 | 5100
ATTACHE | STEEL/E24-2 | 5468.32 | 19424.8 | 21039.8 | +5.411 | +5.496 | H39 | H39 | 3 | 3004 | GRENAILLE-PEINT | E24-2 | ATTACHE | 0.877002 | 0.88548 | 0.00011172 | 0.0001128 | 0 | 0.035462 | 0.03264 | 120
ATTACHE | STEEL/E24-2 | 5468.32 | 19475.2 | 21039.8 | +5.411 | +5.496 | H39 | H39 | 3 | 3004 | GRENAILLE-PEINT | E24-2 | ATTACHE | 0.877002 | 0.88548 | 0.00011172 | 0.0001128 | 0 | 0.035462 | 0.03264 | 120
CSV | STEEL/E24-2 | 4781.28 | 32450 | 26664.8 | +4.733 | +4.804 | C118 | C118 | 3 | 3004 | GRENAILLE-PEINT | E24-2 | CSV | 36.761 | 37.1164 | 0.00468293 | 0.0047282 | 0 | 1.41026 | 1.36816 | 5030
CSV | STEEL/E24-2 | 4781.28 | 37685 | 26664.8 | +4.733 | +4.804 | C119 | C119 | 3 | 3004 | GRENAILLE-PEINT | E24-2 | CSV | 37.2726 | 37.6329 | 0.0047481 | 0.004794 | 0 | 1.42986 | 1.3872 | 5100
CSV | STEEL/E24-2 | 4781.28 | 27250 | 26664.8 | +4.733 | +4.804 | C118 | C118 | 3 | 3004 | GRENAILLE-PEINT | E24-2 | CSV | 36.761 | 37.1164 | 0.00468293 | 0.0047282 | 0 | 1.41026 | 1.36816 | 5030
CSV | STEEL/E24-2 | 4781.28 | 22015 | 26664.8 | +4.733 | +4.804 | C117 | C117 | 3 | 3004 | GRENAILLE-PEINT | E24-2 | CSV | 37.2726 | 37.6329 | 0.0047481 | 0.004794 | 0 | 1.42986 | 1.3872 | 5100
CSV | STEEL/E24-2 | 4781.28 | 17125 | 26664.8 | +4.733 | +4.804 | C116 | C116 | 3 | 3004 | GRENAILLE-PEINT | E24-2 | CSV | 33.7646 | 34.091 | 0.00430122 | 0.0043428 | 0 | 1.29546 | 1.25664 | 4620
CSV | STEEL/E24-2 | 4781.28 | 12370 | 26664.8 | +4.733 | +4.804 | C115 | C115 | 3 | 3004 | GRENAILLE-PEINT | E24-2 | CSV | 33.253 | 33.5744 | 0.00423605 | 0.004277 | 0 | 1.27586 | 1.2376 | 4550
CSV | STEEL/E24-2 | 4781.28 | 7555 | 26664.8 | +4.733 | +4.804 | C113 | C113 | 3 | 3004 | GRENAILLE-PEINT | E24-2 | CSV | 34.6416 | 34.9765 | 0.00441294 | 0.0044556 | 0 | 1.32906 | 1.28928 | 4740
CSV | STEEL/E24-2 | 4781.28 | 3825 | 26664.8 | +4.733 | +4.804 | C103 | C103 | 3 | 3004 | GRENAILLE-PEINT | E24-2 | CSV | 17.3939 | 17.562 | 0.00221578 | 0.0022372 | 0 | 0.668262 | 0.64736 | 2380
CSV | STEEL/E24-2 | 4829.08 | 3825 | 26670.6 | +4.803 | +4.881 | C103 | C103 | 3 | 3004 | GRENAILLE-PEINT | E24-2 | CSV | 17.3939 | 17.562 | 0.00221578 | 0.0022372 | 0 | 0.668262 | 0.64736 | 2380
ATTACHE | STEEL/S235JR | 3911.87 | 49388.1 | 24.3726 | +3.832 | +3.992 | H37 | H37 | 2 | 2005 | GRENAILLE-PEINT | S235JR | ATTACHE | 1.16936 | 1.18066 | 0.000148962 | 0.000150403 | 0.000931 | 0.0466627 | 0.0435207 | 160.003
ATTACHE | STEEL/S235JR | 3901.87 | 48548.1 | 24.3726 | +3.812 | +3.992 | H35 | H35 | 2 | 2005 | GRENAILLE-PEINT | S235JR | ATTACHE | 1.31552 | 1.32824 | 0.000167582 | 0.000169202 | 0.000931 | 0.0522627 | 0.0489607 | 180.003
ATTACHE | STEEL/S235JR | 3588.83 | 45743.6 | 20753.9 | +3.499 | +3.679 | H35 | H35 | 2 | 2005 | GRENAILLE-PEINT | S235JR | ATTACHE | 1.31552 | 1.32824 | 0.000167582 | 0.000169202 | 0.000931 | 0.0522627 | 0.0489607 | 180.003
ATTACHE | STEEL/S235JR | 3901.87 | 45789.8 | 24.3726 | +3.812 | +3.992 | H35 | H35 | 2 | 2005 | GRENAILLE-PEINT | S235JR | ATTACHE | 1.31552 | 1.32824 | 0.000167582 | 0.000169202 | 0.000931 | 0.0522627 | 0.0489607 | 180.003
ATTACHE | STEEL/S235JR | 3901.87 | 43031.4 | 24.3726 | +3.812 | +3.992 | H35 | H35 | 2 | 2005 | GRENAILLE-PEINT | S235JR | ATTACHE | 1.31552 | 1.32824 | 0.000167582 | 0.000169202 | 0.000931 | 0.0522627 | 0.0489607 | 180.003
ATTACHE | STEEL/S235JR | 3588.83 | 42985.2 | 20753.9 | +3.499 | +3.679 | H35 | H35 | 2 | 2005 | GRENAILLE-PEINT | S235JR | ATTACHE | 1.31552 | 1.32824 | 0.000167582 | 0.000169202 | 0.000931 | 0.0522627 | 0.0489607 | 180.003
ATTACHE | STEEL/S235JR | 3901.87 | 40273.1 | 24.3726 | +3.812 | +3.992 | H35 | H35 | 2 | 2005 | GRENAILLE-PEINT | S235JR | ATTACHE | 1.31552 | 1.32824 | 0.000167582 | 0.000169202 | 0.000931 | 0.0522627 | 0.0489607 | 180.003
ATTACHE | STEEL/S235JR | 3587 | 40226.9 | 20694.9 | +3.497 | +3.677 | H35 | H35 | 2 | 2005 | GRENAILLE-PEINT | S235JR | ATTACHE | 1.31552 | 1.32824 | 0.000167582 | 0.000169202 | 0.000931 | 0.0522627 | 0.0489607 | 180.003
ATTACHE | STEEL/S235JR | 3901.87 | 10953.1 | 24.3726 | +3.812 | +3.992 | H35 | H35 | 2 | 2005 | GRENAILLE-PEINT | S235JR | ATTACHE | 1.31552 | 1.32824 | 0.000167582 | 0.000169202 | 0.000931 | 0.0522627 | 0.0489607 | 180.003
ATTACHE | STEEL/S235JR | 3588.83 | 10906.9 | 20753.9 | +3.499 | +3.679 | H35 | H35 | 2 | 2005 | GRENAILLE-PEINT | S235JR | ATTACHE | 1.31552 | 1.32824 | 0.000167582 | 0.000169202 | 0.000931 | 0.0522627 | 0.0489607 | 180.003
ATTACHE | STEEL/S235JR | 3901.87 | 13083.1 | 24.3726 | +3.812 | +3.992 | H35 | H35 | 2 | 2005 | GRENAILLE-PEINT | S235JR | ATTACHE | 1.31552 | 1.32824 | 0.000167582 | 0.000169202 | 0.000931 | 0.0522627 | 0.0489607 | 180.003
ATTACHE | STEEL/S235JR | 3588.83 | 13036.9 | 20753.9 | +3.499 | +3.679 | H35 | H35 | 2 | 2005 | GRENAILLE-PEINT | S235JR | ATTACHE | 1.31552 | 1.32824 | 0.000167582 | 0.000169202 | 0.000931 | 0.0522627 | 0.0489607 | 180.003
ATTACHE | STEEL/S235JR | 3588.83 | 15166.9 | 20753.9 | +3.499 | +3.679 | H35 | H35 | 2 | 2005 | GRENAILLE-PEINT | S235JR | ATTACHE | 1.31552 | 1.32824 | 0.000167582 | 0.000169202 | 0.000931 | 0.0522627 | 0.0489607 | 180.003
ATTACHE | STEEL/S235JR | 3901.87 | 15213.1 | 24.3726 | +3.812 | +3.992 | H35 | H35 | 2 | 2005 | GRENAILLE-PEINT | S235JR | ATTACHE | 1.31552 | 1.32824 | 0.000167582 | 0.000169202 | 0.000931 | 0.0522627 | 0.0489607 | 180.003
ATTACHE | STEEL/S235JR | 3588.83 | 17296.9 | 20753.9 | +3.499 | +3.679 | H35 | H35 | 2 | 2005 | GRENAILLE-PEINT | S235JR | ATTACHE | 1.31552 | 1.32824 | 0.000167582 | 0.000169202 | 0.000931 | 0.0522627 | 0.0489607 | 180.003
ATTACHE | STEEL/S235JR | 3901.87 | 17343.1 | 24.3726 | +3.812 | +3.992 | H35 | H35 | 2 | 2005 | GRENAILLE-PEINT | S235JR | ATTACHE | 1.31552 | 1.32824 | 0.000167582 | 0.000169202 | 0.000931 | 0.0522627 | 0.0489607 | 180.003
ATTACHE | STEEL/S235JR | 3587 | 19426.9 | 20694.9 | +3.497 | +3.677 | H35 | H35 | 2 | 2005 | GRENAILLE-PEINT | S235JR | ATTACHE | 1.31552 | 1.32824 | 0.000167582 | 0.000169202 | 0.000931 | 0.0522627 | 0.0489607 | 180.003
ATTACHE | STEEL/S235JR | 3901.87 | 19473.1 | 24.3726 | +3.812 | +3.992 | H35 | H35 | 2 | 2005 | GRENAILLE-PEINT | S235JR | ATTACHE | 1.31552 | 1.32824 | 0.000167582 | 0.000169202 | 0.000931 | 0.0522627 | 0.0489607 | 180.003
ATTACHE | STEEL/S235JR | 3901.87 | 27066.9 | 24.3726 | +3.812 | +3.992 | H35 | H35 | 2 | 2005 | GRENAILLE-PEINT | S235JR | ATTACHE | 1.31552 | 1.32824 | 0.000167582 | 0.000169202 | 0.000931 | 0.0522627 | 0.0489607 | 180.003
ATTACHE | STEEL/S235JR | 3901.87 | 32266.9 | 24.3726 | +3.812 | +3.992 | H35 | H35 | 2 | 2005 | GRENAILLE-PEINT | S235JR | ATTACHE | 1.31552 | 1.32824 | 0.000167582 | 0.000169202 | 0.000931 | 0.0522627 | 0.0489607 | 180.003
ATTACHE | STEEL/S235JR | 3901.87 | 24535.6 | 24.3726 | +3.812 | +3.992 | H35 | H35 | 2 | 2005 | GRENAILLE-PEINT | S235JR | ATTACHE | 1.31552 | 1.32824 | 0.000167582 | 0.000169202 | 0.000931 | 0.0522627 | 0.0489607 | 180.003
ATTACHE | STEEL/S235JR | 3901.87 | 22004.4 | 24.3726 | +3.812 | +3.992 | H35 | H35 | 2 | 2005 | GRENAILLE-PEINT | S235JR | ATTACHE | 1.31552 | 1.32824 | 0.000167582 | 0.000169202 | 0.000931 | 0.0522627 | 0.0489607 | 180.003
ATTACHE | STEEL/E24-2 | 5518.91 | 13502 | 75600.1 | +5.469 | +5.539 | 674 | M5 | 1 | 1007 | GRENAILLE-PEINT | E24-2 | ATTACHE | 0.760068 | 0.767416 | 0.000096824 | 0.00009776 | 0.00728 | 0.030982 | 0.028288 | 104
 | STEEL/E24-2 | 5412.02 | 69167.1 | 44128.4 | +5.362 | +5.432 | 614 | L45 | 3 | 3003 | GRENAILLE-PEINT | E24-2 |  | 0.854277 | 0.862535 | 0.000108825 | 0.000109877 | 0.00818234 | 0.0345914 | 0.0317942 | 116.891
CSV | STEEL/E24-2 | 5266.7 | 25950 | 69787.7 | +5.244 | +5.315 | C107 | C107 | 1 | 1009 | GRENAILLE-PEINT | E24-2 | CSV | 17.7593 | 17.931 | 0.00226233 | 0.0022842 | 0 | 0.682262 | 0.66096 | 2430
CSV | STEEL/E24-2 | 5218.9 | 25950 | 69781.9 | +5.167 | +5.245 | C107 | C107 | 1 | 1009 | GRENAILLE-PEINT | E24-2 | CSV | 17.7593 | 17.931 | 0.00226233 | 0.0022842 | 0 | 0.682262 | 0.66096 | 2430
CSV | STEEL/E24-2 | 5238.24 | 33755 | 69623.6 | +5.186 | +5.264 | C109 | C109 | 1 | 1009 | GRENAILLE-PEINT | E24-2 | CSV | 17.6862 | 17.8572 | 0.00225302 | 0.0022748 | 0 | 0.679462 | 0.65824 | 2420
CSV | STEEL/E24-2 | 4857.34 | 2129.46 | 77408.3 | +4.787 | +4.957 | C102 | C102 | 1 | 1009 | GRENAILLE-PEINT | E24-2 | CSV | 24.0794 | 24.3121 | 0.00306743 | 0.00309709 | 0 | 0.924399 | 0.896178 | 3294.77
CSV | STEEL/E24-2 | 4809.2 | 2129.46 | 77406.8 | +4.709 | +4.880 | C102 | C102 | 1 | 1009 | GRENAILLE-PEINT | E24-2 | CSV | 24.0794 | 24.3121 | 0.00306743 | 0.00309709 | 0 | 0.924399 | 0.896178 | 3294.77
CSV | STEEL/E24-2 | 4781.28 | 33755 | 73364.8 | +4.733 | +4.804 | C109 | C109 | 1 | 1009 | GRENAILLE-PEINT | E24-2 | CSV | 17.6862 | 17.8572 | 0.00225302 | 0.0022748 | 0 | 0.679462 | 0.65824 | 2420
CSV | STEEL/E24-2 | 4829.08 | 33755 | 73370.6 | +4.803 | +4.881 | C109 | C109 | 1 | 1009 | GRENAILLE-PEINT | E24-2 | CSV | 17.6862 | 17.8572 | 0.00225302 | 0.0022748 | 0 | 0.679462 | 0.65824 | 2420
CSV | STEEL/E24-2 | 4829.08 | 38950 | 73370.6 | +4.803 | +4.881 | C108 | C108 | 1 | 1004 | GRENAILLE-PEINT | E24-2 | CSV | 17.7593 | 17.931 | 0.00226233 | 0.0022842 | 0 | 0.682262 | 0.66096 | 2430
CSV | STEEL/E24-2 | 4781.28 | 38950 | 73364.8 | +4.733 | +4.804 | C108 | C108 | 1 | 1004 | GRENAILLE-PEINT | E24-2 | CSV | 17.7593 | 17.931 | 0.00226233 | 0.0022842 | 0 | 0.682262 | 0.66096 | 2430
CSV | STEEL/E24-2 | 4829.08 | 36350 | 73370.6 | +4.803 | +4.881 | C108 | C108 | 1 | 1004 | GRENAILLE-PEINT | E24-2 | CSV | 17.7593 | 17.931 | 0.00226233 | 0.0022842 | 0 | 0.682262 | 0.66096 | 2430
CSV | STEEL/E24-2 | 4781.28 | 36350 | 73364.8 | +4.733 | +4.804 | C108 | C108 | 1 | 1004 | GRENAILLE-PEINT | E24-2 | CSV | 17.7593 | 17.931 | 0.00226233 | 0.0022842 | 0 | 0.682262 | 0.66096 | 2430
CSV | STEEL/E24-2 | 4829.08 | 44150 | 73370.6 | +4.803 | +4.881 | C108 | C108 | 1 | 1004 | GRENAILLE-PEINT | E24-2 | CSV | 17.7593 | 17.931 | 0.00226233 | 0.0022842 | 0 | 0.682262 | 0.66096 | 2430
CSV | STEEL/E24-2 | 4781.28 | 49350 | 73364.8 | +4.733 | +4.804 | C108 | C108 | 1 | 1004 | GRENAILLE-PEINT | E24-2 | CSV | 17.7593 | 17.931 | 0.00226233 | 0.0022842 | 0 | 0.682262 | 0.66096 | 2430
CSV | STEEL/E24-2 | 4829.08 | 49350 | 73370.6 | +4.803 | +4.881 | C108 | C108 | 1 | 1004 | GRENAILLE-PEINT | E24-2 | CSV | 17.7593 | 17.931 | 0.00226233 | 0.0022842 | 0 | 0.682262 | 0.66096 | 2430
CSV | STEEL/E24-2 | 4781.28 | 46750 | 73364.8 | +4.733 | +4.804 | C108 | C108 | 1 | 1004 | GRENAILLE-PEINT | E24-2 | CSV | 17.7593 | 17.931 | 0.00226233 | 0.0022842 | 0 | 0.682262 | 0.66096 | 2430
CSV | STEEL/E24-2 | 4829.08 | 51950 | 73370.6 | +4.803 | +4.881 | C108 | C108 | 1 | 1004 | GRENAILLE-PEINT | E24-2 | CSV | 17.7593 | 17.931 | 0.00226233 | 0.0022842 | 0 | 0.682262 | 0.66096 | 2430
CSV | STEEL/E24-2 | 4781.28 | 51950 | 73364.8 | +4.733 | +4.804 | C108 | C108 | 1 | 1004 | GRENAILLE-PEINT | E24-2 | CSV | 17.7593 | 17.931 | 0.00226233 | 0.0022842 | 0 | 0.682262 | 0.66096 | 2430
CSV | STEEL/E24-2 | 4781.28 | 57150 | 73364.8 | +4.733 | +4.804 | C108 | C108 | 1 | 1004 | GRENAILLE-PEINT | E24-2 | CSV | 17.7593 | 17.931 | 0.00226233 | 0.0022842 | 0 | 0.682262 | 0.66096 | 2430
CSV | STEEL/E24-2 | 4829.08 | 57150 | 73370.6 | +4.803 | +4.881 | C108 | C108 | 1 | 1004 | GRENAILLE-PEINT | E24-2 | CSV | 17.7593 | 17.931 | 0.00226233 | 0.0022842 | 0 | 0.682262 | 0.66096 | 2430
CSV | STEEL/E24-2 | 4829.08 | 59750 | 73370.6 | +4.803 | +4.881 | C108 | C108 | 1 | 1004 | GRENAILLE-PEINT | E24-2 | CSV | 17.7593 | 17.931 | 0.00226233 | 0.0022842 | 0 | 0.682262 | 0.66096 | 2430
CSV | STEEL/E24-2 | 4781.28 | 59750 | 73364.8 | +4.733 | +4.804 | C108 | C108 | 1 | 1004 | GRENAILLE-PEINT | E24-2 | CSV | 17.7593 | 17.931 | 0.00226233 | 0.0022842 | 0 | 0.682262 | 0.66096 | 2430
CSV | STEEL/E24-2 | 4829.08 | 62400 | 73370.6 | +4.803 | +4.881 | C104 | C104 | 1 | 1004 | GRENAILLE-PEINT | E24-2 | CSV | 18.4901 | 18.6689 | 0.00235543 | 0.0023782 | 0 | 0.710262 | 0.68816 | 2530
CSV | STEEL/E24-2 | 4781.28 | 62400 | 73364.8 | +4.733 | +4.804 | C104 | C104 | 1 | 1004 | GRENAILLE-PEINT | E24-2 | CSV | 18.4901 | 18.6689 | 0.00235543 | 0.0023782 | 0 | 0.710262 | 0.68816 | 2530
CSV | STEEL/E24-2 | 4829.08 | 41550 | 73370.6 | +4.803 | +4.881 | C108 | C108 | 1 | 1004 | GRENAILLE-PEINT | E24-2 | CSV | 17.7593 | 17.931 | 0.00226233 | 0.0022842 | 0 | 0.682262 | 0.66096 | 2430
CSV | STEEL/E24-2 | 4781.28 | 41550 | 73364.8 | +4.733 | +4.804 | C108 | C108 | 1 | 1004 | GRENAILLE-PEINT | E24-2 | CSV | 17.7593 | 17.931 | 0.00226233 | 0.0022842 | 0 | 0.682262 | 0.66096 | 2430
ATTACHE | STEEL/E24-2 | 5468.32 | 40275.2 | 67739.8 | +5.411 | +5.496 | H38 | H38 | 1 | 1004 | GRENAILLE-PEINT | E24-2 | ATTACHE | 0.877002 | 0.88548 | 0.00011172 | 0.0001128 | 0 | 0.035462 | 0.03264 | 120
ATTACHE | STEEL/E24-2 | 5468.32 | 40224.8 | 67739.8 | +5.411 | +5.496 | H38 | H38 | 1 | 1004 | GRENAILLE-PEINT | E24-2 | ATTACHE | 0.877002 | 0.88548 | 0.00011172 | 0.0001128 | 0 | 0.035462 | 0.03264 | 120
CSV | STEEL/E24-2 | 4781.28 | 44150 | 73364.8 | +4.733 | +4.804 | C108 | C108 | 1 | 1004 | GRENAILLE-PEINT | E24-2 | CSV | 17.7593 | 17.931 | 0.00226233 | 0.0022842 | 0 | 0.682262 | 0.66096 | 2430
CSV | STEEL/E24-2 | 4829.08 | 46750 | 73370.6 | +4.803 | +4.881 | C108 | C108 | 1 | 1004 | GRENAILLE-PEINT | E24-2 | CSV | 17.7593 | 17.931 | 0.00226233 | 0.0022842 | 0 | 0.682262 | 0.66096 | 2430
CSV | STEEL/E24-2 | 4829.08 | 54550 | 73370.6 | +4.803 | +4.881 | C108 | C108 | 1 | 1004 | GRENAILLE-PEINT | E24-2 | CSV | 17.7593 | 17.931 | 0.00226233 | 0.0022842 | 0 | 0.682262 | 0.66096 | 2430
CSV | STEEL/E24-2 | 4781.28 | 54550 | 73364.8 | +4.733 | +4.804 | C108 | C108 | 1 | 1004 | GRENAILLE-PEINT | E24-2 | CSV | 17.7593 | 17.931 | 0.00226233 | 0.0022842 | 0 | 0.682262 | 0.66096 | 2430
 | STEEL/E24-2 | 5412.02 | 69167.1 | 55803.4 | +5.362 | +5.432 | 614 | L44 | 1 | 1003 | GRENAILLE-PEINT | E24-2 |  | 0.854277 | 0.862535 | 0.000108825 | 0.000109877 | 0.00818234 | 0.0345914 | 0.0317942 | 116.891
 | STEEL/E24-2 | 5412.02 | 69167.1 | 67478.4 | +5.362 | +5.432 | 614 | L44 | 1 | 1003 | GRENAILLE-PEINT | E24-2 |  | 0.854277 | 0.862535 | 0.000108825 | 0.000109877 | 0.00818234 | 0.0345914 | 0.0317942 | 116.891
 | STEEL/E24-2 | 5412.02 | -17.0788 | 44128.4 | +5.362 | +5.432 | 614 | L43 | 3 | 3003 | GRENAILLE-PEINT | E24-2 |  | 0.854277 | 0.862535 | 0.000108825 | 0.000109877 | 0.00818234 | 0.0345914 | 0.0317942 | 116.891
 | STEEL/E24-2 | 5741.5 | 18.079 | 44085.1 | +5.604 | +5.878 | 613 | P22 | 1 | 1001 | GRENAILLE-PEINT | E24-2 |  | 2.00249 | 2.02185 | 0.000255094 | 0.00025756 | 0.000931 | 0.078582 | 0.074528 | 274
LISSE | STEEL/S235JR | 4903.41 | 13538.9 | 79024.9 | +3.983 | +5.824 | 601 | L11 | 1 | 1003 | GRENAILLE-PEINT | S235JR | LISSE | 13.4559 | 13.586 | 0.00171413 | 0.0017307 | 0.000931 | 0.51739 | 0.500798 | 1841.17
CSV | STEEL/E24-2 | 4781.28 | 42815 | 38339.8 | +4.733 | +4.804 | C117 | C117 | 3 | 3004 | GRENAILLE-PEINT | E24-2 | CSV | 37.2726 | 37.6329 | 0.0047481 | 0.004794 | 0 | 1.42986 | 1.3872 | 5100
CSV | STEEL/E24-2 | 4781.28 | 48047.5 | 38339.8 | +4.733 | +4.804 | C120 | C120 | 3 | 3004 | GRENAILLE-PEINT | E24-2 | CSV | 36.7245 | 37.0795 | 0.00467828 | 0.0047235 | 0 | 1.40886 | 1.3668 | 5025
ATTACHE | STEEL/E24-2 | 5468.32 | 40275.2 | 32714.8 | +5.411 | +5.496 | H39 | H39 | 3 | 3004 | GRENAILLE-PEINT | E24-2 | ATTACHE | 0.877002 | 0.88548 | 0.00011172 | 0.0001128 | 0 | 0.035462 | 0.03264 | 120
CSV | STEEL/E24-2 | 4781.28 | 37685 | 38339.8 | +4.733 | +4.804 | C119 | C119 | 3 | 3004 | GRENAILLE-PEINT | E24-2 | CSV | 37.2726 | 37.6329 | 0.0047481 | 0.004794 | 0 | 1.42986 | 1.3872 | 5100
ATTACHE | STEEL/E24-2 | 5468.32 | 19475.2 | 67739.8 | +5.411 | +5.496 | H39 | H39 | 1 | 1009 | GRENAILLE-PEINT | E24-2 | ATTACHE | 0.877002 | 0.88548 | 0.00011172 | 0.0001128 | 0 | 0.035462 | 0.03264 | 120
CSV | STEEL/E24-2 | 4781.28 | 42815 | 61689.8 | +4.733 | +4.804 | C117 | C117 | 1 | 1004 | GRENAILLE-PEINT | E24-2 | CSV | 37.2726 | 37.6329 | 0.0047481 | 0.004794 | 0 | 1.42986 | 1.3872 | 5100
CSV | STEEL/E24-2 | 4781.28 | 32450 | 61689.8 | +4.733 | +4.804 | C118 | C118 | 1 | 1004 | GRENAILLE-PEINT | E24-2 | CSV | 36.761 | 37.1164 | 0.00468293 | 0.0047282 | 0 | 1.41026 | 1.36816 | 5030
CSV | STEEL/E24-2 | 4781.28 | 17125 | 61689.8 | +4.733 | +4.804 | C116 | C116 | 1 | 1004 | GRENAILLE-PEINT | E24-2 | CSV | 33.7646 | 34.091 | 0.00430122 | 0.0043428 | 0 | 1.29546 | 1.25664 | 4620
CSV | STEEL/E24-2 | 3599.52 | 14125 | 4668.26 | +3.579 | +3.649 | C132 | C132 | 2 | 2004 | GRENAILLE-PEINT | E24-2 | CSV | 14.3244 | 14.4628 | 0.00182476 | 0.0018424 | 0 | 0.550662 | 0.53312 | 1960
CSV | STEEL/E24-2 | 3599.52 | 11995 | 4668.26 | +3.579 | +3.649 | C132 | C132 | 2 | 2004 | GRENAILLE-PEINT | E24-2 | CSV | 14.3244 | 14.4628 | 0.00182476 | 0.0018424 | 0 | 0.550662 | 0.53312 | 1960
CSV | STEEL/E24-2 | 3599.52 | 25778.1 | 4668.26 | +3.579 | +3.649 | C131 | C131 | 2 | 2004 | GRENAILLE-PEINT | E24-2 | CSV | 17.2568 | 17.4237 | 0.00219832 | 0.00221958 | 0 | 0.663012 | 0.64226 | 2361.25
CSV | STEEL/E24-2 | 3551.39 | 30909.4 | 4666.57 | +3.501 | +3.573 | C110 | C110 | 2 | 2004 | GRENAILLE-PEINT | E24-2 | CSV | 18.2617 | 18.4383 | 0.00232634 | 0.00234883 | 0 | 0.701512 | 0.67966 | 2498.75
CSV | STEEL/E24-2 | 3599.52 | 30909.4 | 4668.26 | +3.579 | +3.649 | C110 | C110 | 2 | 2004 | GRENAILLE-PEINT | E24-2 | CSV | 18.2617 | 18.4383 | 0.00232634 | 0.00234883 | 0 | 0.701512 | 0.67966 | 2498.75
CSV | STEEL/E24-2 | 3551.39 | 33578.1 | 4666.57 | +3.501 | +3.573 | C110 | C110 | 2 | 2004 | GRENAILLE-PEINT | E24-2 | CSV | 18.2617 | 18.4383 | 0.00232634 | 0.00234883 | 0 | 0.701512 | 0.67966 | 2498.75
CSV | STEEL/E24-2 | 3599.52 | 33578.1 | 4668.26 | +3.579 | +3.649 | C110 | C110 | 2 | 2004 | GRENAILLE-PEINT | E24-2 | CSV | 18.2617 | 18.4383 | 0.00232634 | 0.00234883 | 0 | 0.701512 | 0.67966 | 2498.75
CSV | STEEL/E24-2 | 3599.52 | 47145.8 | 4668.26 | +3.579 | +3.649 | C129 | C129 | 2 | 2004 | GRENAILLE-PEINT | E24-2 | CSV | 18.9164 | 19.0993 | 0.00240974 | 0.00243303 | 0 | 0.726594 | 0.704026 | 2588.33
POUTRES | STEEL/E24-2 | 4928.09 | 46771.3 | 20875.1 | +4.250 | +5.581 | 618 | N46 | 2 | 2006 | GRENAILLE-PEINT | E24-2 | POUTRES | 17.3279 | 17.4954 | 0.00220738 | 0.00222872 | 0 | 0.665735 | 0.644905 | 2370.98
POUTRES | STEEL/E24-2 | 4928.09 | 46771.3 | 20824.9 | +4.250 | +5.581 | 618 | N46 | 2 | 2006 | GRENAILLE-PEINT | E24-2 | POUTRES | 17.3279 | 17.4954 | 0.00220738 | 0.00222872 | 0 | 0.665735 | 0.644905 | 2370.98
ATTACHE | STEEL/S235JR | 3588.83 | 32220.6 | 20753.9 | +3.499 | +3.679 | H35 | H35 | 2 | 2005 | GRENAILLE-PEINT | S235JR | ATTACHE | 1.31552 | 1.32824 | 0.000167582 | 0.000169202 | 0.000931 | 0.0522627 | 0.0489607 | 180.003
POUTRES | STEEL/E24-2 | 4874.44 | 41613.1 | 20875.1 | +4.250 | +5.474 | 617 | N46 | 2 | 2006 | GRENAILLE-PEINT | E24-2 | POUTRES | 15.8662 | 16.0196 | 0.00202118 | 0.00204072 | 0 | 0.609735 | 0.590505 | 2170.98
POUTRES | STEEL/E24-2 | 4874.44 | 41613.1 | 20824.9 | +4.250 | +5.474 | 617 | N46 | 2 | 2006 | GRENAILLE-PEINT | E24-2 | POUTRES | 15.8662 | 16.0196 | 0.00202118 | 0.00204072 | 0 | 0.609735 | 0.590505 | 2170.98
POUTRES | STEEL/E24-2 | 4925.35 | 48885.9 | 32550.1 | +4.251 | +5.578 | 619 | N43 | 3 | 3003 | GRENAILLE-PEINT | E24-2 | POUTRES | 13.1958 | 13.3233 | 0.00168099 | 0.00169724 | 0 | 0.507423 | 0.491116 | 1805.57
CSV | STEEL/E24-2 | 4781.28 | 27250 | 38339.8 | +4.733 | +4.804 | C118 | C118 | 3 | 3004 | GRENAILLE-PEINT | E24-2 | CSV | 36.761 | 37.1164 | 0.00468293 | 0.0047282 | 0 | 1.41026 | 1.36816 | 5030
POUTRES | STEEL/E24-2 | 4874.44 | 41613.1 | 32550.1 | +4.250 | +5.474 | 617 | N43 | 3 | 3003 | GRENAILLE-PEINT | E24-2 | POUTRES | 15.8662 | 16.0196 | 0.00202118 | 0.00204072 | 0 | 0.609735 | 0.590505 | 2170.98
POUTRES | STEEL/E24-2 | 4874.44 | 41613.1 | 32499.9 | +4.250 | +5.474 | 617 | N43 | 3 | 3003 | GRENAILLE-PEINT | E24-2 | POUTRES | 15.8662 | 16.0196 | 0.00202118 | 0.00204072 | 0 | 0.609735 | 0.590505 | 2170.98
ATTACHE | STEEL/S235JR | 3588.83 | 27020.6 | 20753.9 | +3.499 | +3.679 | H35 | H35 | 2 | 2005 | GRENAILLE-PEINT | S235JR | ATTACHE | 1.31552 | 1.32824 | 0.000167582 | 0.000169202 | 0.000931 | 0.0522627 | 0.0489607 | 180.003
POUTRES | STEEL/E24-2 | 4874.44 | 38886.9 | 20824.9 | +4.250 | +5.474 | 617 | N44 | 2 | 2006 | GRENAILLE-PEINT | E24-2 | POUTRES | 15.8662 | 16.0196 | 0.00202118 | 0.00204072 | 0 | 0.609735 | 0.590505 | 2170.98
POUTRES | STEEL/E24-2 | 4874.44 | 38886.9 | 20875.1 | +4.250 | +5.474 | 617 | N44 | 2 | 2006 | GRENAILLE-PEINT | E24-2 | POUTRES | 15.8662 | 16.0196 | 0.00202118 | 0.00204072 | 0 | 0.609735 | 0.590505 | 2170.98
POUTRES | STEEL/E24-2 | 4874.44 | 20813.1 | 20824.9 | +4.250 | +5.474 | 617 | N45 | 2 | 2006 | GRENAILLE-PEINT | E24-2 | POUTRES | 15.8662 | 16.0196 | 0.00202118 | 0.00204072 | 0 | 0.609735 | 0.590505 | 2170.98
POUTRES | STEEL/E24-2 | 4874.44 | 20813.1 | 20875.1 | +4.250 | +5.474 | 617 | N45 | 2 | 2006 | GRENAILLE-PEINT | E24-2 | POUTRES | 15.8662 | 16.0196 | 0.00202118 | 0.00204072 | 0 | 0.609735 | 0.590505 | 2170.98
POUTRES | STEEL/E24-2 | 4874.44 | 38886.9 | 67524.9 | +4.250 | +5.474 | 617 | N7 | 1 | 1006 | GRENAILLE-PEINT | E24-2 | POUTRES | 15.8662 | 16.0196 | 0.00202118 | 0.00204072 | 0 | 0.609735 | 0.590505 | 2170.98
POUTRES | STEEL/E24-2 | 4874.44 | 38886.9 | 67575.1 | +4.250 | +5.474 | 617 | N7 | 1 | 1006 | GRENAILLE-PEINT | E24-2 | POUTRES | 15.8662 | 16.0196 | 0.00202118 | 0.00204072 | 0 | 0.609735 | 0.590505 | 2170.98
POUTRES | STEEL/E24-2 | 4874.44 | 41613.1 | 67575.1 | +4.250 | +5.474 | 617 | N6 | 1 | 1006 | GRENAILLE-PEINT | E24-2 | POUTRES | 15.8662 | 16.0196 | 0.00202118 | 0.00204072 | 0 | 0.609735 | 0.590505 | 2170.98
POUTRES | STEEL/E24-2 | 4874.44 | 41613.1 | 67524.9 | +4.250 | +5.474 | 617 | N6 | 1 | 1006 | GRENAILLE-PEINT | E24-2 | POUTRES | 15.8662 | 16.0196 | 0.00202118 | 0.00204072 | 0 | 0.609735 | 0.590505 | 2170.98
POUTRES | STEEL/E24-2 | 4928.09 | 59771.3 | 67575.1 | +4.250 | +5.581 | 618 | N13 | 1 | 1006 | GRENAILLE-PEINT | E24-2 | POUTRES | 17.3279 | 17.4954 | 0.00220738 | 0.00222872 | 0 | 0.665735 | 0.644905 | 2370.98
POUTRES | STEEL/E24-2 | 4928.09 | 59771.3 | 67524.9 | +4.250 | +5.581 | 618 | N13 | 1 | 1006 | GRENAILLE-PEINT | E24-2 | POUTRES | 17.3279 | 17.4954 | 0.00220738 | 0.00222872 | 0 | 0.665735 | 0.644905 | 2370.98
POUTRES | STEEL/E24-2 | 4874.44 | 20813.1 | 67524.9 | +4.250 | +5.474 | 617 | N11 | 1 | 1006 | GRENAILLE-PEINT | E24-2 | POUTRES | 15.8662 | 16.0196 | 0.00202118 | 0.00204072 | 0 | 0.609735 | 0.590505 | 2170.98
POUTRES | STEEL/E24-2 | 4874.44 | 20813.1 | 67575.1 | +4.250 | +5.474 | 617 | N11 | 1 | 1006 | GRENAILLE-PEINT | E24-2 | POUTRES | 15.8662 | 16.0196 | 0.00202118 | 0.00204072 | 0 | 0.609735 | 0.590505 | 2170.98
CSV | STEEL/E24-2 | 4781.28 | 65100 | 50014.8 | +4.733 | +4.804 | C104 | C104 | 1 | 1004 | GRENAILLE-PEINT | E24-2 | CSV | 18.4901 | 18.6689 | 0.00235543 | 0.0023782 | 0 | 0.710262 | 0.68816 | 2530
CSV | STEEL/E24-2 | 4781.28 | 67800 | 50014.8 | +4.733 | +4.804 | C104 | C104 | 1 | 1004 | GRENAILLE-PEINT | E24-2 | CSV | 18.4901 | 18.6689 | 0.00235543 | 0.0023782 | 0 | 0.710262 | 0.68816 | 2530
POUTRES | STEEL/E24-2 | 4874.44 | 38886.9 | 55849.9 | +4.250 | +5.474 | 617 | N8 | 1 | 1006 | GRENAILLE-PEINT | E24-2 | POUTRES | 15.8662 | 16.0196 | 0.00202118 | 0.00204072 | 0 | 0.609735 | 0.590505 | 2170.98
POUTRES | STEEL/E24-2 | 4874.44 | 38886.9 | 55900.1 | +4.250 | +5.474 | 617 | N8 | 1 | 1006 | GRENAILLE-PEINT | E24-2 | POUTRES | 15.8662 | 16.0196 | 0.00202118 | 0.00204072 | 0 | 0.609735 | 0.590505 | 2170.98
POUTRES | STEEL/E24-2 | 4874.44 | 41613.1 | 55900.1 | +4.250 | +5.474 | 617 | N41 | 1 | 1006 | GRENAILLE-PEINT | E24-2 | POUTRES | 15.8662 | 16.0196 | 0.00202118 | 0.00204072 | 0 | 0.609735 | 0.590505 | 2170.98
POUTRES | STEEL/E24-2 | 4874.44 | 41613.1 | 55849.9 | +4.250 | +5.474 | 617 | N41 | 1 | 1006 | GRENAILLE-PEINT | E24-2 | POUTRES | 15.8662 | 16.0196 | 0.00202118 | 0.00204072 | 0 | 0.609735 | 0.590505 | 2170.98
POUTRES | STEEL/E24-2 | 4928.09 | 59771.3 | 55900.1 | +4.250 | +5.581 | 618 | N13 | 1 | 1006 | GRENAILLE-PEINT | E24-2 | POUTRES | 17.3279 | 17.4954 | 0.00220738 | 0.00222872 | 0 | 0.665735 | 0.644905 | 2370.98
POUTRES | STEEL/E24-2 | 4928.09 | 59771.3 | 55849.9 | +4.250 | +5.581 | 618 | N13 | 1 | 1006 | GRENAILLE-PEINT | E24-2 | POUTRES | 17.3279 | 17.4954 | 0.00220738 | 0.00222872 | 0 | 0.665735 | 0.644905 | 2370.98
POUTRES | STEEL/E24-2 | 4874.44 | 20813.1 | 55849.9 | +4.250 | +5.474 | 617 | N10 | 1 | 1006 | GRENAILLE-PEINT | E24-2 | POUTRES | 15.8662 | 16.0196 | 0.00202118 | 0.00204072 | 0 | 0.609735 | 0.590505 | 2170.98
POUTRES | STEEL/E24-2 | 4874.44 | 20813.1 | 55900.1 | +4.250 | +5.474 | 617 | N10 | 1 | 1006 | GRENAILLE-PEINT | E24-2 | POUTRES | 15.8662 | 16.0196 | 0.00202118 | 0.00204072 | 0 | 0.609735 | 0.590505 | 2170.98
CSV | STEEL/E24-2 | 4829.08 | 1275 | 38345.6 | +4.803 | +4.881 | C103 | C103 | 3 | 3004 | GRENAILLE-PEINT | E24-2 | CSV | 17.3939 | 17.562 | 0.00221578 | 0.0022372 | 0 | 0.668262 | 0.64736 | 2380
ATTACHE | STEEL/E24-2 | 5468.32 | 19475.2 | 32714.8 | +5.411 | +5.496 | H39 | H39 | 3 | 3004 | GRENAILLE-PEINT | E24-2 | ATTACHE | 0.877002 | 0.88548 | 0.00011172 | 0.0001128 | 0 | 0.035462 | 0.03264 | 120
POUTRES | STEEL/E24-2 | 4874.44 | 38886.9 | 32499.9 | +4.250 | +5.474 | 617 | N40 | 3 | 3006 | GRENAILLE-PEINT | E24-2 | POUTRES | 15.8662 | 16.0196 | 0.00202118 | 0.00204072 | 0 | 0.609735 | 0.590505 | 2170.98
POUTRES | STEEL/E24-2 | 4874.44 | 38886.9 | 32550.1 | +4.250 | +5.474 | 617 | N40 | 3 | 3006 | GRENAILLE-PEINT | E24-2 | POUTRES | 15.8662 | 16.0196 | 0.00202118 | 0.00204072 | 0 | 0.609735 | 0.590505 | 2170.98
POUTRES | STEEL/E24-2 | 4874.44 | 20813.1 | 32499.9 | +4.250 | +5.474 | 617 | N9 | 3 | 3006 | GRENAILLE-PEINT | E24-2 | POUTRES | 15.8662 | 16.0196 | 0.00202118 | 0.00204072 | 0 | 0.609735 | 0.590505 | 2170.98
POUTRES | STEEL/E24-2 | 4874.44 | 20813.1 | 32550.1 | +4.250 | +5.474 | 617 | N9 | 3 | 3006 | GRENAILLE-PEINT | E24-2 | POUTRES | 15.8662 | 16.0196 | 0.00202118 | 0.00204072 | 0 | 0.609735 | 0.590505 | 2170.98
ATTACHE | STEEL/E24-2 | 5468.32 | 40275.2 | 44389.8 | +5.411 | +5.496 | H39 | H39 | 1 | 1004 | GRENAILLE-PEINT | E24-2 | ATTACHE | 0.877002 | 0.88548 | 0.00011172 | 0.0001128 | 0 | 0.035462 | 0.03264 | 120
CSV | STEEL/E24-2 | 4781.28 | 27250 | 50014.8 | +4.733 | +4.804 | C118 | C118 | 1 | 1004 | GRENAILLE-PEINT | E24-2 | CSV | 36.761 | 37.1164 | 0.00468293 | 0.0047282 | 0 | 1.41026 | 1.36816 | 5030
ATTACHE | STEEL/E24-2 | 5468.32 | 40224.8 | 44389.8 | +5.411 | +5.496 | H39 | H39 | 1 | 1004 | GRENAILLE-PEINT | E24-2 | ATTACHE | 0.877002 | 0.88548 | 0.00011172 | 0.0001128 | 0 | 0.035462 | 0.03264 | 120
CSV | STEEL/E24-2 | 4781.28 | 32450 | 50014.8 | +4.733 | +4.804 | C118 | C118 | 1 | 1004 | GRENAILLE-PEINT | E24-2 | CSV | 36.761 | 37.1164 | 0.00468293 | 0.0047282 | 0 | 1.41026 | 1.36816 | 5030
CSV | STEEL/E24-2 | 4781.28 | 37685 | 50014.8 | +4.733 | +4.804 | C119 | C119 | 1 | 1004 | GRENAILLE-PEINT | E24-2 | CSV | 37.2726 | 37.6329 | 0.0047481 | 0.004794 | 0 | 1.42986 | 1.3872 | 5100
ATTACHE | STEEL/E24-2 | 5468.32 | 19475.2 | 44389.8 | +5.411 | +5.496 | H39 | H39 | 1 | 1004 | GRENAILLE-PEINT | E24-2 | ATTACHE | 0.877002 | 0.88548 | 0.00011172 | 0.0001128 | 0 | 0.035462 | 0.03264 | 120
CSV | STEEL/E24-2 | 4781.28 | 58450 | 50014.8 | +4.733 | +4.804 | C118 | C118 | 1 | 1004 | GRENAILLE-PEINT | E24-2 | CSV | 36.761 | 37.1164 | 0.00468293 | 0.0047282 | 0 | 1.41026 | 1.36816 | 5030
ATTACHE | STEEL/E24-2 | 5468.32 | 19424.8 | 44389.8 | +5.411 | +5.496 | H39 | H39 | 1 | 1004 | GRENAILLE-PEINT | E24-2 | ATTACHE | 0.877002 | 0.88548 | 0.00011172 | 0.0001128 | 0 | 0.035462 | 0.03264 | 120
CSV | STEEL/E24-2 | 4781.28 | 53250 | 50014.8 | +4.733 | +4.804 | C118 | C118 | 1 | 1004 | GRENAILLE-PEINT | E24-2 | CSV | 36.761 | 37.1164 | 0.00468293 | 0.0047282 | 0 | 1.41026 | 1.36816 | 5030
CSV | STEEL/E24-2 | 4781.28 | 42815 | 50014.8 | +4.733 | +4.804 | C117 | C117 | 1 | 1004 | GRENAILLE-PEINT | E24-2 | CSV | 37.2726 | 37.6329 | 0.0047481 | 0.004794 | 0 | 1.42986 | 1.3872 | 5100
CSV | STEEL/E24-2 | 4829.08 | 67800 | 50020.6 | +4.803 | +4.881 | C104 | C104 | 1 | 1004 | GRENAILLE-PEINT | E24-2 | CSV | 18.4901 | 18.6689 | 0.00235543 | 0.0023782 | 0 | 0.710262 | 0.68816 | 2530
ATTACHE | STEEL/E24-2 | 5468.32 | 19424.8 | 32714.8 | +5.411 | +5.496 | H39 | H39 | 3 | 3004 | GRENAILLE-PEINT | E24-2 | ATTACHE | 0.877002 | 0.88548 | 0.00011172 | 0.0001128 | 0 | 0.035462 | 0.03264 | 120
CSV | STEEL/E24-2 | 4829.08 | 65100 | 50020.6 | +4.803 | +4.881 | C104 | C104 | 1 | 1004 | GRENAILLE-PEINT | E24-2 | CSV | 18.4901 | 18.6689 | 0.00235543 | 0.0023782 | 0 | 0.710262 | 0.68816 | 2530
CSV | STEEL/E24-2 | 4781.28 | 12370 | 38339.8 | +4.733 | +4.804 | C115 | C115 | 3 | 3004 | GRENAILLE-PEINT | E24-2 | CSV | 33.253 | 33.5744 | 0.00423605 | 0.004277 | 0 | 1.27586 | 1.2376 | 4550
CSV | STEEL/E24-2 | 4829.08 | 3825 | 38345.6 | +4.803 | +4.881 | C103 | C103 | 3 | 3004 | GRENAILLE-PEINT | E24-2 | CSV | 17.3939 | 17.562 | 0.00221578 | 0.0022372 | 0 | 0.668262 | 0.64736 | 2380
CSV | STEEL/E24-2 | 4781.28 | 3825 | 38339.8 | +4.733 | +4.804 | C103 | C103 | 3 | 3004 | GRENAILLE-PEINT | E24-2 | CSV | 17.3939 | 17.562 | 0.00221578 | 0.0022372 | 0 | 0.668262 | 0.64736 | 2380
CSV | STEEL/E24-2 | 4781.28 | 1275 | 38339.8 | +4.733 | +4.804 | C103 | C103 | 3 | 3004 | GRENAILLE-PEINT | E24-2 | CSV | 17.3939 | 17.562 | 0.00221578 | 0.0022372 | 0 | 0.668262 | 0.64736 | 2380
CSV | STEEL/E24-2 | 4781.28 | 7555 | 38339.8 | +4.733 | +4.804 | C113 | C113 | 3 | 3004 | GRENAILLE-PEINT | E24-2 | CSV | 34.6416 | 34.9765 | 0.00441294 | 0.0044556 | 0 | 1.32906 | 1.28928 | 4740
CSV | STEEL/E24-2 | 4781.28 | 48050 | 50014.8 | +4.733 | +4.804 | C118 | C118 | 1 | 1004 | GRENAILLE-PEINT | E24-2 | CSV | 36.761 | 37.1164 | 0.00468293 | 0.0047282 | 0 | 1.41026 | 1.36816 | 5030
POUTRES | STEEL/E24-2 | 4874.44 | 38886.9 | 44174.9 | +4.250 | +5.474 | 617 | N8 | 1 | 1006 | GRENAILLE-PEINT | E24-2 | POUTRES | 15.8662 | 16.0196 | 0.00202118 | 0.00204072 | 0 | 0.609735 | 0.590505 | 2170.98
POUTRES | STEEL/E24-2 | 4874.44 | 38886.9 | 44225.1 | +4.250 | +5.474 | 617 | N8 | 1 | 1006 | GRENAILLE-PEINT | E24-2 | POUTRES | 15.8662 | 16.0196 | 0.00202118 | 0.00204072 | 0 | 0.609735 | 0.590505 | 2170.98
POUTRES | STEEL/E24-2 | 4874.44 | 20813.1 | 44174.9 | +4.250 | +5.474 | 617 | N10 | 1 | 1006 | GRENAILLE-PEINT | E24-2 | POUTRES | 15.8662 | 16.0196 | 0.00202118 | 0.00204072 | 0 | 0.609735 | 0.590505 | 2170.98
POUTRES | STEEL/E24-2 | 4874.44 | 41613.1 | 44225.1 | +4.250 | +5.474 | 617 | N41 | 1 | 1006 | GRENAILLE-PEINT | E24-2 | POUTRES | 15.8662 | 16.0196 | 0.00202118 | 0.00204072 | 0 | 0.609735 | 0.590505 | 2170.98
POUTRES | STEEL/E24-2 | 4874.44 | 41613.1 | 44174.9 | +4.250 | +5.474 | 617 | N41 | 1 | 1006 | GRENAILLE-PEINT | E24-2 | POUTRES | 15.8662 | 16.0196 | 0.00202118 | 0.00204072 | 0 | 0.609735 | 0.590505 | 2170.98
POUTRES | STEEL/E24-2 | 4928.09 | 59771.3 | 44225.1 | +4.250 | +5.581 | 618 | N42 | 1 | 1006 | GRENAILLE-PEINT | E24-2 | POUTRES | 17.3279 | 17.4954 | 0.00220738 | 0.00222872 | 0 | 0.665735 | 0.644905 | 2370.98
POUTRES | STEEL/E24-2 | 4928.09 | 59771.3 | 44174.9 | +4.250 | +5.581 | 618 | N42 | 1 | 1006 | GRENAILLE-PEINT | E24-2 | POUTRES | 17.3279 | 17.4954 | 0.00220738 | 0.00222872 | 0 | 0.665735 | 0.644905 | 2370.98
POUTRES | STEEL/E24-2 | 4874.44 | 20813.1 | 44225.1 | +4.250 | +5.474 | 617 | N10 | 1 | 1006 | GRENAILLE-PEINT | E24-2 | POUTRES | 15.8662 | 16.0196 | 0.00202118 | 0.00204072 | 0 | 0.609735 | 0.590505 | 2170.98
ATTACHE | STEEL/S235JR | 3901.87 | 37604.4 | 24.3726 | +3.812 | +3.992 | H35 | H35 | 2 | 2005 | GRENAILLE-PEINT | S235JR | ATTACHE | 1.31552 | 1.32824 | 0.000167582 | 0.000169202 | 0.000931 | 0.0522627 | 0.0489607 | 180.003
STABILITE | STEEL/E24-2 | 3859.08 | 69173.1 | 47135.3 | +2.275 | +5.469 | V13 | V13 | 1 | 1002 | GRENAILLE-PEINT | E24-2 | STABILITE | 47.0726 | 47.4981 | 0.00599651 | 0.00605072 | 0 | 1.80532 | 1.75085 | 6436.93
STABILITE | STEEL/E24-2 | 3859.08 | 69126.9 | 47135.3 | +2.275 | +5.469 | V13 | V13 | 1 | 1002 | GRENAILLE-PEINT | E24-2 | STABILITE | 47.0726 | 47.4981 | 0.00599651 | 0.00605072 | 0 | 1.80532 | 1.75085 | 6436.93
STABILITE | STEEL/E24-2 | 935.787 | 69173.1 | 47145.2 | -0.358 | +2.257 | V14 | V14 | 1 | 1002 | GRENAILLE-PEINT | E24-2 | STABILITE | 45.2189 | 45.6265 | 0.00576036 | 0.00581229 | 0 | 1.7343 | 1.68185 | 6183.29
STABILITE | STEEL/E24-2 | 935.787 | 69126.9 | 47145.2 | -0.358 | +2.257 | V14 | V14 | 1 | 1002 | GRENAILLE-PEINT | E24-2 | STABILITE | 45.2189 | 45.6265 | 0.00576036 | 0.00581229 | 0 | 1.7343 | 1.68185 | 6183.29
CSV | STEEL/E24-2 | 4781.28 | 17125 | 50014.8 | +4.733 | +4.804 | C116 | C116 | 1 | 1004 | GRENAILLE-PEINT | E24-2 | CSV | 33.7646 | 34.091 | 0.00430122 | 0.0043428 | 0 | 1.29546 | 1.25664 | 4620
CSV | STEEL/E24-2 | 4781.28 | 7555 | 50014.8 | +4.733 | +4.804 | C113 | C113 | 1 | 1004 | GRENAILLE-PEINT | E24-2 | CSV | 34.6416 | 34.9765 | 0.00441294 | 0.0044556 | 0 | 1.32906 | 1.28928 | 4740
CSV | STEEL/E24-2 | 4829.08 | 1275 | 50020.6 | +4.803 | +4.881 | C103 | C103 | 1 | 1004 | GRENAILLE-PEINT | E24-2 | CSV | 17.3939 | 17.562 | 0.00221578 | 0.0022372 | 0 | 0.668262 | 0.64736 | 2380
CSV | STEEL/E24-2 | 4781.28 | 1275 | 50014.8 | +4.733 | +4.804 | C103 | C103 | 1 | 1004 | GRENAILLE-PEINT | E24-2 | CSV | 17.3939 | 17.562 | 0.00221578 | 0.0022372 | 0 | 0.668262 | 0.64736 | 2380
CSV | STEEL/E24-2 | 4781.28 | 22015 | 50014.8 | +4.733 | +4.804 | C117 | C117 | 1 | 1004 | GRENAILLE-PEINT | E24-2 | CSV | 37.2726 | 37.6329 | 0.0047481 | 0.004794 | 0 | 1.42986 | 1.3872 | 5100
CSV | STEEL/E24-2 | 4829.08 | 3825 | 50020.6 | +4.803 | +4.881 | C103 | C103 | 1 | 1004 | GRENAILLE-PEINT | E24-2 | CSV | 17.3939 | 17.562 | 0.00221578 | 0.0022372 | 0 | 0.668262 | 0.64736 | 2380
CSV | STEEL/E24-2 | 4781.28 | 12370 | 50014.8 | +4.733 | +4.804 | C115 | C115 | 1 | 1004 | GRENAILLE-PEINT | E24-2 | CSV | 33.253 | 33.5744 | 0.00423605 | 0.004277 | 0 | 1.27586 | 1.2376 | 4550
CSV | STEEL/E24-2 | 4781.28 | 62400 | 50014.8 | +4.733 | +4.804 | C121 | C121 | 1 | 1004 | GRENAILLE-PEINT | E24-2 | CSV | 18.4901 | 18.6689 | 0.00235543 | 0.0023782 | 0 | 0.710262 | 0.68816 | 2530
CSV | STEEL/E24-2 | 4781.28 | 3825 | 50014.8 | +4.733 | +4.804 | C103 | C103 | 1 | 1004 | GRENAILLE-PEINT | E24-2 | CSV | 17.3939 | 17.562 | 0.00221578 | 0.0022372 | 0 | 0.668262 | 0.64736 | 2380
CSV | STEEL/E24-2 | 4781.28 | 48050 | 61689.8 | +4.733 | +4.804 | C118 | C118 | 1 | 1004 | GRENAILLE-PEINT | E24-2 | CSV | 36.761 | 37.1164 | 0.00468293 | 0.0047282 | 0 | 1.41026 | 1.36816 | 5030
CSV | STEEL/E24-2 | 4781.28 | 58450 | 61689.8 | +4.733 | +4.804 | C118 | C118 | 1 | 1004 | GRENAILLE-PEINT | E24-2 | CSV | 36.761 | 37.1164 | 0.00468293 | 0.0047282 | 0 | 1.41026 | 1.36816 | 5030
CSV | STEEL/E24-2 | 4781.28 | 53250 | 61689.8 | +4.733 | +4.804 | C118 | C118 | 1 | 1004 | GRENAILLE-PEINT | E24-2 | CSV | 36.761 | 37.1164 | 0.00468293 | 0.0047282 | 0 | 1.41026 | 1.36816 | 5030
CSV | STEEL/E24-2 | 4781.28 | 7555 | 61689.8 | +4.733 | +4.804 | C113 | C113 | 1 | 1004 | GRENAILLE-PEINT | E24-2 | CSV | 34.6416 | 34.9765 | 0.00441294 | 0.0044556 | 0 | 1.32906 | 1.28928 | 4740
CSV | STEEL/E24-2 | 4781.28 | 12370 | 61689.8 | +4.733 | +4.804 | C115 | C115 | 1 | 1004 | GRENAILLE-PEINT | E24-2 | CSV | 33.253 | 33.5744 | 0.00423605 | 0.004277 | 0 | 1.27586 | 1.2376 | 4550
CSV | STEEL/E24-2 | 4781.28 | 22015 | 61689.8 | +4.733 | +4.804 | C117 | C117 | 1 | 1004 | GRENAILLE-PEINT | E24-2 | CSV | 37.2726 | 37.6329 | 0.0047481 | 0.004794 | 0 | 1.42986 | 1.3872 | 5100
CSV | STEEL/E24-2 | 4781.28 | 37685 | 61689.8 | +4.733 | +4.804 | C119 | C119 | 1 | 1004 | GRENAILLE-PEINT | E24-2 | CSV | 37.2726 | 37.6329 | 0.0047481 | 0.004794 | 0 | 1.42986 | 1.3872 | 5100
CSV | STEEL/E24-2 | 4781.28 | 62400 | 61689.8 | +4.733 | +4.804 | C121 | C121 | 1 | 1004 | GRENAILLE-PEINT | E24-2 | CSV | 18.4901 | 18.6689 | 0.00235543 | 0.0023782 | 0 | 0.710262 | 0.68816 | 2530
CSV | STEEL/E24-2 | 4781.28 | 1275 | 61689.8 | +4.733 | +4.804 | C103 | C103 | 1 | 1004 | GRENAILLE-PEINT | E24-2 | CSV | 17.3939 | 17.562 | 0.00221578 | 0.0022372 | 0 | 0.668262 | 0.64736 | 2380
CSV | STEEL/E24-2 | 4829.08 | 1275 | 61695.6 | +4.803 | +4.881 | C103 | C103 | 1 | 1004 | GRENAILLE-PEINT | E24-2 | CSV | 17.3939 | 17.562 | 0.00221578 | 0.0022372 | 0 | 0.668262 | 0.64736 | 2380
CSV | STEEL/E24-2 | 4781.28 | 3825 | 61689.8 | +4.733 | +4.804 | C103 | C103 | 1 | 1004 | GRENAILLE-PEINT | E24-2 | CSV | 17.3939 | 17.562 | 0.00221578 | 0.0022372 | 0 | 0.668262 | 0.64736 | 2380
CSV | STEEL/E24-2 | 4829.08 | 3825 | 61695.6 | +4.803 | +4.881 | C103 | C103 | 1 | 1004 | GRENAILLE-PEINT | E24-2 | CSV | 17.3939 | 17.562 | 0.00221578 | 0.0022372 | 0 | 0.668262 | 0.64736 | 2380
CSV | STEEL/E24-2 | 4829.08 | 65100 | 61695.6 | +4.803 | +4.881 | C104 | C104 | 1 | 1004 | GRENAILLE-PEINT | E24-2 | CSV | 18.4901 | 18.6689 | 0.00235543 | 0.0023782 | 0 | 0.710262 | 0.68816 | 2530
CSV | STEEL/E24-2 | 4829.08 | 67800 | 61695.6 | +4.803 | +4.881 | C104 | C104 | 1 | 1004 | GRENAILLE-PEINT | E24-2 | CSV | 18.4901 | 18.6689 | 0.00235543 | 0.0023782 | 0 | 0.710262 | 0.68816 | 2530
CSV | STEEL/E24-2 | 4781.28 | 22015 | 38339.8 | +4.733 | +4.804 | C117 | C117 | 3 | 3004 | GRENAILLE-PEINT | E24-2 | CSV | 37.2726 | 37.6329 | 0.0047481 | 0.004794 | 0 | 1.42986 | 1.3872 | 5100
CSV | STEEL/E24-2 | 4781.28 | 32450 | 38339.8 | +4.733 | +4.804 | C118 | C118 | 3 | 3004 | GRENAILLE-PEINT | E24-2 | CSV | 36.761 | 37.1164 | 0.00468293 | 0.0047282 | 0 | 1.41026 | 1.36816 | 5030
CSV | STEEL/E24-2 | 4744.29 | 51950 | 38370.4 | +4.692 | +4.770 | C122 | C122 | 3 | 3004 | GRENAILLE-PEINT | E24-2 | CSV | 17.6862 | 17.8572 | 0.00225302 | 0.0022748 | 0 | 0.679462 | 0.65824 | 2420
CSV | STEEL/E24-2 | 4744.29 | 54550 | 38370.4 | +4.692 | +4.770 | C122 | C122 | 3 | 3004 | GRENAILLE-PEINT | E24-2 | CSV | 17.6862 | 17.8572 | 0.00225302 | 0.0022748 | 0 | 0.679462 | 0.65824 | 2420
CSV | STEEL/E24-2 | 4744.29 | 57150 | 38370.4 | +4.692 | +4.770 | C122 | C122 | 3 | 3004 | GRENAILLE-PEINT | E24-2 | CSV | 17.6862 | 17.8572 | 0.00225302 | 0.0022748 | 0 | 0.679462 | 0.65824 | 2420
CSV | STEEL/E24-2 | 4744.29 | 59747.5 | 38370.4 | +4.692 | +4.770 | C123 | C123 | 3 | 3004 | GRENAILLE-PEINT | E24-2 | CSV | 17.6497 | 17.8203 | 0.00224837 | 0.0022701 | 0 | 0.678062 | 0.65688 | 2415
CSV | STEEL/E24-2 | 4744.3 | 62402.5 | 38370.4 | +4.692 | +4.770 | C124 | C124 | 3 | 3004 | GRENAILLE-PEINT | E24-2 | CSV | 18.3805 | 18.5582 | 0.00234147 | 0.0023641 | 0 | 0.706062 | 0.68408 | 2515
CSV | STEEL/E24-2 | 4747.92 | 65100 | 38340.8 | +4.700 | +4.770 | C125 | C125 | 3 | 3004 | GRENAILLE-PEINT | E24-2 | CSV | 18.417 | 18.5951 | 0.00234612 | 0.0023688 | 0 | 0.707462 | 0.68544 | 2520
CSV | STEEL/E24-2 | 4795.72 | 65100 | 38346.6 | +4.770 | +4.848 | C125 | C125 | 3 | 3004 | GRENAILLE-PEINT | E24-2 | CSV | 18.417 | 18.5951 | 0.00234612 | 0.0023688 | 0 | 0.707462 | 0.68544 | 2520
CSV | STEEL/E24-2 | 4747.92 | 67802.5 | 38340.8 | +4.700 | +4.770 | C126 | C126 | 3 | 3004 | GRENAILLE-PEINT | E24-2 | CSV | 18.4536 | 18.632 | 0.00235077 | 0.0023735 | 0 | 0.708862 | 0.6868 | 2525
CSV | STEEL/E24-2 | 4795.72 | 67802.5 | 38346.6 | +4.770 | +4.848 | C126 | C126 | 3 | 3004 | GRENAILLE-PEINT | E24-2 | CSV | 18.4536 | 18.632 | 0.00235078 | 0.0023735 | 0 | 0.708862 | 0.6868 | 2525
CSV | STEEL/E24-2 | 4781.28 | 1275 | 26664.8 | +4.733 | +4.804 | C103 | C103 | 3 | 3004 | GRENAILLE-PEINT | E24-2 | CSV | 17.3939 | 17.562 | 0.00221578 | 0.0022372 | 0 | 0.668262 | 0.64736 | 2380
CSV | STEEL/E24-2 | 4781.28 | 17125 | 38339.8 | +4.733 | +4.804 | C116 | C116 | 3 | 3004 | GRENAILLE-PEINT | E24-2 | CSV | 33.7646 | 34.091 | 0.00430122 | 0.0043428 | 0 | 1.29546 | 1.25664 | 4620
CSV | STEEL/E24-2 | 4781.28 | 67800 | 61689.8 | +4.733 | +4.804 | C104 | C104 | 1 | 1004 | GRENAILLE-PEINT | E24-2 | CSV | 18.4901 | 18.6689 | 0.00235543 | 0.0023782 | 0 | 0.710262 | 0.68816 | 2530
CSV | STEEL/E24-2 | 4829.08 | 1275 | 26670.6 | +4.803 | +4.881 | C103 | C103 | 3 | 3004 | GRENAILLE-PEINT | E24-2 | CSV | 17.3939 | 17.562 | 0.00221578 | 0.0022372 | 0 | 0.668262 | 0.64736 | 2380
CSV | STEEL/E24-2 | 3599.52 | 16255 | 4668.26 | +3.579 | +3.649 | C132 | C132 | 2 | 2004 | GRENAILLE-PEINT | E24-2 | CSV | 14.3244 | 14.4628 | 0.00182476 | 0.0018424 | 0 | 0.550662 | 0.53312 | 1960
CSV | STEEL/E24-2 | 3599.52 | 28309.4 | 4668.26 | +3.579 | +3.649 | C131 | C131 | 2 | 2004 | GRENAILLE-PEINT | E24-2 | CSV | 17.2568 | 17.4237 | 0.00219832 | 0.00221958 | 0 | 0.663012 | 0.64226 | 2361.25
CSV | STEEL/E24-2 | 3599.52 | 18385 | 4668.26 | +3.579 | +3.649 | C132 | C132 | 2 | 2004 | GRENAILLE-PEINT | E24-2 | CSV | 14.3244 | 14.4628 | 0.00182476 | 0.0018424 | 0 | 0.550662 | 0.53312 | 1960
CSV | STEEL/E24-2 | 3599.52 | 20715.6 | 4668.26 | +3.579 | +3.649 | C131 | C131 | 2 | 2004 | GRENAILLE-PEINT | E24-2 | CSV | 17.2568 | 17.4237 | 0.00219832 | 0.00221958 | 0 | 0.663012 | 0.64226 | 2361.25
CSV | STEEL/E24-2 | 3599.52 | 23246.9 | 4668.26 | +3.579 | +3.649 | C131 | C131 | 2 | 2004 | GRENAILLE-PEINT | E24-2 | CSV | 17.2568 | 17.4237 | 0.00219832 | 0.00221958 | 0 | 0.663012 | 0.64226 | 2361.25
CSV | STEEL/E24-2 | 3599.52 | 36246.9 | 4668.26 | +3.579 | +3.649 | C130 | C130 | 2 | 2004 | GRENAILLE-PEINT | E24-2 | CSV | 18.2617 | 18.4383 | 0.00232634 | 0.00234883 | 0 | 0.701512 | 0.67966 | 2498.75
CSV | STEEL/E24-2 | 3599.52 | 38915.6 | 4668.26 | +3.579 | +3.649 | C130 | C130 | 2 | 2004 | GRENAILLE-PEINT | E24-2 | CSV | 18.2617 | 18.4383 | 0.00232634 | 0.00234883 | 0 | 0.701512 | 0.67966 | 2498.75
CSV | STEEL/E24-2 | 3599.52 | 41629.2 | 4668.26 | +3.579 | +3.649 | C129 | C129 | 2 | 2004 | GRENAILLE-PEINT | E24-2 | CSV | 18.9164 | 19.0993 | 0.00240974 | 0.00243303 | 0 | 0.726594 | 0.704026 | 2588.33
CSV | STEEL/E24-2 | 3599.52 | 44387.5 | 4668.26 | +3.579 | +3.649 | C129 | C129 | 2 | 2004 | GRENAILLE-PEINT | E24-2 | CSV | 18.9165 | 19.0994 | 0.00240974 | 0.00243304 | 0 | 0.726597 | 0.704029 | 2588.34
CSV | STEEL/E24-2 | 5286.04 | 33755 | 69629.4 | +5.264 | +5.334 | C109 | C109 | 1 | 1009 | GRENAILLE-PEINT | E24-2 | CSV | 17.6862 | 17.8572 | 0.00225302 | 0.0022748 | 0 | 0.679462 | 0.65824 | 2420
CSV | STEEL/E24-2 | 5030.38 | 20750 | 71722.6 | +5.008 | +5.078 | C107 | C107 | 1 | 1009 | GRENAILLE-PEINT | E24-2 | CSV | 17.7593 | 17.931 | 0.00226233 | 0.0022842 | 0 | 0.682262 | 0.66096 | 2430
CSV | STEEL/E24-2 | 4982.57 | 20750 | 71716.7 | +4.931 | +5.009 | C107 | C107 | 1 | 1009 | GRENAILLE-PEINT | E24-2 | CSV | 17.7593 | 17.931 | 0.00226233 | 0.0022842 | 0 | 0.682262 | 0.66096 | 2430
CSV | STEEL/E24-2 | 5030.38 | 23350 | 71722.6 | +5.008 | +5.078 | C107 | C107 | 1 | 1009 | GRENAILLE-PEINT | E24-2 | CSV | 17.7593 | 17.931 | 0.00226233 | 0.0022842 | 0 | 0.682262 | 0.66096 | 2430
CSV | STEEL/E24-2 | 4982.57 | 23350 | 71716.7 | +4.931 | +5.009 | C107 | C107 | 1 | 1009 | GRENAILLE-PEINT | E24-2 | CSV | 17.7593 | 17.931 | 0.00226233 | 0.0022842 | 0 | 0.682262 | 0.66096 | 2430
CSV | STEEL/E24-2 | 5030.38 | 25932.5 | 71722.6 | +5.008 | +5.078 | C98 | C98 | 1 | 1009 | GRENAILLE-PEINT | E24-2 | CSV | 17.5035 | 17.6727 | 0.00222975 | 0.0022513 | 0 | 0.672462 | 0.65144 | 2395
CSV | STEEL/E24-2 | 4982.57 | 25932.5 | 71716.8 | +4.931 | +5.009 | C99 | C99 | 1 | 1009 | GRENAILLE-PEINT | E24-2 | CSV | 17.5035 | 17.6727 | 0.00222975 | 0.0022513 | 0 | 0.672462 | 0.65144 | 2395
CSV | STEEL/E24-2 | 5062.56 | 13049.4 | 70788.2 | +5.012 | +5.142 | C114 | C114 | 1 | 1009 | GRENAILLE-PEINT | E24-2 | CSV | 16.0935 | 16.2491 | 0.00205013 | 0.00206995 | 0 | 0.618441 | 0.598963 | 2202.07
CSV | STEEL/E24-2 | 5014.43 | 13049.4 | 70786.8 | +4.935 | +5.064 | C114 | C114 | 1 | 1009 | GRENAILLE-PEINT | E24-2 | CSV | 16.0935 | 16.2491 | 0.00205013 | 0.00206995 | 0 | 0.618441 | 0.598963 | 2202.07
CSV | STEEL/E24-2 | 3607.14 | 24359.2 | 77390.4 | +3.536 | +3.708 | C101 | C101 | 1 | 1009 | GRENAILLE-PEINT | E24-2 | CSV | 24.1004 | 24.3334 | 0.00307012 | 0.0030998 | 0 | 0.925206 | 0.896963 | 3297.66
CSV | STEEL/E24-2 | 3559 | 24359.2 | 77388.9 | +3.459 | +3.630 | C101 | C101 | 1 | 1009 | GRENAILLE-PEINT | E24-2 | CSV | 24.1004 | 24.3334 | 0.00307012 | 0.0030998 | 0 | 0.925206 | 0.896963 | 3297.66
CSV | STEEL/E24-2 | 4531.29 | 1280.35 | 29108.7 | +4.451 | +4.638 | C127 | C127 | 3 | 3004 | GRENAILLE-PEINT | E24-2 | CSV | 18.3586 | 18.5361 | 0.00233868 | 0.00236128 | 0 | 0.705223 | 0.683265 | 2512
CSV | STEEL/E24-2 | 4483.49 | 1280.35 | 29102.9 | +4.381 | +4.560 | C127 | C127 | 3 | 3004 | GRENAILLE-PEINT | E24-2 | CSV | 18.3586 | 18.5361 | 0.00233868 | 0.00236128 | 0 | 0.705223 | 0.683265 | 2512
CSV | STEEL/E24-2 | 5125.42 | 1269.65 | 24244.5 | +5.045 | +5.232 | C127 | C127 | 3 | 3004 | GRENAILLE-PEINT | E24-2 | CSV | 18.3586 | 18.5361 | 0.00233868 | 0.00236128 | 0 | 0.705223 | 0.683265 | 2512
CSV | STEEL/E24-2 | 5077.61 | 1269.65 | 24238.6 | +4.975 | +5.154 | C127 | C127 | 3 | 3004 | GRENAILLE-PEINT | E24-2 | CSV | 18.3586 | 18.5361 | 0.00233868 | 0.00236128 | 0 | 0.705223 | 0.683265 | 2512
CSV | STEEL/E24-2 | 4781.28 | 27250 | 61689.8 | +4.733 | +4.804 | C118 | C118 | 1 | 1004 | GRENAILLE-PEINT | E24-2 | CSV | 36.761 | 37.1164 | 0.00468293 | 0.0047282 | 0 | 1.41026 | 1.36816 | 5030
CSV | STEEL/E24-2 | 4781.28 | 65100 | 61689.8 | +4.733 | +4.804 | C104 | C104 | 1 | 1004 | GRENAILLE-PEINT | E24-2 | CSV | 18.4901 | 18.6689 | 0.00235543 | 0.0023782 | 0 | 0.710262 | 0.68816 | 2530
ATTACHE | STEEL/E24-2 | 5468.32 | 40224.8 | 56064.8 | +5.411 | +5.496 | H39 | H39 | 1 | 1004 | GRENAILLE-PEINT | E24-2 | ATTACHE | 0.877002 | 0.88548 | 0.00011172 | 0.0001128 | 0 | 0.035462 | 0.03264 | 120
ATTACHE | STEEL/E24-2 | 5468.32 | 40275.2 | 56064.8 | +5.411 | +5.496 | H39 | H39 | 1 | 1004 | GRENAILLE-PEINT | E24-2 | ATTACHE | 0.877002 | 0.88548 | 0.00011172 | 0.0001128 | 0 | 0.035462 | 0.03264 | 120
ATTACHE | STEEL/E24-2 | 5468.32 | 19475.2 | 56064.8 | +5.411 | +5.496 | H39 | H39 | 1 | 1004 | GRENAILLE-PEINT | E24-2 | ATTACHE | 0.877002 | 0.88548 | 0.00011172 | 0.0001128 | 0 | 0.035462 | 0.03264 | 120
ATTACHE | STEEL/E24-2 | 5468.32 | 19424.8 | 56064.8 | +5.411 | +5.496 | H39 | H39 | 1 | 1004 | GRENAILLE-PEINT | E24-2 | ATTACHE | 0.877002 | 0.88548 | 0.00011172 | 0.0001128 | 0 | 0.035462 | 0.03264 | 120
CSV | STEEL/E24-2 | 5156.08 | 1325 | 71724.5 | +5.135 | +5.206 | C105 | C105 | 1 | 1009 | GRENAILLE-PEINT | E24-2 | CSV | 17.6131 | 17.7834 | 0.00224371 | 0.0022654 | 0 | 0.676662 | 0.65552 | 2410
CSV | STEEL/E24-2 | 5107.95 | 1325 | 71723 | +5.057 | +5.130 | C105 | C105 | 1 | 1009 | GRENAILLE-PEINT | E24-2 | CSV | 17.6131 | 17.7834 | 0.00224371 | 0.0022654 | 0 | 0.676662 | 0.65552 | 2410
CSV | STEEL/E24-2 | 5033.65 | 3825 | 71720.7 | +5.013 | +5.083 | C103 | C103 | 1 | 1009 | GRENAILLE-PEINT | E24-2 | CSV | 17.3939 | 17.562 | 0.00221578 | 0.0022372 | 0 | 0.668262 | 0.64736 | 2380
CSV | STEEL/E24-2 | 4985.52 | 3825 | 71719.2 | +4.935 | +5.007 | C103 | C103 | 1 | 1009 | GRENAILLE-PEINT | E24-2 | CSV | 17.3939 | 17.562 | 0.00221578 | 0.0022372 | 0 | 0.668262 | 0.64736 | 2380
CSV | STEEL/E24-2 | 5033.65 | 6375 | 71720.7 | +5.013 | +5.083 | C103 | C103 | 1 | 1009 | GRENAILLE-PEINT | E24-2 | CSV | 17.3939 | 17.562 | 0.00221578 | 0.0022372 | 0 | 0.668262 | 0.64736 | 2380
CSV | STEEL/E24-2 | 4985.52 | 6375 | 71719.2 | +4.935 | +5.007 | C103 | C103 | 1 | 1009 | GRENAILLE-PEINT | E24-2 | CSV | 17.3939 | 17.562 | 0.00221578 | 0.0022372 | 0 | 0.668262 | 0.64736 | 2380
CSV | STEEL/E24-2 | 5033.65 | 8830 | 71720.7 | +5.013 | +5.083 | C106 | C106 | 1 | 1009 | GRENAILLE-PEINT | E24-2 | CSV | 16.0053 | 16.16 | 0.00203889 | 0.0020586 | 0 | 0.615062 | 0.59568 | 2190
CSV | STEEL/E24-2 | 4985.52 | 8830 | 71719.2 | +4.935 | +5.007 | C106 | C106 | 1 | 1009 | GRENAILLE-PEINT | E24-2 | CSV | 16.0053 | 16.16 | 0.00203889 | 0.0020586 | 0 | 0.615062 | 0.59568 | 2190
CSV | STEEL/E24-2 | 5033.65 | 11190 | 71720.7 | +5.013 | +5.083 | C106 | C106 | 1 | 1009 | GRENAILLE-PEINT | E24-2 | CSV | 16.0053 | 16.16 | 0.00203889 | 0.0020586 | 0 | 0.615062 | 0.59568 | 2190
CSV | STEEL/E24-2 | 4985.52 | 11190 | 71719.2 | +4.935 | +5.007 | C106 | C106 | 1 | 1009 | GRENAILLE-PEINT | E24-2 | CSV | 16.0053 | 16.16 | 0.00203889 | 0.0020586 | 0 | 0.615062 | 0.59568 | 2190
CSV | STEEL/E24-2 | 5033.65 | 12942.5 | 71720.7 | +5.013 | +5.083 | C97 | C97 | 1 | 1009 | GRENAILLE-PEINT | E24-2 | CSV | 7.12564 | 7.19453 | 0.000907725 | 0.0009165 | 0 | 0.274862 | 0.2652 | 975
CSV | STEEL/E24-2 | 4985.52 | 12942.5 | 71719.2 | +4.935 | +5.007 | C97 | C97 | 1 | 1009 | GRENAILLE-PEINT | E24-2 | CSV | 7.12564 | 7.19453 | 0.000907725 | 0.0009165 | 0 | 0.274862 | 0.2652 | 975
CSV | STEEL/E24-2 | 5033.65 | 14157.5 | 71720.7 | +5.013 | +5.083 | C97 | C97 | 1 | 1009 | GRENAILLE-PEINT | E24-2 | CSV | 7.12564 | 7.19452 | 0.000907725 | 0.0009165 | 0 | 0.274862 | 0.2652 | 975
CSV | STEEL/E24-2 | 4985.52 | 14157.5 | 71719.2 | +4.935 | +5.007 | C97 | C97 | 1 | 1009 | GRENAILLE-PEINT | E24-2 | CSV | 7.12564 | 7.19452 | 0.000907725 | 0.0009165 | 0 | 0.274862 | 0.2652 | 975
CSV | STEEL/E24-2 | 5033.65 | 15910 | 71720.7 | +5.013 | +5.083 | C106 | C106 | 1 | 1009 | GRENAILLE-PEINT | E24-2 | CSV | 16.0053 | 16.16 | 0.00203889 | 0.0020586 | 0 | 0.615062 | 0.59568 | 2190
CSV | STEEL/E24-2 | 4985.52 | 15910 | 71719.2 | +4.935 | +5.007 | C106 | C106 | 1 | 1009 | GRENAILLE-PEINT | E24-2 | CSV | 16.0053 | 16.16 | 0.00203889 | 0.0020586 | 0 | 0.615062 | 0.59568 | 2190
CSV | STEEL/E24-2 | 5033.65 | 18270 | 71720.7 | +5.013 | +5.083 | C106 | C106 | 1 | 1009 | GRENAILLE-PEINT | E24-2 | CSV | 16.0053 | 16.16 | 0.00203889 | 0.0020586 | 0 | 0.615062 | 0.59568 | 2190
CSV | STEEL/E24-2 | 4985.52 | 18270 | 71719.2 | +4.935 | +5.007 | C106 | C106 | 1 | 1009 | GRENAILLE-PEINT | E24-2 | CSV | 16.0053 | 16.16 | 0.00203889 | 0.0020586 | 0 | 0.615062 | 0.59568 | 2190
CSV | STEEL/E24-2 | 5113.71 | 1280.58 | 73091.4 | +5.053 | +5.203 | C100 | C100 | 1 | 1009 | GRENAILLE-PEINT | E24-2 | CSV | 25.5124 | 25.759 | 0.00324998 | 0.0032814 | 0 | 0.979301 | 0.949512 | 3490.85
CSV | STEEL/E24-2 | 5114.74 | 1245.47 | 73058.5 | +5.055 | +5.204 | C100 | C100 | 1 | 1009 | GRENAILLE-PEINT | E24-2 | CSV | 25.5124 | 25.759 | 0.00324998 | 0.0032814 | 0 | 0.979301 | 0.949512 | 3490.85
STABILITE | STEEL/E24-2 | 922.449 | -24.0789 | 47076.4 | -0.388 | +2.206 | V5 | V5 | 1 | 1002 | GRENAILLE-PEINT | E24-2 | STABILITE | 45.6101 | 46.0215 | 0.0058102 | 0.00586261 | 0 | 1.74929 | 1.69642 | 6236.82
STABILITE | STEEL/E24-2 | 922.448 | 24.0789 | 47076.4 | -0.388 | +2.206 | V5 | V5 | 1 | 1002 | GRENAILLE-PEINT | E24-2 | STABILITE | 45.6101 | 46.0215 | 0.0058102 | 0.00586261 | 0 | 1.74929 | 1.69642 | 6236.82
STABILITE | STEEL/E24-2 | 927.541 | -24.0789 | 52948 | -0.362 | +2.244 | V6 | V6 | 1 | 1002 | GRENAILLE-PEINT | E24-2 | STABILITE | 45.0727 | 45.4789 | 0.00574174 | 0.00579349 | 0 | 1.7287 | 1.67641 | 6163.29
STABILITE | STEEL/E24-2 | 927.541 | 24.0789 | 52948 | -0.362 | +2.244 | V6 | V6 | 1 | 1002 | GRENAILLE-PEINT | E24-2 | STABILITE | 45.0727 | 45.4789 | 0.00574174 | 0.00579349 | 0 | 1.7287 | 1.67641 | 6163.29
STABILITE | STEEL/E24-2 | 3159.06 | -24.0789 | 52962.2 | +2.264 | +4.083 | V4 | V4 | 1 | 1002 | GRENAILLE-PEINT | E24-2 | STABILITE | 42.9413 | 43.3269 | 0.00547023 | 0.00551935 | 0 | 1.64704 | 1.59709 | 5871.65
STABILITE | STEEL/E24-2 | 3159.06 | 24.0789 | 52962.2 | +2.264 | +4.083 | V4 | V4 | 1 | 1002 | GRENAILLE-PEINT | E24-2 | STABILITE | 42.9413 | 43.3269 | 0.00547023 | 0.00551935 | 0 | 1.64704 | 1.59709 | 5871.65
STABILITE | STEEL/E24-2 | 3929.99 | -24.0789 | 47137.1 | +2.350 | +5.484 | V7 | V7 | 1 | 1002 | GRENAILLE-PEINT | E24-2 | STABILITE | 46.741 | 47.1633 | 0.00595426 | 0.00600806 | 0 | 1.79262 | 1.7385 | 6391.56
STABILITE | STEEL/E24-2 | 3929.99 | 24.0789 | 47137.1 | +2.350 | +5.484 | V7 | V7 | 1 | 1002 | GRENAILLE-PEINT | E24-2 | STABILITE | 46.741 | 47.1633 | 0.00595426 | 0.00600806 | 0 | 1.79262 | 1.7385 | 6391.56
ATTACHE | STEEL/S235JR | -110 | 7674.08 | 44485.1 | -0.220 | -0.000 | H36 | H36 | 1 | 1002 | GRENAILLE-PEINT | S235JR | ATTACHE | 1.60784 | 1.62338 | 0.00020482 | 0.0002068 | 0.000931 | 0.063462 | 0.05984 | 220
ATTACHE | STEEL/S235JR | 3990.28 | 7625.92 | 55719.9 | +3.880 | +4.100 | H36 | H36 | 1 | 1002 | GRENAILLE-PEINT | S235JR | ATTACHE | 1.60784 | 1.62338 | 0.00020482 | 0.0002068 | 0.000931 | 0.063462 | 0.05984 | 220
ATTACHE | STEEL/S235JR | 5349.37 | 7674.08 | 44485.1 | +5.239 | +5.459 | H36 | H36 | 1 | 1002 | GRENAILLE-PEINT | S235JR | ATTACHE | 1.60784 | 1.62338 | 0.00020482 | 0.0002068 | 0.000931 | 0.063462 | 0.05984 | 220
ATTACHE | STEEL/S235JR | -110 | 7625.92 | 55719.9 | -0.220 | -0.000 | H36 | H36 | 1 | 1002 | GRENAILLE-PEINT | S235JR | ATTACHE | 1.60784 | 1.62338 | 0.00020482 | 0.0002068 | 0.000931 | 0.063462 | 0.05984 | 220
STABILITE | STEEL/S235JR | 1075.52 | 7625.92 | 47713.2 | -0.143 | +2.266 | V8 | V8 | 1 | 1002 | GRENAILLE-PEINT | S235JR | STABILITE | 49.2818 | 49.7287 | 0.00627794 | 0.00633486 | 0 | 1.88996 | 1.83307 | 6739.22
STABILITE | STEEL/S235JR | 3134.38 | 7625.92 | 53266.3 | +2.208 | +4.033 | V9 | V9 | 1 | 1002 | GRENAILLE-PEINT | S235JR | STABILITE | 36.9932 | 37.3213 | 0.00471251 | 0.00475431 | 0 | 1.41916 | 1.37572 | 5057.78
STABILITE | STEEL/S235JR | 3826.56 | 7625.92 | 47691.2 | +2.250 | +5.377 | V10 | V10 | 1 | 1002 | GRENAILLE-PEINT | S235JR | STABILITE | 50.7887 | 51.2502 | 0.0064699 | 0.00652868 | 0 | 1.9477 | 1.88915 | 6945.41
STABILITE | STEEL/S235JR | 1061.29 | 7625.92 | 53319.7 | -0.128 | +2.224 | V11 | V11 | 1 | 1002 | GRENAILLE-PEINT | S235JR | STABILITE | 37.9511 | 38.2885 | 0.00483454 | 0.00487752 | 0 | 1.45586 | 1.41137 | 5188.85
ATTACHE | STEEL/S235JR | 5349.37 | 61074.1 | 44485.1 | +5.239 | +5.459 | H36 | H36 | 1 | 1002 | GRENAILLE-PEINT | S235JR | ATTACHE | 1.60784 | 1.62338 | 0.00020482 | 0.0002068 | 0.000931 | 0.063462 | 0.05984 | 220
ATTACHE | STEEL/S235JR | 3990.28 | 61025.9 | 55719.9 | +3.880 | +4.100 | H36 | H36 | 1 | 1002 | GRENAILLE-PEINT | S235JR | ATTACHE | 1.60784 | 1.62338 | 0.00020482 | 0.0002068 | 0.000931 | 0.063462 | 0.05984 | 220
ATTACHE | STEEL/S235JR | -110 | 61025.9 | 55719.9 | -0.220 | +0.000 | H36 | H36 | 1 | 1002 | GRENAILLE-PEINT | S235JR | ATTACHE | 1.60784 | 1.62338 | 0.00020482 | 0.0002068 | 0.000931 | 0.063462 | 0.05984 | 220
STABILITE | STEEL/S235JR | 1061.29 | 61025.9 | 53319.7 | -0.128 | +2.224 | V11 | V11 | 1 | 1002 | GRENAILLE-PEINT | S235JR | STABILITE | 37.9511 | 38.2885 | 0.00483454 | 0.00487752 | 0 | 1.45586 | 1.41137 | 5188.85
STABILITE | STEEL/S235JR | 3826.56 | 61025.9 | 47691.2 | +2.250 | +5.377 | V10 | V10 | 1 | 1002 | GRENAILLE-PEINT | S235JR | STABILITE | 50.7887 | 51.2502 | 0.0064699 | 0.00652868 | 0 | 1.9477 | 1.88915 | 6945.41
STABILITE | STEEL/S235JR | 3134.38 | 61025.9 | 53266.3 | +2.208 | +4.033 | V9 | V9 | 1 | 1002 | GRENAILLE-PEINT | S235JR | STABILITE | 36.9932 | 37.3213 | 0.00471251 | 0.00475431 | 0 | 1.41916 | 1.37572 | 5057.78
STABILITE | STEEL/S235JR | 1075.52 | 61025.9 | 47713.2 | -0.143 | +2.266 | V8 | V8 | 1 | 1002 | GRENAILLE-PEINT | S235JR | STABILITE | 49.2818 | 49.7287 | 0.00627794 | 0.00633486 | 0 | 1.88996 | 1.83307 | 6739.22
ATTACHE | STEEL/S235JR | -110 | 61074.1 | 44485.1 | -0.220 | +0.000 | H36 | H36 | 1 | 1002 | GRENAILLE-PEINT | S235JR | ATTACHE | 1.60784 | 1.62338 | 0.00020482 | 0.0002068 | 0.000931 | 0.063462 | 0.05984 | 220
CSV | STEEL/E24-2 | 4781.28 | 65100 | 73364.8 | +4.733 | +4.804 | C104 | C104 | 1 | 1004 | GRENAILLE-PEINT | E24-2 | CSV | 18.4901 | 18.6689 | 0.00235543 | 0.0023782 | 0 | 0.710262 | 0.68816 | 2530
CSV | STEEL/E24-2 | 4829.08 | 65100 | 73370.6 | +4.803 | +4.881 | C104 | C104 | 1 | 1004 | GRENAILLE-PEINT | E24-2 | CSV | 18.4901 | 18.6689 | 0.00235543 | 0.0023782 | 0 | 0.710262 | 0.68816 | 2530
CSV | STEEL/E24-2 | 4829.08 | 67800 | 73370.6 | +4.803 | +4.881 | C104 | C104 | 1 | 1004 | GRENAILLE-PEINT | E24-2 | CSV | 18.4901 | 18.6689 | 0.00235543 | 0.0023782 | 0 | 0.710262 | 0.68816 | 2530
CSV | STEEL/E24-2 | 4781.28 | 67800 | 73364.8 | +4.733 | +4.804 | C104 | C104 | 1 | 1004 | GRENAILLE-PEINT | E24-2 | CSV | 18.4901 | 18.6689 | 0.00235543 | 0.0023782 | 0 | 0.710262 | 0.68816 | 2530
POUTRES | STEEL/E24-2 | 4925.35 | 48885.9 | 32499.9 | +4.251 | +5.578 | 619 | N43 | 3 | 3003 | GRENAILLE-PEINT | E24-2 | POUTRES | 13.1958 | 13.3233 | 0.00168099 | 0.00169724 | 0 | 0.507423 | 0.491116 | 1805.57
ATTACHE | STEEL/E24-2 | 5468.32 | 40224.8 | 32714.8 | +5.411 | +5.496 | H39 | H39 | 3 | 3004 | GRENAILLE-PEINT | E24-2 | ATTACHE | 0.877002 | 0.88548 | 0.00011172 | 0.0001128 | 0 | 0.035462 | 0.03264 | 120
FEUILLURE | STEEL/E24-2 | 4233.5 | 48104.9 | 20735.1 | +3.817 | +4.650 | L20 | L20 | 2 | 2006 | GRENAILLE-PEINT | E24-2 | FEUILLURE | 6.08786 | 6.14671 | 0.000775523 | 0.00078302 | 0.000931 | 0.235102 | 0.226576 | 833
 | STEEL/E24-2 | 5412.02 | -17.0788 | 55803.4 | +5.362 | +5.432 | 614 | L42 | 1 | 1003 | GRENAILLE-PEINT | E24-2 |  | 0.854277 | 0.862535 | 0.000108825 | 0.000109877 | 0.00818234 | 0.0345914 | 0.0317942 | 116.891
 | STEEL/E24-2 | 5741.5 | 18.079 | 55760.1 | +5.604 | +5.878 | 613 | P25 | 1 | 1001 | GRENAILLE-PEINT | E24-2 |  | 2.00249 | 2.02185 | 0.000255094 | 0.00025756 | 0.000931 | 0.078582 | 0.074528 | 274
 | STEEL/E24-2 | 5412.02 | -17.0788 | 67478.4 | +5.362 | +5.432 | 614 | L42 | 1 | 1003 | GRENAILLE-PEINT | E24-2 |  | 0.854277 | 0.862535 | 0.000108825 | 0.000109877 | 0.00818234 | 0.0345914 | 0.0317942 | 116.891
 | STEEL/E24-2 | 5741.5 | 18.079 | 67435.1 | +5.604 | +5.878 | 613 | P24 | 1 | 1001 | GRENAILLE-PEINT | E24-2 |  | 2.00249 | 2.02185 | 0.000255094 | 0.00025756 | 0.000931 | 0.078582 | 0.074528 | 274
STABILITE | STEEL/E24-2 | 3159.06 | 69125.9 | 52962.2 | +2.264 | +4.083 | V12 | V12 | 1 | 1002 | GRENAILLE-PEINT | E24-2 | STABILITE | 42.9413 | 43.3269 | 0.00547023 | 0.00551935 | 0 | 1.64704 | 1.59709 | 5871.65
STABILITE | STEEL/E24-2 | 3159.06 | 69174.1 | 52962.2 | +2.264 | +4.083 | V12 | V12 | 1 | 1002 | GRENAILLE-PEINT | E24-2 | STABILITE | 42.9413 | 43.3269 | 0.00547023 | 0.00551935 | 0 | 1.64704 | 1.59709 | 5871.65
