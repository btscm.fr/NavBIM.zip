Properties of the parts of a building model (IFC2X3), part 10 of 32

# IfcBeam: PL10*120 (17)
Name | Material | Center of gravity Z (mm) | Center of gravity Y (mm) | Center of gravity X (mm) | Bottom elevation | Top elevation | Part mark | Assembly mark | Class | Finish | Grade | Net weight (kg) = Gross weight (kg) = Weight (kg) = NetWeight (kg) | Net volume (m3) = Gross volume (m3) = NetVolume (m3) | Gross footprint area (m2) | Area per tons (m2) | Net surface area (m2) = Gross area (m2) = OuterSurfaceArea (m2) | Tekla Quantity, Length (mm) = BaseQuantities, Length (mm)
PLAT | STEEL/E24-2 | 3861.92 | 21883.3 | 71825.1 | +3.764 | +3.959 | 280 | K89 | 1010 | GRENAILLE-PEINT | E24-2 | 1.8369 | 0.000234 | 0.0012 | 28.9074 | 0.0531 | 195
PLAT | STEEL/E24-2 | 5196.25 | 24650 | 71753 | +5.091 | +5.301 | 177 | K48 | 1010 | GRENAILLE-PEINT | E24-2 | 1.9782 | 0.000252 | 0.0012 | 28.8141 | 0.057 | 210
PLAT | STEEL/E24-2 | 5196.25 | 19450 | 71753 | +5.091 | +5.301 | 177 | K43 | 1010 | GRENAILLE-PEINT | E24-2 | 1.9782 | 0.000252 | 0.0012 | 28.8141 | 0.057 | 210
PLAT | STEEL/E24-2 | 5196.25 | 22050 | 71753 | +5.091 | +5.301 | 177 | K47 | 1010 | GRENAILLE-PEINT | E24-2 | 1.9782 | 0.000252 | 0.0012 | 28.8141 | 0.057 | 210
PLAT | STEEL/E24-2 | 5199.86 | 17090 | 71753 | +5.095 | +5.305 | 177 | K44 | 1010 | GRENAILLE-PEINT | E24-2 | 1.9782 | 0.000252 | 0.0012 | 28.8141 | 0.057 | 210
PLAT | STEEL/E24-2 | 5199.86 | 14730 | 71753 | +5.095 | +5.305 | 177 | K46 | 1010 | GRENAILLE-PEINT | E24-2 | 1.9782 | 0.000252 | 0.0012 | 28.8141 | 0.057 | 210
PLAT | STEEL/S235JR | 3944.54 | 20847 | 73829.8 | +3.938 | +3.951 | 234 | P54 | 1008 | GALVANISE | S235JR | 2.0724 | 0.000264 | 0 | 28.7589 | 0.0596 | 220
PLAT | STEEL/S235JR | 3882.76 | 20847 | 75823.8 | +3.876 | +3.890 | 234 | P55 | 1008 | GALVANISE | S235JR | 2.0724 | 0.000264 | 0 | 28.7589 | 0.0596 | 220
PLAT | STEEL/S235JR | 3846.16 | 22320 | 77003.8 | +3.839 | +3.853 | 234 | P56 | 1008 | GALVANISE | S235JR | 2.0724 | 0.000264 | 0 | 28.7589 | 0.0596 | 220
PLAT | STEEL/S235JR | 3816.99 | 22320 | 77944.8 | +3.810 | +3.824 | 234 | P57 | 1008 | GALVANISE | S235JR | 2.0724 | 0.000264 | 0 | 28.7589 | 0.0596 | 220
PLAT | STEEL/S235JR | 3944.54 | 24940 | 73829.8 | +3.938 | +3.951 | 234 | P54 | 1008 | GALVANISE | S235JR | 2.0724 | 0.000264 | 0 | 28.7589 | 0.0596 | 220
PLAT | STEEL/S235JR | 3882.76 | 24940 | 75823.8 | +3.876 | +3.890 | 234 | P55 | 1008 | GALVANISE | S235JR | 2.0724 | 0.000264 | 0 | 28.7589 | 0.0596 | 220
PLAT | STEEL/E24-2 | 5419.49 | 26545 | 71877 | +5.314 | +5.524 | 177 | K95 | 1010 | GRENAILLE-PEINT | E24-2 | 1.9782 | 0.000252 | 0.0012 | 28.8141 | 0.057 | 210

# IfcBeam: PL10*130 (4)
In: Undefined
Description: PL10*130; Material: STEEL/S235JR
Tekla Common - Part mark: 235; Phase: 1; Class: 1008; Finish: GALVANISE; Grade: S235JR; Profile: PL10*130; Name: PLAT; sets with these values: 2
Tekla Quantity - Net weight: 2.2451 kg; Gross weight: 2.2451 kg; Weight: 2.2451 kg; Net volume: 0.000286 m3; Gross volume: 0.000286 m3; Gross footprint area: 0 m2; Area per tons: 28.5956 m2; Net surface area: 0.0642 m2; Gross area: 0.0642 m2; Height: 130 mm; Width: 10 mm; Length: 220 mm; sets with these values: 2
BaseQuantities - Length: 220 mm; OuterSurfaceArea: 0.0642 m2; NetVolume: 0.000286 m3; NetWeight: 2.2451 kg
Name | Center of gravity Z (mm) | Center of gravity Y (mm) | Center of gravity X (mm) | Bottom elevation | Top elevation | Assembly mark
PLAT | 3882.76 | 19800 | 75823.8 | +3.874 | +3.891 | P60
PLAT | 3944.54 | 19800 | 73829.8 | +3.936 | +3.953 | P58
PLAT | 3882.76 | 15633.3 | 75823.8 | +3.874 | +3.891 | P61
PLAT | 3944.54 | 15633.3 | 73829.8 | +3.936 | +3.953 | P59

# IfcBeam: PL10*150 (75)
In: Undefined
Description: PL10*150
Tekla Common - Finish: GRENAILLE-PEINT; Profile: PL10*150; sets with these values: 2
Tekla Quantity - Height: 150 mm; Width: 10 mm; sets with these values: 2
Name | Material | Center of gravity Z (mm) | Center of gravity Y (mm) | Center of gravity X (mm) | Bottom elevation | Top elevation | Part mark | Assembly mark | Phase | Class | Grade | Name | Net weight (kg) = Gross weight (kg) = Weight (kg) = NetWeight (kg) | Net volume (m3) = Gross volume (m3) = NetVolume (m3) | Gross footprint area (m2) | Area per tons (m2) | Net surface area (m2) = Gross area (m2) = OuterSurfaceArea (m2) | Tekla Quantity, Length (mm) = BaseQuantities, Length (mm)
PLAT | STEEL/E24-2 | 4300.71 | 7650 | 32385 | +4.196 | +4.406 | 176 | K42 | 3 | 3005 | E24-2 | PLAT | 2.47275 | 0.000315 | 0.0015 | 28.3894 | 0.0702 | 210
PLAT | STEEL/E24-2 | 5675.41 | 7650 | 21120 | +5.570 | +5.780 | 176 | K42 | 3 | 3005 | E24-2 | PLAT | 2.47275 | 0.000315 | 0.0015 | 28.3894 | 0.0702 | 210
TOLE | STEEL/E36-3 | 5885 | -76.5 | 32525 | +5.880 | +5.890 | 209 | P113 | 3 | 3001 | E36-3 | TOLE | 3.37942 | 0.0004305 | 0.04305 | 28.0639 | 0.09484 | 287
TOLE | STEEL/E36-3 | 5885 | -76.5 | 20850 | +5.880 | +5.890 | 208 | P119 | 2 | 2001 | E36-3 | TOLE | 3.37942 | 0.0004305 | 0.04305 | 28.0639 | 0.09484 | 287
PLAT | STEEL/E24-2 | 5663.2 | 40250 | 67920 | +5.558 | +5.768 | 176 | K39 | 1 | 1010 | E24-2 | PLAT | 2.47275 | 0.000315 | 0.0015 | 28.3894 | 0.0702 | 210
PLAT | STEEL/E24-2 | 5663.2 | 19450 | 67920 | +5.558 | +5.768 | 176 | K43 | 1 | 1010 | E24-2 | PLAT | 2.47275 | 0.000315 | 0.0015 | 28.3894 | 0.0702 | 210
PLAT | STEEL/E24-2 | 5675.41 | 61050 | 67820 | +5.570 | +5.780 | 176 | K40 | 1 | 1010 | E24-2 | PLAT | 2.47275 | 0.000315 | 0.0015 | 28.3894 | 0.0702 | 210
PLAT | STEEL/E24-2 | 5329.59 | 17090 | 67558.1 | +5.225 | +5.435 | 176 | K44 | 1 | 1010 | E24-2 | PLAT | 2.47275 | 0.000315 | 0.0015 | 28.3894 | 0.0702 | 210
PLAT | STEEL/E24-2 | 5329.59 | 12370 | 67558.1 | +5.225 | +5.435 | 176 | K45 | 1 | 1010 | E24-2 | PLAT | 2.47275 | 0.000315 | 0.0015 | 28.3894 | 0.0702 | 210
PLAT | STEEL/E24-2 | 5329.59 | 2550 | 67558.1 | +5.225 | +5.435 | 176 | K38 | 1 | 1010 | E24-2 | PLAT | 2.47275 | 0.000315 | 0.0015 | 28.3894 | 0.0702 | 210
PLAT | STEEL/E24-2 | 5321.47 | 7650 | 67820 | +5.216 | +5.426 | 176 | K37 | 1 | 1010 | E24-2 | PLAT | 2.47275 | 0.000315 | 0.0015 | 28.3894 | 0.0702 | 210
PLAT | STEEL/E24-2 | 4300.71 | 61050 | 67410 | +4.196 | +4.406 | 176 | K41 | 1 | 1005 | E24-2 | PLAT | 2.47275 | 0.000315 | 0.0015 | 28.3894 | 0.0702 | 210
PLAT | STEEL/E24-2 | 5675.41 | 61050 | 56145 | +5.570 | +5.780 | 176 | K41 | 1 | 1005 | E24-2 | PLAT | 2.47275 | 0.000315 | 0.0015 | 28.3894 | 0.0702 | 210
PLAT | STEEL/E36-3 | 5486.82 | 40676.3 | 20850 | +5.381 | +5.593 | 298 | N46 | 2 | 2006 | E36-3 | PLAT | 9.60351 | 0.00122338 | 0 | 27.4886 | 0.263987 | 815.584
PLAT | STEEL/E36-3 | 5486.82 | 40676.3 | 32525 | +5.381 | +5.593 | 301 | N43 | 3 | 3003 | E36-3 | PLAT | 9.60351 | 0.00122338 | 0 | 27.4886 | 0.263987 | 815.584
ECLISSE | STEEL/E36-3 | 4242 | 28324.9 | 20850 | +4.237 | +4.247 | H3 | H3 | 2 | 2006 | E36-3 | ECLISSE | 6.00525 | 0.000765 | 0.0765 | 27.6758 | 0.1662 | 510
ECLISSE | STEEL/E36-3 | 3935 | 28324.9 | 20850 | +3.930 | +3.940 | H3 | H3 | 2 | 2006 | E36-3 | ECLISSE | 6.00525 | 0.000765 | 0.0765 | 27.6758 | 0.1662 | 510
ECLISSE | STEEL/E36-3 | 5588 | 28324.9 | 20850 | +5.583 | +5.593 | H3 | H3 | 2 | 2006 | E36-3 | ECLISSE | 6.00525 | 0.000765 | 0.0765 | 27.6758 | 0.1662 | 510
ECLISSE | STEEL/E36-3 | 5895 | 28324.9 | 20850 | +5.890 | +5.900 | H3 | H3 | 2 | 2006 | E36-3 | ECLISSE | 6.00525 | 0.000765 | 0.0765 | 27.6758 | 0.1662 | 510
PLAT | STEEL/E36-3 | 5486.82 | 39823.7 | 20850 | +5.381 | +5.593 | 298 | N44 | 2 | 2006 | E36-3 | PLAT | 9.60351 | 0.00122338 | 0 | 27.4886 | 0.263987 | 815.584
PLAT | STEEL/E36-3 | 5486.82 | 19876.3 | 20850 | +5.381 | +5.593 | 298 | N45 | 2 | 2006 | E36-3 | PLAT | 9.60351 | 0.00122338 | 0 | 27.4886 | 0.263987 | 815.584
PLAT | STEEL/E36-3 | 5486.82 | 19023.7 | 20850 | +5.381 | +5.593 | 298 | N49 | 2 | 2006 | E36-3 | PLAT | 9.60351 | 0.00122338 | 0 | 27.4886 | 0.263987 | 815.584
ECLISSE | STEEL/E36-3 | 4242 | 28324.9 | 67550 | +4.237 | +4.247 | H3 | H3 | 1 | 1006 | E36-3 | ECLISSE | 6.00525 | 0.000765 | 0.0765 | 27.6758 | 0.1662 | 510
ECLISSE | STEEL/E36-3 | 3935 | 28324.9 | 67550 | +3.930 | +3.940 | H3 | H3 | 1 | 1006 | E36-3 | ECLISSE | 6.00525 | 0.000765 | 0.0765 | 27.6758 | 0.1662 | 510
ECLISSE | STEEL/E36-3 | 5588 | 28324.9 | 67550 | +5.583 | +5.593 | H3 | H3 | 1 | 1006 | E36-3 | ECLISSE | 6.00525 | 0.000765 | 0.0765 | 27.6758 | 0.1662 | 510
ECLISSE | STEEL/E36-3 | 5895 | 28324.9 | 67550 | +5.890 | +5.900 | H3 | H3 | 1 | 1006 | E36-3 | ECLISSE | 6.00525 | 0.000765 | 0.0765 | 27.6758 | 0.1662 | 510
PLAT | STEEL/E36-3 | 5486.82 | 39823.7 | 67550 | +5.381 | +5.593 | 298 | N7 | 1 | 1006 | E36-3 | PLAT | 9.60351 | 0.00122338 | 0 | 27.4886 | 0.263987 | 815.584
PLAT | STEEL/E36-3 | 5486.82 | 40676.3 | 67550 | +5.381 | +5.593 | 298 | N6 | 1 | 1006 | E36-3 | PLAT | 9.60351 | 0.00122338 | 0 | 27.4886 | 0.263987 | 815.584
PLAT | STEEL/E36-3 | 5486.82 | 19876.3 | 67550 | +5.381 | +5.593 | 298 | N11 | 1 | 1006 | E36-3 | PLAT | 9.60351 | 0.00122338 | 0 | 27.4886 | 0.263987 | 815.584
PLAT | STEEL/E36-3 | 5486.82 | 19023.7 | 67550 | +5.381 | +5.593 | 298 | N12 | 1 | 1006 | E36-3 | PLAT | 9.60351 | 0.00122338 | 0 | 27.4886 | 0.263987 | 815.584
ECLISSE | STEEL/E36-3 | 3935 | 52175.1 | 67550 | +3.930 | +3.940 | H3 | H3 | 1 | 1006 | E36-3 | ECLISSE | 6.00525 | 0.000765 | 0.0765 | 27.6758 | 0.1662 | 510
ECLISSE | STEEL/E36-3 | 4242 | 52175.1 | 67550 | +4.237 | +4.247 | H3 | H3 | 1 | 1006 | E36-3 | ECLISSE | 6.00525 | 0.000765 | 0.0765 | 27.6758 | 0.1662 | 510
ECLISSE | STEEL/E36-3 | 5895 | 52175.1 | 67550 | +5.890 | +5.900 | H3 | H3 | 1 | 1006 | E36-3 | ECLISSE | 6.00525 | 0.000765 | 0.0765 | 27.6758 | 0.1662 | 510
ECLISSE | STEEL/E36-3 | 5588 | 52175.1 | 67550 | +5.583 | +5.593 | H3 | H3 | 1 | 1006 | E36-3 | ECLISSE | 6.00525 | 0.000765 | 0.0765 | 27.6758 | 0.1662 | 510
PLAT | STEEL/E24-2 | 5675.41 | 7650 | 56145 | +5.570 | +5.780 | 176 | K42 | 1 | 1005 | E24-2 | PLAT | 2.47275 | 0.000315 | 0.0015 | 28.3894 | 0.0702 | 210
ECLISSE | STEEL/E36-3 | 4242 | 28324.9 | 55875 | +4.237 | +4.247 | H3 | H3 | 1 | 1006 | E36-3 | ECLISSE | 6.00525 | 0.000765 | 0.0765 | 27.6758 | 0.1662 | 510
ECLISSE | STEEL/E36-3 | 3935 | 28324.9 | 55875 | +3.930 | +3.940 | H3 | H3 | 1 | 1006 | E36-3 | ECLISSE | 6.00525 | 0.000765 | 0.0765 | 27.6758 | 0.1662 | 510
ECLISSE | STEEL/E36-3 | 5588 | 28324.9 | 55875 | +5.583 | +5.593 | H3 | H3 | 1 | 1006 | E36-3 | ECLISSE | 6.00525 | 0.000765 | 0.0765 | 27.6758 | 0.1662 | 510
ECLISSE | STEEL/E36-3 | 5895 | 28324.9 | 55875 | +5.890 | +5.900 | H3 | H3 | 1 | 1006 | E36-3 | ECLISSE | 6.00525 | 0.000765 | 0.0765 | 27.6758 | 0.1662 | 510
PLAT | STEEL/E36-3 | 5486.82 | 39823.7 | 55875 | +5.381 | +5.593 | 298 | N8 | 1 | 1006 | E36-3 | PLAT | 9.60351 | 0.00122338 | 0 | 27.4886 | 0.263987 | 815.584
PLAT | STEEL/E36-3 | 5486.82 | 40676.3 | 55875 | +5.381 | +5.593 | 298 | N41 | 1 | 1006 | E36-3 | PLAT | 9.60351 | 0.00122338 | 0 | 27.4886 | 0.263987 | 815.584
PLAT | STEEL/E36-3 | 5486.82 | 19876.3 | 55875 | +5.381 | +5.593 | 298 | N10 | 1 | 1006 | E36-3 | PLAT | 9.60351 | 0.00122338 | 0 | 27.4886 | 0.263987 | 815.584
PLAT | STEEL/E36-3 | 5486.82 | 19023.7 | 55875 | +5.381 | +5.593 | 298 | N47 | 1 | 1006 | E36-3 | PLAT | 9.60351 | 0.00122338 | 0 | 27.4886 | 0.263987 | 815.584
ECLISSE | STEEL/E36-3 | 3935 | 52175.1 | 55875 | +3.930 | +3.940 | H3 | H3 | 1 | 1006 | E36-3 | ECLISSE | 6.00525 | 0.000765 | 0.0765 | 27.6758 | 0.1662 | 510
ECLISSE | STEEL/E36-3 | 4242 | 52175.1 | 55875 | +4.237 | +4.247 | H3 | H3 | 1 | 1006 | E36-3 | ECLISSE | 6.00525 | 0.000765 | 0.0765 | 27.6758 | 0.1662 | 510
ECLISSE | STEEL/E36-3 | 5895 | 52175.1 | 55875 | +5.890 | +5.900 | H3 | H3 | 1 | 1006 | E36-3 | ECLISSE | 6.00525 | 0.000765 | 0.0765 | 27.6758 | 0.1662 | 510
ECLISSE | STEEL/E36-3 | 5588 | 52175.1 | 55875 | +5.583 | +5.593 | H3 | H3 | 1 | 1006 | E36-3 | ECLISSE | 6.00525 | 0.000765 | 0.0765 | 27.6758 | 0.1662 | 510
ECLISSE | STEEL/E36-3 | 4242 | 28324.9 | 32525 | +4.237 | +4.247 | H3 | H3 | 3 | 3006 | E36-3 | ECLISSE | 6.00525 | 0.000765 | 0.0765 | 27.6758 | 0.1662 | 510
ECLISSE | STEEL/E36-3 | 3935 | 28324.9 | 32525 | +3.930 | +3.940 | H3 | H3 | 3 | 3006 | E36-3 | ECLISSE | 6.00525 | 0.000765 | 0.0765 | 27.6758 | 0.1662 | 510
ECLISSE | STEEL/E36-3 | 5588 | 28324.9 | 32525 | +5.583 | +5.593 | H3 | H3 | 3 | 3006 | E36-3 | ECLISSE | 6.00525 | 0.000765 | 0.0765 | 27.6758 | 0.1662 | 510
ECLISSE | STEEL/E36-3 | 5895 | 28324.9 | 32525 | +5.890 | +5.900 | H3 | H3 | 3 | 3006 | E36-3 | ECLISSE | 6.00525 | 0.000765 | 0.0765 | 27.6758 | 0.1662 | 510
PLAT | STEEL/E36-3 | 5486.82 | 39823.7 | 32525 | +5.381 | +5.593 | 298 | N40 | 3 | 3006 | E36-3 | PLAT | 9.60351 | 0.00122338 | 0 | 27.4886 | 0.263987 | 815.584
PLAT | STEEL/E36-3 | 5486.82 | 19876.3 | 32525 | +5.381 | +5.593 | 298 | N9 | 3 | 3006 | E36-3 | PLAT | 9.60351 | 0.00122338 | 0 | 27.4886 | 0.263987 | 815.584
PLAT | STEEL/E36-3 | 5486.82 | 19023.7 | 32525 | +5.381 | +5.593 | 298 | N48 | 3 | 3006 | E36-3 | PLAT | 9.60351 | 0.00122338 | 0 | 27.4886 | 0.263987 | 815.584
PLAT | STEEL/E24-2 | 5675.41 | 61050 | 44470 | +5.570 | +5.780 | 176 | K41 | 1 | 1005 | E24-2 | PLAT | 2.47275 | 0.000315 | 0.0015 | 28.3894 | 0.0702 | 210
PLAT | STEEL/E24-2 | 4300.71 | 61050 | 55735 | +4.196 | +4.406 | 176 | K41 | 1 | 1005 | E24-2 | PLAT | 2.47275 | 0.000315 | 0.0015 | 28.3894 | 0.0702 | 210
PLAT | STEEL/E24-2 | 4300.71 | 7650 | 55735 | +4.196 | +4.406 | 176 | K42 | 1 | 1005 | E24-2 | PLAT | 2.47275 | 0.000315 | 0.0015 | 28.3894 | 0.0702 | 210
PLAT | STEEL/E24-2 | 5675.41 | 7650 | 44470 | +5.570 | +5.780 | 176 | K42 | 1 | 1005 | E24-2 | PLAT | 2.47275 | 0.000315 | 0.0015 | 28.3894 | 0.0702 | 210
PLAT | STEEL/E24-2 | 4300.71 | 7650 | 67410 | +4.196 | +4.406 | 176 | K42 | 1 | 1005 | E24-2 | PLAT | 2.47275 | 0.000315 | 0.0015 | 28.3894 | 0.0702 | 210
PLAT | STEEL/E36-3 | 5486.82 | 19876.3 | 44200 | +5.381 | +5.593 | 298 | N10 | 1 | 1006 | E36-3 | PLAT | 9.60351 | 0.00122338 | 0 | 27.4886 | 0.263987 | 815.584
PLAT | STEEL/E36-3 | 5486.82 | 40676.3 | 44200 | +5.381 | +5.593 | 298 | N41 | 1 | 1006 | E36-3 | PLAT | 9.60351 | 0.00122338 | 0 | 27.4886 | 0.263987 | 815.584
PLAT | STEEL/E36-3 | 5486.82 | 19023.7 | 44200 | +5.381 | +5.593 | 298 | N47 | 1 | 1006 | E36-3 | PLAT | 9.60351 | 0.00122338 | 0 | 27.4886 | 0.263987 | 815.584
ECLISSE | STEEL/E36-3 | 4242 | 28324.9 | 44200 | +4.237 | +4.247 | H3 | H3 | 1 | 1006 | E36-3 | ECLISSE | 6.00525 | 0.000765 | 0.0765 | 27.6758 | 0.1662 | 510
PLAT | STEEL/E36-3 | 5486.82 | 39823.7 | 44200 | +5.381 | +5.593 | 298 | N8 | 1 | 1006 | E36-3 | PLAT | 9.60351 | 0.00122338 | 0 | 27.4886 | 0.263987 | 815.584
ECLISSE | STEEL/E36-3 | 3935 | 28324.9 | 44200 | +3.930 | +3.940 | H3 | H3 | 1 | 1006 | E36-3 | ECLISSE | 6.00525 | 0.000765 | 0.0765 | 27.6758 | 0.1662 | 510
ECLISSE | STEEL/E36-3 | 5588 | 28324.9 | 44200 | +5.583 | +5.593 | H3 | H3 | 1 | 1006 | E36-3 | ECLISSE | 6.00525 | 0.000765 | 0.0765 | 27.6758 | 0.1662 | 510
ECLISSE | STEEL/E36-3 | 5895 | 28324.9 | 44200 | +5.890 | +5.900 | H3 | H3 | 1 | 1006 | E36-3 | ECLISSE | 6.00525 | 0.000765 | 0.0765 | 27.6758 | 0.1662 | 510
ECLISSE | STEEL/E36-3 | 3935 | 52175.1 | 44200 | +3.930 | +3.940 | H3 | H3 | 1 | 1006 | E36-3 | ECLISSE | 6.00525 | 0.000765 | 0.0765 | 27.6758 | 0.1662 | 510
ECLISSE | STEEL/E36-3 | 4242 | 52175.1 | 44200 | +4.237 | +4.247 | H3 | H3 | 1 | 1006 | E36-3 | ECLISSE | 6.00525 | 0.000765 | 0.0765 | 27.6758 | 0.1662 | 510
ECLISSE | STEEL/E36-3 | 5895 | 52175.1 | 44200 | +5.890 | +5.900 | H3 | H3 | 1 | 1006 | E36-3 | ECLISSE | 6.00525 | 0.000765 | 0.0765 | 27.6758 | 0.1662 | 510
ECLISSE | STEEL/E36-3 | 5588 | 52175.1 | 44200 | +5.583 | +5.593 | H3 | H3 | 1 | 1006 | E36-3 | ECLISSE | 6.00525 | 0.000765 | 0.0765 | 27.6758 | 0.1662 | 510
PLAT | STEEL/E24-2 | 4300.71 | 7650 | 44060 | +4.196 | +4.406 | 176 | K42 | 3 | 3005 | E24-2 | PLAT | 2.47275 | 0.000315 | 0.0015 | 28.3894 | 0.0702 | 210
PLAT | STEEL/E24-2 | 5675.41 | 7650 | 32795 | +5.570 | +5.780 | 176 | K42 | 3 | 3005 | E24-2 | PLAT | 2.47275 | 0.000315 | 0.0015 | 28.3894 | 0.0702 | 210
PLAT | STEEL/E24-2 | 5189.72 | 27250 | 71806.5 | +5.085 | +5.295 | 178 | K49 | 1 | 1010 | E24-2 | PLAT | 2.47275 | 0.000315 | 0.0015 | 28.3894 | 0.0702 | 210
PLATINE | STEEL/E24-2 | 4088.5 | 49790 | 32525 | +3.945 | +4.232 | 226 | N43 | 3 | 3003 | E24-2 | PLATINE | 3.37942 | 0.0004305 | 0.0015 | 28.0639 | 0.09484 | 287

# IfcBeam: PL10*180 (8)
In: Undefined
Description: PL10*180; Material: STEEL/E24-2
Tekla Common - Finish: GRENAILLE-PEINT; Grade: E24-2; Profile: PL10*180; Name: POUTRE; sets with these values: 2
Tekla Quantity - Gross footprint area: 0 m2; Height: 180 mm; Width: 10 mm; sets with these values: 2
Name | Center of gravity Z (mm) | Center of gravity Y (mm) | Center of gravity X (mm) | Bottom elevation | Top elevation | Part mark | Assembly mark | Phase | Class | Net weight (kg) = Gross weight (kg) = Weight (kg) = NetWeight (kg) | Net volume (m3) = Gross volume (m3) = NetVolume (m3) | Area per tons (m2) | Net surface area (m2) = Gross area (m2) = OuterSurfaceArea (m2) | Tekla Quantity, Length (mm) = BaseQuantities, Length (mm)
POUTRE | 5429.49 | 7650 | 67727.7 | +5.422 | +5.437 | 204 | P38 | 1 | 1001 | 2.19127 | 0.000279143 | 28.536 | 0.0625301 | 155.079
POUTRE | 5792.21 | 61050 | 67728.1 | +5.778 | +5.807 | 203 | P37 | 1 | 1001 | 2.20748 | 0.000281208 | 28.524 | 0.0629662 | 156.227
POUTRE | 5792.21 | 61050 | 56053.1 | +5.778 | +5.807 | 203 | P2 | 1 | 1001 | 2.20748 | 0.000281208 | 28.524 | 0.0629662 | 156.227
POUTRE | 5792.21 | 7650 | 21028.1 | +5.778 | +5.807 | 297 | P39 | 2 | 2001 | 2.20748 | 0.000281208 | 28.524 | 0.0629662 | 156.227
POUTRE | 5792.21 | 7650 | 32703.1 | +5.778 | +5.807 | 297 | P5 | 3 | 3001 | 2.20748 | 0.000281208 | 28.524 | 0.0629662 | 156.227
POUTRE | 5792.21 | 7650 | 56053.1 | +5.778 | +5.807 | 203 | P4 | 1 | 1001 | 2.20748 | 0.000281208 | 28.524 | 0.0629662 | 156.227
POUTRE | 5792.21 | 7650 | 44378.1 | +5.778 | +5.807 | 203 | P3 | 1 | 1001 | 2.20748 | 0.000281208 | 28.524 | 0.0629662 | 156.227
POUTRE | 5792.21 | 61050 | 44378.1 | +5.778 | +5.807 | 203 | P1 | 1 | 1001 | 2.20748 | 0.000281208 | 28.524 | 0.0629662 | 156.227

# IfcBeam: PL10*200 (18)
In: Undefined
Description: PL10*200
Tekla Common - Phase: 1; Profile: PL10*200; Name: TOLE; sets with these values: 2
Tekla Quantity - Height: 200 mm; Width: 10 mm; sets with these values: 2
Name | Material | Center of gravity Z (mm) | Center of gravity Y (mm) | Center of gravity X (mm) | Bottom elevation | Top elevation | Part mark | Assembly mark | Class | Finish | Grade | Net weight (kg) = Gross weight (kg) = Weight (kg) = NetWeight (kg) | Net volume (m3) = Gross volume (m3) = NetVolume (m3) | Gross footprint area (m2) | Area per tons (m2) | Net surface area (m2) = Gross area (m2) = OuterSurfaceArea (m2) | Tekla Quantity, Length (mm) = BaseQuantities, Length (mm)
TOLE | STEEL/S235JR | 4470 | 18227 | 77004 | +4.465 | +4.475 | 232 | P56 | 1008 | GALVANISE | S235JR | 3.14 | 0.0004 | 0.04 | 28.0255 | 0.088 | 200
TOLE | STEEL/S235JR | 4470 | 18227 | 77945 | +4.465 | +4.475 | 232 | P57 | 1008 | GALVANISE | S235JR | 3.14 | 0.0004 | 0.04 | 28.0255 | 0.088 | 200
TOLE | STEEL/S235JR | 4470 | 20847 | 73830 | +4.465 | +4.475 | 232 | P54 | 1008 | GALVANISE | S235JR | 3.14 | 0.0004 | 0.04 | 28.0255 | 0.088 | 200
TOLE | STEEL/E36-3 | 5885 | 69125 | 44200 | +5.880 | +5.890 | 207 | P26 | 1001 | GRENAILLE-PEINT | E36-3 | 7.536 | 0.00096 | 0.096 | 27.2824 | 0.2056 | 480
TOLE | STEEL/E36-3 | 5885 | 25 | 44200 | +5.880 | +5.890 | 207 | P22 | 1001 | GRENAILLE-PEINT | E36-3 | 7.536 | 0.00096 | 0.096 | 27.2824 | 0.2056 | 480
TOLE | STEEL/E36-3 | 5885 | 25 | 55875 | +5.880 | +5.890 | 207 | P25 | 1001 | GRENAILLE-PEINT | E36-3 | 7.536 | 0.00096 | 0.096 | 27.2824 | 0.2056 | 480
TOLE | STEEL/E36-3 | 5885 | 69125 | 55875 | +5.880 | +5.890 | 207 | P27 | 1001 | GRENAILLE-PEINT | E36-3 | 7.536 | 0.00096 | 0.096 | 27.2824 | 0.2056 | 480
TOLE | STEEL/E36-3 | 5885 | 69125 | 67550 | +5.880 | +5.890 | 207 | P23 | 1001 | GRENAILLE-PEINT | E36-3 | 7.536 | 0.00096 | 0.096 | 27.2824 | 0.2056 | 480
TOLE | STEEL/E36-3 | 5885 | 25 | 67550 | +5.880 | +5.890 | 207 | P24 | 1001 | GRENAILLE-PEINT | E36-3 | 7.536 | 0.00096 | 0.096 | 27.2824 | 0.2056 | 480
TOLE | STEEL/S235JR | 4470 | 20847 | 75824 | +4.465 | +4.475 | 232 | P55 | 1008 | GALVANISE | S235JR | 3.14 | 0.0004 | 0.04 | 28.0255 | 0.088 | 200
TOLE | STEEL/S235JR | 4470 | 22320 | 77004 | +4.465 | +4.475 | 232 | P56 | 1008 | GALVANISE | S235JR | 3.14 | 0.0004 | 0.04 | 28.0255 | 0.088 | 200
TOLE | STEEL/S235JR | 4470 | 22320 | 77945 | +4.465 | +4.475 | 232 | P57 | 1008 | GALVANISE | S235JR | 3.14 | 0.0004 | 0.04 | 28.0255 | 0.088 | 200
TOLE | STEEL/S235JR | 4470 | 19763.2 | 75824 | +4.465 | +4.475 | 233 | P60 | 1008 | GALVANISE | S235JR | 3.14 | 0.0004 | 0.04 | 28.0255 | 0.088 | 200
TOLE | STEEL/S235JR | 4470 | 19763.2 | 73830 | +4.465 | +4.475 | 233 | P58 | 1008 | GALVANISE | S235JR | 3.14 | 0.0004 | 0.04 | 28.0255 | 0.088 | 200
TOLE | STEEL/S235JR | 4470 | 15670.2 | 75824 | +4.465 | +4.475 | 233 | P61 | 1008 | GALVANISE | S235JR | 3.14 | 0.0004 | 0.04 | 28.0255 | 0.088 | 200
TOLE | STEEL/S235JR | 4470 | 15670.2 | 73830 | +4.465 | +4.475 | 233 | P59 | 1008 | GALVANISE | S235JR | 3.14 | 0.0004 | 0.04 | 28.0255 | 0.088 | 200
TOLE | STEEL/S235JR | 4470 | 24940 | 73830 | +4.465 | +4.475 | 232 | P54 | 1008 | GALVANISE | S235JR | 3.14 | 0.0004 | 0.04 | 28.0255 | 0.088 | 200
TOLE | STEEL/S235JR | 4470 | 24940 | 75824 | +4.465 | +4.475 | 232 | P55 | 1008 | GALVANISE | S235JR | 3.14 | 0.0004 | 0.04 | 28.0255 | 0.088 | 200

# IfcBeam: PL10*225 (7)
In: Undefined
Description: PL10*225; Material: STEEL/E24-2
Tekla Common - Part mark: 172; Phase: 1; Class: 1003; Finish: GRENAILLE-PEINT; Grade: E24-2; Profile: PL10*225; Name: PLATINE; sets with these values: 2
Tekla Quantity - Net weight: 3.00263 kg; Gross weight: 3.00263 kg; Weight: 3.00263 kg; Net volume: 0.0003825 m3; Gross volume: 0.0003825 m3; Gross footprint area: 0.03825 m2; Area per tons: 28.1087 m2; Net surface area: 0.0844 m2; Gross area: 0.0844 m2; Height: 225 mm; Width: 10 mm; Length: 170 mm; sets with these values: 2
BaseQuantities - Length: 170 mm; OuterSurfaceArea: 0.0844 m2; NetVolume: 0.0003825 m3; NetWeight: 3.00263 kg
Name | Center of gravity Z (mm) | Center of gravity Y (mm) | Center of gravity X (mm) | Bottom elevation | Top elevation | Assembly mark
PLATINE | 5 | 69285 | 69967.5 | -0.000 | +0.010 | P42
PLATINE | 5 | 69285 | 71602.5 | -0.000 | +0.010 | P43
PLATINE | 5 | 66752.5 | 79245 | -0.000 | +0.010 | P41
PLATINE | 5 | 61517.5 | 79245 | -0.000 | +0.010 | P50
PLATINE | 5 | 59827.5 | 79245 | -0.000 | +0.010 | P40
PLATINE | -55 | 69285 | 57417.5 | -0.060 | -0.050 | P47
PLATINE | -55 | 69285 | 60252.5 | -0.060 | -0.050 | P46

# IfcBeam: PL10*55 (64)
In: Undefined
Description: PL10*55; Material: STEEL/E36-3
Tekla Common - Part mark: H4; Assembly mark: H4; Finish: GRENAILLE-PEINT; Grade: E36-3; Profile: PL10*55; Name: ECLISSE; sets with these values: 2
Tekla Quantity - Net weight: 2.20193 kg; Gross weight: 2.20193 kg; Weight: 2.20193 kg; Net volume: 0.0002805 m3; Gross volume: 0.0002805 m3; Gross footprint area: 0.02805 m2; Area per tons: 30.6096 m2; Net surface area: 0.0674 m2; Gross area: 0.0674 m2; Height: 55 mm; Width: 10 mm; Length: 510 mm; sets with these values: 2
BaseQuantities - Length: 510 mm; OuterSurfaceArea: 0.0674 m2; NetVolume: 0.0002805 m3; NetWeight: 2.20193 kg
Name | Center of gravity Z (mm) | Center of gravity Y (mm) | Center of gravity X (mm) | Bottom elevation | Top elevation | Phase | Class
ECLISSE | 4222.8 | 28324.9 | 20897.5 | +4.218 | +4.228 | 2 | 2006
ECLISSE | 4222.8 | 28324.9 | 20802.5 | +4.218 | +4.228 | 2 | 2006
ECLISSE | 3954.2 | 28324.9 | 20802.5 | +3.949 | +3.959 | 2 | 2006
ECLISSE | 3954.2 | 28324.9 | 20897.5 | +3.949 | +3.959 | 2 | 2006
ECLISSE | 5607.2 | 28324.9 | 20897.5 | +5.602 | +5.612 | 2 | 2006
ECLISSE | 5607.2 | 28324.9 | 20802.5 | +5.602 | +5.612 | 2 | 2006
ECLISSE | 5875.8 | 28324.9 | 20802.5 | +5.871 | +5.881 | 2 | 2006
ECLISSE | 5875.8 | 28324.9 | 20897.5 | +5.871 | +5.881 | 2 | 2006
ECLISSE | 4222.8 | 28324.9 | 67597.5 | +4.218 | +4.228 | 1 | 1006
ECLISSE | 4222.8 | 28324.9 | 67502.5 | +4.218 | +4.228 | 1 | 1006
ECLISSE | 3954.2 | 28324.9 | 67502.5 | +3.949 | +3.959 | 1 | 1006
ECLISSE | 3954.2 | 28324.9 | 67597.5 | +3.949 | +3.959 | 1 | 1006
ECLISSE | 5607.2 | 28324.9 | 67597.5 | +5.602 | +5.612 | 1 | 1006
ECLISSE | 5607.2 | 28324.9 | 67502.5 | +5.602 | +5.612 | 1 | 1006
ECLISSE | 5875.8 | 28324.9 | 67502.5 | +5.871 | +5.881 | 1 | 1006
ECLISSE | 5875.8 | 28324.9 | 67597.5 | +5.871 | +5.881 | 1 | 1006
ECLISSE | 3954.2 | 52175.1 | 67597.5 | +3.949 | +3.959 | 1 | 1006
ECLISSE | 3954.2 | 52175.1 | 67502.5 | +3.949 | +3.959 | 1 | 1006
ECLISSE | 4222.8 | 52175.1 | 67502.5 | +4.218 | +4.228 | 1 | 1006
ECLISSE | 4222.8 | 52175.1 | 67597.5 | +4.218 | +4.228 | 1 | 1006
ECLISSE | 5875.8 | 52175.1 | 67597.5 | +5.871 | +5.881 | 1 | 1006
ECLISSE | 5875.8 | 52175.1 | 67502.5 | +5.871 | +5.881 | 1 | 1006
ECLISSE | 5607.2 | 52175.1 | 67502.5 | +5.602 | +5.612 | 1 | 1006
ECLISSE | 5607.2 | 52175.1 | 67597.5 | +5.602 | +5.612 | 1 | 1006
ECLISSE | 4222.8 | 28324.9 | 55922.5 | +4.218 | +4.228 | 1 | 1006
ECLISSE | 4222.8 | 28324.9 | 55827.5 | +4.218 | +4.228 | 1 | 1006
ECLISSE | 3954.2 | 28324.9 | 55827.5 | +3.949 | +3.959 | 1 | 1006
ECLISSE | 3954.2 | 28324.9 | 55922.5 | +3.949 | +3.959 | 1 | 1006
ECLISSE | 5607.2 | 28324.9 | 55922.5 | +5.602 | +5.612 | 1 | 1006
ECLISSE | 5607.2 | 28324.9 | 55827.5 | +5.602 | +5.612 | 1 | 1006
ECLISSE | 5875.8 | 28324.9 | 55827.5 | +5.871 | +5.881 | 1 | 1006
ECLISSE | 5875.8 | 28324.9 | 55922.5 | +5.871 | +5.881 | 1 | 1006
ECLISSE | 3954.2 | 52175.1 | 55922.5 | +3.949 | +3.959 | 1 | 1006
ECLISSE | 3954.2 | 52175.1 | 55827.5 | +3.949 | +3.959 | 1 | 1006
ECLISSE | 4222.8 | 52175.1 | 55827.5 | +4.218 | +4.228 | 1 | 1006
ECLISSE | 4222.8 | 52175.1 | 55922.5 | +4.218 | +4.228 | 1 | 1006
ECLISSE | 5875.8 | 52175.1 | 55922.5 | +5.871 | +5.881 | 1 | 1006
ECLISSE | 5875.8 | 52175.1 | 55827.5 | +5.871 | +5.881 | 1 | 1006
ECLISSE | 5607.2 | 52175.1 | 55827.5 | +5.602 | +5.612 | 1 | 1006
ECLISSE | 5607.2 | 52175.1 | 55922.5 | +5.602 | +5.612 | 1 | 1006
ECLISSE | 4222.8 | 28324.9 | 32572.5 | +4.218 | +4.228 | 3 | 3006
ECLISSE | 4222.8 | 28324.9 | 32477.5 | +4.218 | +4.228 | 3 | 3006
ECLISSE | 3954.2 | 28324.9 | 32477.5 | +3.949 | +3.959 | 3 | 3006
ECLISSE | 3954.2 | 28324.9 | 32572.5 | +3.949 | +3.959 | 3 | 3006
ECLISSE | 5607.2 | 28324.9 | 32477.5 | +5.602 | +5.612 | 3 | 3006
ECLISSE | 5607.2 | 28324.9 | 32572.5 | +5.602 | +5.612 | 3 | 3006
ECLISSE | 5875.8 | 28324.9 | 32572.5 | +5.871 | +5.881 | 3 | 3006
ECLISSE | 5875.8 | 28324.9 | 32477.5 | +5.871 | +5.881 | 3 | 3006
ECLISSE | 4222.8 | 28324.9 | 44247.5 | +4.218 | +4.228 | 1 | 1006
ECLISSE | 4222.8 | 28324.9 | 44152.5 | +4.218 | +4.228 | 1 | 1006
ECLISSE | 3954.2 | 28324.9 | 44152.5 | +3.949 | +3.959 | 1 | 1006
ECLISSE | 3954.2 | 28324.9 | 44247.5 | +3.949 | +3.959 | 1 | 1006
ECLISSE | 5875.8 | 28324.9 | 44247.5 | +5.871 | +5.881 | 1 | 1006
ECLISSE | 5607.2 | 28324.9 | 44247.5 | +5.602 | +5.612 | 1 | 1006
ECLISSE | 5875.8 | 28324.9 | 44152.5 | +5.871 | +5.881 | 1 | 1006
ECLISSE | 5607.2 | 28324.9 | 44152.5 | +5.602 | +5.612 | 1 | 1006
ECLISSE | 3954.2 | 52175.1 | 44247.5 | +3.949 | +3.959 | 1 | 1006
ECLISSE | 3954.2 | 52175.1 | 44152.5 | +3.949 | +3.959 | 1 | 1006
ECLISSE | 4222.8 | 52175.1 | 44152.5 | +4.218 | +4.228 | 1 | 1006
ECLISSE | 4222.8 | 52175.1 | 44247.5 | +4.218 | +4.228 | 1 | 1006
ECLISSE | 5875.8 | 52175.1 | 44247.5 | +5.871 | +5.881 | 1 | 1006
ECLISSE | 5875.8 | 52175.1 | 44152.5 | +5.871 | +5.881 | 1 | 1006
ECLISSE | 5607.2 | 52175.1 | 44152.5 | +5.602 | +5.612 | 1 | 1006
ECLISSE | 5607.2 | 52175.1 | 44247.5 | +5.602 | +5.612 | 1 | 1006

# IfcBeam: PL10*80, PLATINE
In: Undefined
Description: PL10*80; Material: STEEL/E24-2
Tekla Common - Center of gravity Z: 5 mm; Center of gravity Y: 64280 mm; Center of gravity X: 79245 mm; Bottom elevation: -0.000; Top elevation: +0.010; Part mark: 173; Assembly mark: P51; Phase: 1; Class: 1003; Finish: GRENAILLE-PEINT; Grade: E24-2; Profile: PL10*80; Name: PLATINE; sets with these values: 2
Tekla Quantity - Net weight: 1.0676 kg; Gross weight: 1.0676 kg; Weight: 1.0676 kg; Net volume: 0.000136 m3; Gross volume: 0.000136 m3; Gross footprint area: 0.0136 m2; Area per tons: 30.1611 m2; Net surface area: 0.0322 m2; Gross area: 0.0322 m2; Height: 80 mm; Width: 10 mm; Length: 170 mm; sets with these values: 2
BaseQuantities - Length: 170 mm; OuterSurfaceArea: 0.0322 m2; NetVolume: 0.000136 m3; NetWeight: 1.0676 kg

# IfcBeam: PL100*10 (6)
In: Undefined
Description: PL100*10; Material: STEEL/E24-2
Tekla Common - Finish: GRENAILLE-PEINT; Grade: E24-2; Profile: PL100*10; sets with these values: 2
Tekla Quantity - Gross footprint area: 0.001 m2; Height: 100 mm; Width: 10 mm; sets with these values: 2
Name | Center of gravity Z (mm) | Center of gravity Y (mm) | Center of gravity X (mm) | Bottom elevation | Top elevation | Part mark | Assembly mark | Phase | Class | Net weight (kg) = Gross weight (kg) = Weight (kg) = NetWeight (kg) | Net volume (m3) = Gross volume (m3) = NetVolume (m3) | Area per tons (m2) | Net surface area (m2) = Gross area (m2) = OuterSurfaceArea (m2) | Tekla Quantity, Length (mm) = BaseQuantities, Length (mm)
 | -150 | -220 | 22452 | -0.200 | -0.100 | 190 | M16 | 3 | 3003 | 0.785 | 0.0001 | 30.5732 | 0.024 | 100
 | -150 | -220 | 74705 | -0.200 | -0.100 | 190 | P111 | 1 | 1003 | 0.785 | 0.0001 | 30.5732 | 0.024 | 100
 | -150 | -220 | 70870 | -0.200 | -0.100 | 190 | P109 | 1 | 1003 | 0.785 | 0.0001 | 30.5732 | 0.024 | 100
 | -150 | -220 | 57575 | -0.200 | -0.100 | 190 | P44 | 1 | 1003 | 0.785 | 0.0001 | 30.5732 | 0.024 | 100
 | -150 | 30170 | 79330 | -0.200 | -0.100 | 190 | P49 | 1 | 1003 | 0.785 | 0.0001 | 30.5732 | 0.024 | 100
PLATINE | 2126.86 | 7657.8 | 79225 | +2.027 | +2.227 | 243 | B4 | 1 | 1002 | 1.57 | 0.0002 | 29.2994 | 0.046 | 200 | Tekla Common - Name: PLATINE

# IfcBeam: PL100*5 (11)
In: Undefined
Description: PL100*5; Material: STEEL/S235JR
Tekla Common - Part mark: 1201; Phase: 4; Class: 4000; Finish: GALVANISE; Grade: S235JR; Profile: PL100*5; Name: SUPPORT; sets with these values: 2
Tekla Quantity - Net weight: 0.712584 kg; Gross weight: 0.785 kg; Weight: 0.712584 kg; Net volume: 0.000090775 m3; Gross volume: 0.0001 m3; Gross footprint area: 0.0005 m2; Area per tons: 57.1021 m2; Net surface area: 0.04069 m2; Gross area: 0.043 m2; Height: 100 mm; Width: 5 mm; Length: 200 mm; sets with these values: 2
BaseQuantities - Length: 200 mm; OuterSurfaceArea: 0.04069 m2; NetVolume: 0.000090775 m3; NetWeight: 0.712584 kg
Name | Center of gravity Z (mm) | Center of gravity Y (mm) | Center of gravity X (mm) | Bottom elevation | Top elevation | Assembly mark
SUPPORT | 5089.91 | 18956 | 71869.5 | +4.990 | +5.190 | E1
SUPPORT | 4790 | 25444 | 55742.5 | +4.690 | +4.890 | E2
SUPPORT | 5440 | 25444 | 55742.5 | +5.340 | +5.540 | E2
SUPPORT | 4790 | 25444 | 44067.5 | +4.690 | +4.890 | E2
SUPPORT | 5440 | 25444 | 44067.5 | +5.340 | +5.540 | E2
SUPPORT | 4790 | 25444 | 32392.5 | +4.690 | +4.890 | E2
SUPPORT | 5440 | 25444 | 32392.5 | +5.340 | +5.540 | E2
SUPPORT | 4790 | 22544 | 67417.5 | +4.690 | +4.890 | E2
SUPPORT | 5440 | 22544 | 67417.5 | +5.340 | +5.540 | E2
SUPPORT | 4439.82 | 18956 | 71869.5 | +4.340 | +4.540 | E1
SUPPORT | 5740 | 18956 | 71869.5 | +5.640 | +5.840 | E1

# IfcBeam: PL100*6 (10)
In: Undefined
Description: PL100*6
Tekla Common - Phase: 1; Profile: PL100*6; sets with these values: 2
Tekla Quantity - Height: 100 mm; Width: 6 mm; sets with these values: 2
Name | Material | Center of gravity Z (mm) | Center of gravity Y (mm) | Center of gravity X (mm) | Bottom elevation | Top elevation | Part mark | Assembly mark | Class | Finish | Grade | Net weight (kg) = Weight (kg) = NetWeight (kg) | Gross weight (kg) | Net volume (m3) = NetVolume (m3) | Gross volume (m3) | Gross footprint area (m2) | Area per tons (m2) | Net surface area (m2) = OuterSurfaceArea (m2) | Gross area (m2) | Tekla Quantity, Length (mm) = BaseQuantities, Length (mm)
 | STEEL/S235JR | 5900 | 27403 | 72603.6 | +5.855 | +5.945 | 343 | S29 | 1008 | GALVANISE | S235JR | 0.413302 | 0.4239 | 0.00005265 | 0.000054 | 0.00051 | 47.7243 | 0.0197246 | 0.02028 | 90
 | STEEL/E24-2 | 5780 | 19497 | 71708 | +5.720 | +5.840 | 338 | M1 | 1007 | GRENAILLE-PEINT | E24-2 | 0.5652 | 0.5652 | 0.000072 | 0.000072 | 0.0006 | 47.1338 | 0.02664 | 0.02664 | 120
 | STEEL/E24-2 | 5780 | 22047 | 71708 | +5.720 | +5.840 | 338 | M2 | 1007 | GRENAILLE-PEINT | E24-2 | 0.5652 | 0.5652 | 0.000072 | 0.000072 | 0.0006 | 47.1338 | 0.02664 | 0.02664 | 120
 | STEEL/S235JR | 5900 | 27403 | 75303.6 | +5.855 | +5.945 | 343 | S29 | 1008 | GALVANISE | S235JR | 0.413302 | 0.4239 | 0.00005265 | 0.000054 | 0.00051 | 47.7243 | 0.0197246 | 0.02028 | 90
 | STEEL/S235JR | 5900 | 28653 | 72603.6 | +5.855 | +5.945 | 343 | S29 | 1008 | GALVANISE | S235JR | 0.413302 | 0.4239 | 0.00005265 | 0.000054 | 0.00051 | 47.7243 | 0.0197246 | 0.02028 | 90
 | STEEL/S235JR | 5900 | 28653 | 75303.6 | +5.855 | +5.945 | 343 | S29 | 1008 | GALVANISE | S235JR | 0.413302 | 0.4239 | 0.00005265 | 0.000054 | 0.00051 | 47.7243 | 0.0197246 | 0.02028 | 90
 | STEEL/S235JR | 5900 | 29903 | 72603.6 | +5.855 | +5.945 | 343 | S29 | 1008 | GALVANISE | S235JR | 0.413302 | 0.4239 | 0.00005265 | 0.000054 | 0.00051 | 47.7243 | 0.0197246 | 0.02028 | 90
 | STEEL/S235JR | 5900 | 29903 | 75303.6 | +5.855 | +5.945 | 343 | S29 | 1008 | GALVANISE | S235JR | 0.413302 | 0.4239 | 0.00005265 | 0.000054 | 0.00051 | 47.7243 | 0.0197246 | 0.02028 | 90
 | STEEL/S235JR | 5900 | 31153 | 72603.6 | +5.855 | +5.945 | 343 | S29 | 1008 | GALVANISE | S235JR | 0.413302 | 0.4239 | 0.00005265 | 0.000054 | 0.00051 | 47.7243 | 0.0197246 | 0.02028 | 90
 | STEEL/S235JR | 5900 | 31153 | 75303.6 | +5.855 | +5.945 | 343 | S29 | 1008 | GALVANISE | S235JR | 0.413302 | 0.4239 | 0.00005265 | 0.000054 | 0.00051 | 47.7243 | 0.0197246 | 0.02028 | 90

# IfcBeam: PL100*8 (12)
In: Undefined
Description: PL100*8; Material: STEEL/E24-2
Tekla Common - Phase: 2; Finish: GRENAILLE-PEINT; Grade: E24-2; Profile: PL100*8; sets with these values: 2
Tekla Quantity - Height: 100 mm; Width: 8 mm; sets with these values: 2
Name | Center of gravity Z (mm) | Center of gravity Y (mm) | Center of gravity X (mm) | Bottom elevation | Top elevation | Part mark | Assembly mark | Class | Net weight (kg) = Gross weight (kg) = Weight (kg) = NetWeight (kg) | Net volume (m3) = Gross volume (m3) = NetVolume (m3) | Gross footprint area (m2) | Area per tons (m2) | Net surface area (m2) = Gross area (m2) = OuterSurfaceArea (m2) | Tekla Quantity, Length (mm) = BaseQuantities, Length (mm)
GOUSSET | 10227.5 | 50109 | 26177.5 | +10.176 | +10.279 | 728 | B6 | 2004 | 0.7536 | 0.000096 | 0 | 36.518 | 0.02752 | 120 | Tekla Common - Name: GOUSSET
GOUSSET | 10227.5 | 66331 | 26177.5 | +10.176 | +10.279 | 728 | B6 | 2004 | 0.7536 | 0.000096 | 0 | 36.518 | 0.02752 | 120 | Tekla Common - Name: GOUSSET
 | 4240 | 9934.5 | 100 | +4.190 | +4.290 | 677 | L52 | 2003 | 0.628 | 0.00008 | 0.0008 | 36.9427 | 0.0232 | 100
 | 4240 | 9934.5 | 2410 | +4.190 | +4.290 | 677 | L52 | 2003 | 0.628 | 0.00008 | 0.0008 | 36.9427 | 0.0232 | 100
 | 3030 | 9934.5 | 2210 | +2.980 | +3.080 | 677 | L52 | 2003 | 0.628 | 0.00008 | 0.0008 | 36.9427 | 0.0232 | 100
 | 3030 | 9934.5 | 4520 | +2.980 | +3.080 | 677 | L52 | 2003 | 0.628 | 0.00008 | 0.0008 | 36.9427 | 0.0232 | 100
 | 3030 | 9934.5 | 4720 | +2.980 | +3.080 | 677 | L52 | 2003 | 0.628 | 0.00008 | 0.0008 | 36.9427 | 0.0232 | 100
 | 4240 | 9934.5 | 6830 | +4.190 | +4.290 | 677 | L52 | 2003 | 0.628 | 0.00008 | 0.0008 | 36.9427 | 0.0232 | 100
 | 4240 | 9934.5 | 9134.6 | +4.190 | +4.290 | 677 | L52 | 2003 | 0.628 | 0.00008 | 0.0008 | 36.9427 | 0.0232 | 100
 | 4210 | 9934.5 | 9334.6 | +4.130 | +4.290 | 678 | L52 | 2003 | 1.0048 | 0.000128 | 0.0008 | 35.9873 | 0.03616 | 160
 | 3060 | 9934.5 | 10220 | +2.980 | +3.140 | 678 | L52 | 2003 | 1.0048 | 0.000128 | 0.0008 | 35.9873 | 0.03616 | 160
 | 3030 | 9934.5 | 7030 | +2.980 | +3.080 | 677 | L52 | 2003 | 0.628 | 0.00008 | 0.0008 | 36.9427 | 0.0232 | 100

# IfcBeam: PL1000*2353, GOUSSET
In: Undefined
Description: PL1000*2353; Material: STEEL/S235JR
Tekla Common - Center of gravity Z: 500 mm; Center of gravity Y: 22577.4 mm; Center of gravity X: -2652.98 mm; Bottom elevation: +0.000; Top elevation: +1.000; Part mark: G99; Assembly mark: G99; Phase: 1; Class: 99; Grade: S235JR; Profile: PL1000*2353; Name: GOUSSET; sets with these values: 2
Tekla Quantity - Net weight: 25878.2 kg; Gross weight: 58988.6 kg; Weight: 25878.2 kg; Net volume: 3.29659 m3; Gross volume: 3.75723 m3; Gross footprint area: 3.29659 m2; Area per tons: 0.725159 m2; Net surface area: 18.7658 m2; Gross area: 7.51447 m2; Height: 2353.34 mm; Width: 1000 mm; Length: 3193.1 mm; sets with these values: 2
Tekla Status - Erection Comment: Missing Value; Checked Date: 0; Assigned By: Me; sets with these values: 2
BaseQuantities - Length: 3193.1 mm; OuterSurfaceArea: 18.7658 m2; NetVolume: 3.29659 m3; NetWeight: 25878.2 kg

# IfcBeam: PL110*6 (44)
In: Undefined
Description: PL110*6; Material: STEEL/E24-2
Tekla Common - Finish: GRENAILLE-PEINT; Grade: E24-2; Profile: PL110*6; Name: PLAT; sets with these values: 2
Tekla Quantity - Height: 110 mm; Width: 6 mm; sets with these values: 2
Name | Center of gravity Z (mm) | Center of gravity Y (mm) | Center of gravity X (mm) | Bottom elevation | Top elevation | Part mark | Assembly mark | Phase | Class | Net weight (kg) = Gross weight (kg) = Weight (kg) = NetWeight (kg) | Net volume (m3) = Gross volume (m3) = NetVolume (m3) | Gross footprint area (m2) | Area per tons (m2) | Net surface area (m2) = Gross area (m2) = OuterSurfaceArea (m2) | Tekla Quantity, Length (mm) = BaseQuantities, Length (mm)
PLAT | 4281 | 10930 | -207 | +4.278 | +4.284 | 347 | L118 | 2 | 2003 | 0.445566 | 0.00005676 | 0.00946 | 47.7415 | 0.021272 | 86
PLAT | 4287 | 10930 | -205 | +4.284 | +4.290 | 348 | L51 | 2 | 2003 | 0.46629 | 0.0000594 | 0.0099 | 47.6099 | 0.0222 | 90
PLAT | 2989 | 10930 | -207 | +2.986 | +2.992 | 347 | L118 | 2 | 2003 | 0.445566 | 0.00005676 | 0.00946 | 47.7415 | 0.021272 | 86
PLAT | 2983 | 10930 | -205 | +2.980 | +2.986 | 348 | L51 | 2 | 2003 | 0.46629 | 0.0000594 | 0.0099 | 47.6099 | 0.0222 | 90
PLAT | 4281 | 13060 | -207 | +4.278 | +4.284 | 347 | L118 | 2 | 2003 | 0.445566 | 0.00005676 | 0.00946 | 47.7415 | 0.021272 | 86
PLAT | 4287 | 13060 | -205 | +4.284 | +4.290 | 348 | L51 | 2 | 2003 | 0.46629 | 0.0000594 | 0.0099 | 47.6099 | 0.0222 | 90
PLAT | 2989 | 13060 | -207 | +2.986 | +2.992 | 347 | L118 | 2 | 2003 | 0.445566 | 0.00005676 | 0.00946 | 47.7415 | 0.021272 | 86
PLAT | 2983 | 13060 | -205 | +2.980 | +2.986 | 348 | L51 | 2 | 2003 | 0.46629 | 0.0000594 | 0.0099 | 47.6099 | 0.0222 | 90
PLAT | 4281 | 17320 | -207 | +4.278 | +4.284 | 347 | L118 | 2 | 2003 | 0.445566 | 0.00005676 | 0.00946 | 47.7415 | 0.021272 | 86
PLAT | 4287 | 17320 | -205 | +4.284 | +4.290 | 348 | L50 | 2 | 2003 | 0.46629 | 0.0000594 | 0.0099 | 47.6099 | 0.0222 | 90
PLAT | 2989 | 17320 | -207 | +2.986 | +2.992 | 347 | L118 | 2 | 2003 | 0.445566 | 0.00005676 | 0.00946 | 47.7415 | 0.021272 | 86
PLAT | 2983 | 17320 | -205 | +2.980 | +2.986 | 348 | L50 | 2 | 2003 | 0.46629 | 0.0000594 | 0.0099 | 47.6099 | 0.0222 | 90
PLAT | 2989 | 15190 | -207 | +2.986 | +2.992 | 347 | L118 | 2 | 2003 | 0.445566 | 0.00005676 | 0.00946 | 47.7415 | 0.021272 | 86
PLAT | 4281 | 15190 | -207 | +4.278 | +4.284 | 347 | L118 | 2 | 2003 | 0.445566 | 0.00005676 | 0.00946 | 47.7415 | 0.021272 | 86
PLAT | 2983 | 19450 | -205 | +2.980 | +2.986 | 348 | L50 | 2 | 2003 | 0.46629 | 0.0000594 | 0.0099 | 47.6099 | 0.0222 | 90
PLAT | 2989 | 19450 | -207 | +2.986 | +2.992 | 347 | L118 | 2 | 2003 | 0.445566 | 0.00005676 | 0.00946 | 47.7415 | 0.021272 | 86
PLAT | 4287 | 19450 | -205 | +4.284 | +4.290 | 348 | L50 | 2 | 2003 | 0.46629 | 0.0000594 | 0.0099 | 47.6099 | 0.0222 | 90
PLAT | 4281 | 19450 | -207 | +4.278 | +4.284 | 347 | L118 | 2 | 2003 | 0.445566 | 0.00005676 | 0.00946 | 47.7415 | 0.021272 | 86
PLAT | 2989 | 21981.2 | -207 | +2.986 | +2.992 | 347 | L118 | 2 | 2003 | 0.445566 | 0.00005676 | 0.00946 | 47.7415 | 0.021272 | 86
PLAT | 4281 | 21981.2 | -207 | +4.278 | +4.284 | 347 | L118 | 2 | 2003 | 0.445566 | 0.00005676 | 0.00946 | 47.7415 | 0.021272 | 86
PLAT | 2983 | 24512.5 | -205 | +2.980 | +2.986 | 348 | L49 | 2 | 2003 | 0.46629 | 0.0000594 | 0.0099 | 47.6099 | 0.0222 | 90
PLAT | 2989 | 24512.5 | -207 | +2.986 | +2.992 | 347 | L118 | 2 | 2003 | 0.445566 | 0.00005676 | 0.00946 | 47.7415 | 0.021272 | 86
PLAT | 4287 | 24512.5 | -205 | +4.284 | +4.290 | 348 | L49 | 2 | 2003 | 0.46629 | 0.0000594 | 0.0099 | 47.6099 | 0.0222 | 90
PLAT | 4281 | 24512.5 | -207 | +4.278 | +4.284 | 347 | L118 | 2 | 2003 | 0.445566 | 0.00005676 | 0.00946 | 47.7415 | 0.021272 | 86
PLAT | 4281 | 29375 | -207 | +4.278 | +4.284 | 347 | L118 | 2 | 2003 | 0.445566 | 0.00005676 | 0.00946 | 47.7415 | 0.021272 | 86
PLAT | 4287 | 29375 | -205 | +4.284 | +4.290 | 348 | L49 | 2 | 2003 | 0.46629 | 0.0000594 | 0.0099 | 47.6099 | 0.0222 | 90
PLAT | 2989 | 29375 | -207 | +2.986 | +2.992 | 347 | L118 | 2 | 2003 | 0.445566 | 0.00005676 | 0.00946 | 47.7415 | 0.021272 | 86
PLAT | 2983 | 29375 | -205 | +2.980 | +2.986 | 348 | L49 | 2 | 2003 | 0.46629 | 0.0000594 | 0.0099 | 47.6099 | 0.0222 | 90
PLAT | 2983 | 27043.8 | -205 | +2.980 | +2.986 | 348 | L49 | 2 | 2003 | 0.46629 | 0.0000594 | 0.0099 | 47.6099 | 0.0222 | 90
PLAT | 2989 | 27043.8 | -207 | +2.986 | +2.992 | 347 | L118 | 2 | 2003 | 0.445566 | 0.00005676 | 0.00946 | 47.7415 | 0.021272 | 86
PLAT | 4287 | 27043.8 | -205 | +4.284 | +4.290 | 348 | L49 | 2 | 2003 | 0.46629 | 0.0000594 | 0.0099 | 47.6099 | 0.0222 | 90
PLAT | 4281 | 27043.8 | -207 | +4.278 | +4.284 | 347 | L118 | 2 | 2003 | 0.445566 | 0.00005676 | 0.00946 | 47.7415 | 0.021272 | 86
PLAT | 2989 | 33300 | -207 | +2.986 | +2.992 | 347 | L117 | 5 | 5001 | 0.445566 | 0.00005676 | 0.00946 | 47.7415 | 0.021272 | 86
PLAT | 2983 | 33300 | -205 | +2.980 | +2.986 | 348 | L54 | 5 | 5001 | 0.46629 | 0.0000594 | 0.0099 | 47.6099 | 0.0222 | 90
PLAT | 4281 | 33300 | -207 | +4.278 | +4.284 | 347 | L117 | 5 | 5001 | 0.445566 | 0.00005676 | 0.00946 | 47.7415 | 0.021272 | 86
PLAT | 4287 | 33300 | -205 | +4.284 | +4.290 | 348 | L54 | 5 | 5001 | 0.46629 | 0.0000594 | 0.0099 | 47.6099 | 0.0222 | 90
PLAT | 4281 | 29630 | -207 | +4.278 | +4.284 | 347 | L53 | 5 | 5001 | 0.445566 | 0.00005676 | 0.00946 | 47.7415 | 0.021272 | 86
PLAT | 4287 | 29630 | -205 | +4.284 | +4.290 | 348 | L54 | 5 | 5001 | 0.46629 | 0.0000594 | 0.0099 | 47.6099 | 0.0222 | 90
PLAT | 2989 | 29630 | -207 | +2.986 | +2.992 | 347 | L53 | 5 | 5001 | 0.445566 | 0.00005676 | 0.00946 | 47.7415 | 0.021272 | 86
PLAT | 2983 | 29630 | -205 | +2.980 | +2.986 | 348 | L54 | 5 | 5001 | 0.46629 | 0.0000594 | 0.0099 | 47.6099 | 0.0222 | 90
PLAT | 4281 | 32243.8 | -207 | +4.278 | +4.284 | 347 | L32 | 5 | 5001 | 0.445566 | 0.00005676 | 0.00946 | 47.7415 | 0.021272 | 86
PLAT | 4287 | 32243.8 | -205 | +4.284 | +4.290 | 348 | L54 | 5 | 5001 | 0.46629 | 0.0000594 | 0.0099 | 47.6099 | 0.0222 | 90
PLAT | 2989 | 32243.8 | -207 | +2.986 | +2.992 | 347 | L32 | 5 | 5001 | 0.445566 | 0.00005676 | 0.00946 | 47.7415 | 0.021272 | 86
PLAT | 2983 | 32243.8 | -205 | +2.980 | +2.986 | 348 | L54 | 5 | 5001 | 0.46629 | 0.0000594 | 0.0099 | 47.6099 | 0.0222 | 90

# IfcBeam: PL110*8 (2)
In: Undefined
Description: PL110*8; Material: STEEL/S235JR
Tekla Common - Center of gravity Z: 5760 mm; Center of gravity Y: 48555 mm; Bottom elevation: +5.705; Top elevation: +5.815; Part mark: 721; Assembly mark: S99; Phase: 2; Class: 2007; Finish: GALVANISE; Grade: S235JR; Profile: PL110*8; Name: SOLIVE; sets with these values: 2
Tekla Quantity - Net weight: 0.75988 kg; Gross weight: 0.75988 kg; Weight: 0.75988 kg; Net volume: 0.0000968 m3; Gross volume: 0.0000968 m3; Gross footprint area: 0.00088 m2; Area per tons: 36.4794 m2; Net surface area: 0.02772 m2; Gross area: 0.02772 m2; Height: 110 mm; Width: 8 mm; Length: 110 mm; sets with these values: 2
BaseQuantities - Length: 110 mm; OuterSurfaceArea: 0.02772 m2; NetVolume: 0.0000968 m3; NetWeight: 0.75988 kg
Name | Center of gravity X (mm)
SOLIVE | 20469
SOLIVE | 19616

# IfcBeam: PL114*6, PLAT
In: Undefined
Description: PL114*6; Material: STEEL/S235JR
Tekla Common - Center of gravity Z: 5827 mm; Center of gravity Y: 13499 mm; Center of gravity X: 79008.5 mm; Bottom elevation: +5.824; Top elevation: +5.830; Part mark: 354; Assembly mark: L11; Phase: 1; Class: 1003; Finish: GRENAILLE-PEINT; Grade: S235JR; Profile: PL114*6; Name: PLAT; sets with these values: 2
Tekla Quantity - Net weight: 0.35975 kg; Gross weight: 0.35975 kg; Weight: 0.35975 kg; Net volume: 0.000045828 m3; Gross volume: 0.000045828 m3; Gross footprint area: 0.007638 m2; Area per tons: 48.5004 m2; Net surface area: 0.017448 m2; Gross area: 0.017448 m2; Height: 114 mm; Width: 6 mm; Length: 67 mm; sets with these values: 2
BaseQuantities - Length: 67 mm; OuterSurfaceArea: 0.017448 m2; NetVolume: 0.000045828 m3; NetWeight: 0.35975 kg

# IfcBeam: PL115*8 (11)
In: Undefined
Description: PL115*8; Material: STEEL/S235JR
Tekla Common - Center of gravity Z: 5760 mm; Center of gravity X: 19616 mm; Bottom elevation: +5.702; Top elevation: +5.817; Phase: 2; Class: 2007; Finish: GALVANISE; Grade: S235JR; Profile: PL115*8; Name: SOLIVE; sets with these values: 2
Tekla Quantity - Height: 115 mm; Width: 8 mm; sets with these values: 2
Name | Center of gravity Y (mm) | Part mark | Assembly mark | Net weight (kg) = Gross weight (kg) = Weight (kg) = NetWeight (kg) | Net volume (m3) = Gross volume (m3) = NetVolume (m3) | Gross footprint area (m2) | Area per tons (m2) | Net surface area (m2) = Gross area (m2) = OuterSurfaceArea (m2) | Tekla Quantity, Length (mm) = BaseQuantities, Length (mm)
SOLIVE | 45306.5 | 722 | S1 | 1.73328 | 0.0002208 | 0.00192 | 35.1242 | 0.06088 | 240
SOLIVE | 42706.5 | 722 | S1 | 1.73328 | 0.0002208 | 0.00192 | 35.1242 | 0.06088 | 240
SOLIVE | 37506.5 | 722 | S1 | 1.73328 | 0.0002208 | 0.00192 | 35.1242 | 0.06088 | 240
SOLIVE | 32306.5 | 722 | S1 | 1.73328 | 0.0002208 | 0.00192 | 35.1242 | 0.06088 | 240
SOLIVE | 27106.5 | 722 | S1 | 1.73328 | 0.0002208 | 0.00192 | 35.1242 | 0.06088 | 240
SOLIVE | 21906.5 | 722 | S1 | 1.73328 | 0.0002208 | 0.00192 | 35.1242 | 0.06088 | 240
SOLIVE | 17233.5 | 722 | S1 | 1.73328 | 0.0002208 | 0.00192 | 35.1242 | 0.06088 | 240
SOLIVE | 12513.5 | 722 | S1 | 1.73328 | 0.0002208 | 0.00192 | 35.1242 | 0.06088 | 240
SOLIVE | 9866.5 | 722 | S1 | 1.73328 | 0.0002208 | 0.00192 | 35.1242 | 0.06088 | 240
SOLIVE | 4956.5 | 722 | S1 | 1.73328 | 0.0002208 | 0.00192 | 35.1242 | 0.06088 | 240
SOLIVE | 109.502 | 828 | S2 | 1.33607 | 0.0001702 | 0.00148 | 35.4398 | 0.04735 | 185

# IfcBeam: PL12*130, PLATINE
In: Undefined
Description: PL12*130; Material: STEEL/E24-2
Tekla Common - Center of gravity Z: 5580.87 mm; Center of gravity Y: 61039.7 mm; Center of gravity X: 32810 mm; Bottom elevation: +5.421; Top elevation: +5.741; Part mark: 1257; Assembly mark: H76; Phase: 3; Class: 3005; Finish: GRENAILLE-PEINT; Grade: E24-2; Profile: PL12*130; Name: PLATINE; sets with these values: 2
Tekla Quantity - Net weight: 3.91872 kg; Gross weight: 3.91872 kg; Weight: 3.91872 kg; Net volume: 0.0004992 m3; Gross volume: 0.0004992 m3; Gross footprint area: 0.00156 m2; Area per tons: 23.9874 m2; Net surface area: 0.094 m2; Gross area: 0.094 m2; Height: 130 mm; Width: 12 mm; Length: 320 mm; sets with these values: 2
BaseQuantities - Length: 320 mm; OuterSurfaceArea: 0.094 m2; NetVolume: 0.0004992 m3; NetWeight: 3.91872 kg

# IfcBeam: PL12*160 (2)
In: Undefined
Description: PL12*160; Material: STEEL/E24-2
Tekla Common - Center of gravity Z: 3208.67 mm; Center of gravity X: 9295 mm; Bottom elevation: +3.203; Top elevation: +3.215; Part mark: 1275; Phase: 2; Class: 2001; Finish: GRENAILLE-PEINT; Grade: E24-2; Profile: PL12*160; Name: PLATINE; sets with these values: 2
Tekla Quantity - Net weight: 2.71296 kg; Gross weight: 2.71296 kg; Weight: 2.71296 kg; Net volume: 0.0003456 m3; Gross volume: 0.0003456 m3; Gross footprint area: 0.0288 m2; Area per tons: 24.2392 m2; Net surface area: 0.06576 m2; Gross area: 0.06576 m2; Height: 160 mm; Width: 12 mm; Length: 180 mm; sets with these values: 2
BaseQuantities - Length: 180 mm; OuterSurfaceArea: 0.06576 m2; NetVolume: 0.0003456 m3; NetWeight: 2.71296 kg
Name | Center of gravity Y (mm) | Assembly mark
PLATINE | 48525 | P128
PLATINE | 10930 | P129

# IfcBeam: PL12*180 (35)
In: Undefined
Description: PL12*180; Material: STEEL/E24-2
Tekla Common - Finish: GRENAILLE-PEINT; Grade: E24-2; Profile: PL12*180; Name: PLATINE; sets with these values: 2
Tekla Quantity - Height: 180 mm; Width: 12 mm; sets with these values: 2
Name | Center of gravity Z (mm) | Center of gravity Y (mm) | Center of gravity X (mm) | Bottom elevation | Top elevation | Part mark | Assembly mark | Phase | Class | Net weight (kg) = Gross weight (kg) = Weight (kg) = NetWeight (kg) | Net volume (m3) = Gross volume (m3) = NetVolume (m3) | Gross footprint area (m2) | Area per tons (m2) | Net surface area (m2) = Gross area (m2) = OuterSurfaceArea (m2) | Tekla Quantity, Length (mm) = BaseQuantities, Length (mm)
PLATINE | -394 | 69275 | 61712.5 | -0.400 | -0.388 | 1254 | P19 | 1 | 1001 | 3.73032 | 0.0004752 | 0.0396 | 23.8049 | 0.0888 | 220
PLATINE | -394 | 69275 | 38362.5 | -0.400 | -0.388 | 1254 | P21 | 3 | 3001 | 3.73032 | 0.0004752 | 0.0396 | 23.8049 | 0.0888 | 220
PLATINE | -394 | 69275 | 50037.5 | -0.400 | -0.388 | 1254 | P20 | 1 | 1001 | 3.73032 | 0.0004752 | 0.0396 | 23.8049 | 0.0888 | 220
PLATINE | -394 | 19450 | 79235 | -0.400 | -0.388 | 1271 | P9 | 1 | 1011 | 3.73032 | 0.0004752 | 0.0396 | 23.8049 | 0.0888 | 220
PLATINE | -394 | 1750 | 79235 | -0.400 | -0.388 | 1271 | P7 | 1 | 1011 | 3.73032 | 0.0004752 | 0.0396 | 23.8049 | 0.0888 | 220
PLATINE | -394 | 13550 | 79235 | -0.400 | -0.388 | 1277 | P8 | 1 | 1011 | 3.73032 | 0.0004752 | 0.0396 | 23.8049 | 0.0888 | 220
PLATINE | -394 | -76.5 | 20850 | -0.400 | -0.388 | 1270 | P119 | 2 | 2001 | 5.42592 | 0.0006912 | 0.0576 | 23.443 | 0.1272 | 320
PLATINE | -54 | 61050 | 79235 | -0.060 | -0.048 | 1256 | P14 | 1 | 1001 | 3.73032 | 0.0004752 | 0.0396 | 23.8049 | 0.0888 | 220
PLATINE | -54 | 55850 | 79235 | -0.060 | -0.048 | 1256 | P16 | 1 | 1001 | 3.73032 | 0.0004752 | 0.0396 | 23.8049 | 0.0888 | 220
PLATINE | -394 | 50650 | 79235 | -0.400 | -0.388 | 1256 | P13 | 1 | 1001 | 3.73032 | 0.0004752 | 0.0396 | 23.8049 | 0.0888 | 220
PLATINE | -394 | 45450 | 79235 | -0.400 | -0.388 | 1256 | P13 | 1 | 1001 | 3.73032 | 0.0004752 | 0.0396 | 23.8049 | 0.0888 | 220
PLATINE | -394 | 40250 | 79235 | -0.400 | -0.388 | 1256 | P13 | 1 | 1001 | 3.73032 | 0.0004752 | 0.0396 | 23.8049 | 0.0888 | 220
PLATINE | -394 | 35050 | 79235 | -0.400 | -0.388 | 1256 | P12 | 1 | 1001 | 3.73032 | 0.0004752 | 0.0396 | 23.8049 | 0.0888 | 220
PLATINE | -394 | 29850 | 79235 | -0.400 | -0.388 | 1271 | P11 | 1 | 1011 | 3.73032 | 0.0004752 | 0.0396 | 23.8049 | 0.0888 | 220
PLATINE | -394 | 24650 | 79235 | -0.400 | -0.388 | 1271 | P10 | 1 | 1011 | 3.73032 | 0.0004752 | 0.0396 | 23.8049 | 0.0888 | 220
PLATINE | -394 | 7650 | 79235 | -0.400 | -0.388 | 1277 | P6 | 1 | 1011 | 3.73032 | 0.0004752 | 0.0396 | 23.8049 | 0.0888 | 220
PLATINE | -394 | -76.5 | 79225 | -0.400 | -0.388 | 1270 | P122 | 1 | 1011 | 5.42592 | 0.0006912 | 0.0576 | 23.443 | 0.1272 | 320
PLATINE | -394 | -76.5 | 74420 | -0.400 | -0.388 | 1255 | P117 | 1 | 1001 | 5.42592 | 0.0006912 | 0.0576 | 23.443 | 0.1272 | 320
PLATINE | -394 | -76.5 | 61712.5 | -0.400 | -0.388 | 1255 | P116 | 1 | 1001 | 5.42592 | 0.0006912 | 0.0576 | 23.443 | 0.1272 | 320
PLATINE | -394 | -76.5 | 50037.5 | -0.400 | -0.388 | 1255 | P115 | 1 | 1001 | 5.42592 | 0.0006912 | 0.0576 | 23.443 | 0.1272 | 320
PLATINE | -394 | -76.5 | 38362.5 | -0.400 | -0.388 | 1255 | P114 | 3 | 3001 | 5.42592 | 0.0006912 | 0.0576 | 23.443 | 0.1272 | 320
PLATINE | -394 | -76.5 | 32525 | -0.400 | -0.388 | 1270 | P113 | 3 | 3001 | 5.42592 | 0.0006912 | 0.0576 | 23.443 | 0.1272 | 320
PLATINE | -394 | -76.5 | 28633 | -0.400 | -0.388 | 1270 | P121 | 3 | 3001 | 5.42592 | 0.0006912 | 0.0576 | 23.443 | 0.1272 | 320
PLATINE | -394 | -76.5 | 24742 | -0.400 | -0.388 | 1270 | P120 | 3 | 3001 | 5.42592 | 0.0006912 | 0.0576 | 23.443 | 0.1272 | 320
PLATINE | 6 | 69275 | 73387.5 | +0.000 | +0.012 | 1254 | P18 | 1 | 1001 | 3.73032 | 0.0004752 | 0.0396 | 23.8049 | 0.0888 | 220
PLATINE | -54 | 69275 | 79185 | -0.060 | -0.048 | 1274 | P17 | 1 | 1011 | 3.73032 | 0.0004752 | 0.0396 | 23.8049 | 0.0888 | 220
PLATINE | -54 | 64525 | 79235 | -0.060 | -0.048 | 1256 | P15 | 1 | 1001 | 3.73032 | 0.0004752 | 0.0396 | 23.8049 | 0.0888 | 220
PLATINE | 3634 | 48525 | 0 | +3.628 | +3.640 | 1275 | P127 | 2 | 2001 | 2.71296 | 0.0003456 | 0.0288 | 24.2392 | 0.06576 | 160
PLATINE | 3634 | 10930 | 0 | +3.628 | +3.640 | 1275 | P125 | 2 | 2001 | 2.71296 | 0.0003456 | 0.0288 | 24.2392 | 0.06576 | 160
PLATINE | 3634 | 40250 | 0 | +3.628 | +3.640 | 1275 | P126 | 2 | 2001 | 2.71296 | 0.0003456 | 0.0288 | 24.2392 | 0.06576 | 160
PLATINE | 3634 | 26100 | 0 | +3.628 | +3.640 | 1275 | P125 | 2 | 2001 | 2.71296 | 0.0003456 | 0.0288 | 24.2392 | 0.06576 | 160
PLATINE | 3634 | 18560 | 0 | +3.628 | +3.640 | 1275 | P125 | 2 | 2001 | 2.71296 | 0.0003456 | 0.0288 | 24.2392 | 0.06576 | 160
PLATINE | 3208.67 | 40250 | 9295 | +3.203 | +3.215 | 1276 | P124 | 2 | 2001 | 3.05208 | 0.0003888 | 0.0324 | 24.0623 | 0.07344 | 180
PLATINE | 3208.67 | 29575 | 9295 | +3.203 | +3.215 | 1276 | P124 | 2 | 2001 | 3.05208 | 0.0003888 | 0.0324 | 24.0623 | 0.07344 | 180
PLATINE | 3208.67 | 19450 | 9295 | +3.203 | +3.215 | 1276 | P124 | 2 | 2001 | 3.05208 | 0.0003888 | 0.0324 | 24.0623 | 0.07344 | 180

# IfcBeam: PL12*200 (8)
In: Undefined
Description: PL12*200; Material: STEEL/E24-2
Tekla Common - Center of gravity Z: -394 mm; Bottom elevation: -0.400; Top elevation: -0.388; Phase: 2; Finish: GRENAILLE-PEINT; Grade: E24-2; Profile: PL12*200; Name: PLATINE; sets with these values: 2
Tekla Quantity - Net weight: 3.768 kg; Gross weight: 3.768 kg; Weight: 3.768 kg; Net volume: 0.00048 m3; Gross volume: 0.00048 m3; Gross footprint area: 0.04 m2; Area per tons: 23.7792 m2; Net surface area: 0.0896 m2; Gross area: 0.0896 m2; Height: 200 mm; Width: 12 mm; Length: 200 mm; sets with these values: 2
BaseQuantities - Length: 200 mm; OuterSurfaceArea: 0.0896 m2; NetVolume: 0.00048 m3; NetWeight: 3.768 kg
Name | Center of gravity Y (mm) | Center of gravity X (mm) | Part mark | Assembly mark | Class
PLATINE | 18560 | 0 | 1273 | P125 | 2001
PLATINE | 26100 | 0 | 1273 | P125 | 2001
PLATINE | 40250 | -1.42109e-14 | 1278 | P126 | 2001
PLATINE | 48525 | -1.42109e-14 | 1278 | P127 | 2001
PLATINE | 10930 | 0 | 1273 | P125 | 2001
PLATINE | 48525 | 9295 | 1278 | P128 | 2001
PLATINE | 10215 | 720 | 1280 | P131 | 2003
PLATINE | 10215 | 8810 | 1280 | P130 | 2003

# IfcBeam: PL12*220, PLATINE
In: Undefined
Description: PL12*220; Material: STEEL/E24-2
Tekla Common - Center of gravity Z: 3494 mm; Center of gravity Y: 26050 mm; Center of gravity X: 71815 mm; Bottom elevation: +3.488; Top elevation: +3.500; Part mark: 1265; Assembly mark: P118; Phase: 1; Class: 1011; Finish: GRENAILLE-PEINT; Grade: E24-2; Profile: PL12*220; Name: PLATINE; sets with these values: 2
Tekla Quantity - Net weight: 4.76652 kg; Gross weight: 4.76652 kg; Weight: 4.76652 kg; Net volume: 0.0006072 m3; Gross volume: 0.0006072 m3; Gross footprint area: 0.0506 m2; Area per tons: 23.4972 m2; Net surface area: 0.112 m2; Gross area: 0.112 m2; Height: 220 mm; Width: 12 mm; Length: 230 mm; sets with these values: 2
BaseQuantities - Length: 230 mm; OuterSurfaceArea: 0.112 m2; NetVolume: 0.0006072 m3; NetWeight: 4.76652 kg

# IfcBeam: PL12*250 (6)
In: Undefined
Description: PL12*250; Material: STEEL/E24-2
Tekla Common - Center of gravity Z: -394 mm; Bottom elevation: -0.400; Top elevation: -0.388; Finish: GRENAILLE-PEINT; Grade: E24-2; Profile: PL12*250; Name: PLATINE; sets with these values: 2
Tekla Quantity - Net weight: 5.4165 kg; Gross weight: 5.4165 kg; Weight: 5.4165 kg; Net volume: 0.00069 m3; Gross volume: 0.00069 m3; Gross footprint area: 0.0575 m2; Area per tons: 23.3583 m2; Net surface area: 0.12652 m2; Gross area: 0.12652 m2; Height: 250 mm; Width: 12 mm; Length: 230 mm; sets with these values: 2
BaseQuantities - Length: 230 mm; OuterSurfaceArea: 0.12652 m2; NetVolume: 0.00069 m3; NetWeight: 5.4165 kg
Name | Center of gravity Y (mm) | Center of gravity X (mm) | Part mark | Assembly mark | Phase | Class
PLATINE | 13550 | 71815 | 1272 | P123 | 1 | 1011
PLATINE | 26050 | 71815 | 1272 | P118 | 1 | 1011
PLATINE | 19450 | 9295 | 1272 | P124 | 2 | 2001
PLATINE | 29575 | 9295 | 1272 | P124 | 2 | 2001
PLATINE | 40250 | 9295 | 1272 | P124 | 2 | 2001
PLATINE | 10930 | 9295 | 1279 | P129 | 2 | 2001

# IfcBeam: PL12*80, PLATINE
In: Undefined
Description: PL12*80; Material: STEEL/E24-2
Tekla Common - Center of gravity Z: 5580.87 mm; Center of gravity Y: 61060.3 mm; Center of gravity X: 32825 mm; Bottom elevation: +5.421; Top elevation: +5.741; Part mark: H77; Assembly mark: H77; Phase: 3; Class: 3005; Finish: GRENAILLE-PEINT; Grade: E24-2; Profile: PL12*80; Name: PLATINE; sets with these values: 2
Tekla Quantity - Net weight: 2.41152 kg; Gross weight: 2.41152 kg; Weight: 2.41152 kg; Net volume: 0.0003072 m3; Gross volume: 0.0003072 m3; Gross footprint area: 0.00096 m2; Area per tons: 25.2123 m2; Net surface area: 0.0608 m2; Gross area: 0.0608 m2; Height: 80 mm; Width: 12 mm; Length: 320 mm; sets with these values: 2
BaseQuantities - Length: 320 mm; OuterSurfaceArea: 0.0608 m2; NetVolume: 0.0003072 m3; NetWeight: 2.41152 kg

# IfcBeam: PL120*10 (25)
In: Undefined
Description: PL120*10; Material: STEEL/E24-2
Tekla Common - Finish: GRENAILLE-PEINT; Grade: E24-2; Profile: PL120*10; sets with these values: 2
Tekla Quantity - Height: 120 mm; Width: 10 mm; sets with these values: 2
Name | Center of gravity Z (mm) | Center of gravity Y (mm) | Center of gravity X (mm) | Bottom elevation | Top elevation | Part mark | Assembly mark | Phase | Class | Net weight (kg) = Gross weight (kg) = Weight (kg) = NetWeight (kg) | Net volume (m3) = Gross volume (m3) = NetVolume (m3) | Gross footprint area (m2) | Area per tons (m2) | Net surface area (m2) = Gross area (m2) = OuterSurfaceArea (m2) | Tekla Quantity, Length (mm) = BaseQuantities, Length (mm) | Name
 | 3191.61 | -587.368 | 20689.9 | +3.062 | +3.322 | 228 | K94 | 3 | 3003 | 2.44965 | 0.000312058 | 0.0012 | 28.5806 | 0.0700125 | 260.048
PLAT | 3464.67 | 10031 | 9235 | +3.225 | +3.705 | 293 | N4 | 2 | 2006 | 4.5216 | 0.000576 | 0.0012 | 28.1316 | 0.1272 | 480 | PLAT
PLAT | 3840 | 10031 | -1.02131e-15 | +3.650 | +4.030 | 294 | N20 | 2 | 2006 | 3.5796 | 0.000456 | 0.0012 | 28.2713 | 0.1012 | 380 | PLAT
PLAT | 3840 | 10930 | -105 | +3.650 | +4.030 | 294 | L118 | 2 | 2003 | 3.5796 | 0.000456 | 0.0012 | 28.2713 | 0.1012 | 380 | PLAT
PLAT | 3840 | 10930 | -95 | +3.650 | +4.030 | 294 | N20 | 2 | 2006 | 3.5796 | 0.000456 | 0.0012 | 28.2713 | 0.1012 | 380 | PLAT
PLAT | 3840 | 13060 | -105 | +3.650 | +4.030 | 294 | L118 | 2 | 2003 | 3.5796 | 0.000456 | 0.0012 | 28.2713 | 0.1012 | 380 | PLAT
PLAT | 3840 | 13060 | -95 | +3.650 | +4.030 | 294 | N20 | 2 | 2006 | 3.5796 | 0.000456 | 0.0012 | 28.2713 | 0.1012 | 380 | PLAT
PLAT | 3840 | 15190 | -105 | +3.650 | +4.030 | 294 | L118 | 2 | 2003 | 3.5796 | 0.000456 | 0.0012 | 28.2713 | 0.1012 | 380 | PLAT
PLAT | 3840 | 15190 | -95 | +3.650 | +4.030 | 294 | N20 | 2 | 2006 | 3.5796 | 0.000456 | 0.0012 | 28.2713 | 0.1012 | 380 | PLAT
PLAT | 3840 | 17320 | -105 | +3.650 | +4.030 | 294 | L118 | 2 | 2003 | 3.5796 | 0.000456 | 0.0012 | 28.2713 | 0.1012 | 380 | PLAT
PLAT | 3840 | 17320 | -95 | +3.650 | +4.030 | 294 | N20 | 2 | 2006 | 3.5796 | 0.000456 | 0.0012 | 28.2713 | 0.1012 | 380 | PLAT
PLAT | 3840 | 19450 | -105 | +3.650 | +4.030 | 294 | L118 | 2 | 2003 | 3.5796 | 0.000456 | 0.0012 | 28.2713 | 0.1012 | 380 | PLAT
PLAT | 3840 | 19450 | -95 | +3.650 | +4.030 | 294 | N19 | 2 | 2006 | 3.5796 | 0.000456 | 0.0012 | 28.2713 | 0.1012 | 380 | PLAT
