Properties of the parts of a building model (IFC2X3), part 15 of 32

# IfcBeam: PL60*8 (225)
Name | Material | Center of gravity Z (mm) | Center of gravity Y (mm) | Center of gravity X (mm) | Bottom elevation | Top elevation | Part mark | Assembly mark | Phase | Class | Grade | Name | Net weight (kg) = Gross weight (kg) = Weight (kg) = NetWeight (kg) | Net volume (m3) = Gross volume (m3) = NetVolume (m3) | Gross footprint area (m2) | Area per tons (m2) | Net surface area (m2) = Gross area (m2) = OuterSurfaceArea (m2) | Tekla Quantity, Length (mm) = BaseQuantities, Length (mm)
CALE | STEEL/E24-2 | 5096.74 | 130.036 | 74282 | +5.066 | +5.127 | Y2 | Y2 | 1 | 1009 | E24-2 | CALE | 0.22608 | 0.0000288 | 0 | 40.3397 | 0.00912 | 60
CALE | STEEL/E24-2 | 5111.77 | 585.456 | 73797.1 | +5.081 | +5.143 | Y2 | Y2 | 1 | 1009 | E24-2 | CALE | 0.22608 | 0.0000288 | 0 | 40.3397 | 0.00912 | 60
CALE | STEEL/E24-2 | 5126.68 | 1037.17 | 73316.1 | +5.096 | +5.157 | Y2 | Y2 | 1 | 1009 | E24-2 | CALE | 0.22608 | 0.0000288 | 0 | 40.3397 | 0.00912 | 60
CALE | STEEL/E24-2 | 5141.59 | 1488.88 | 72835.1 | +5.111 | +5.172 | Y2 | Y2 | 1 | 1009 | E24-2 | CALE | 0.22608 | 0.0000288 | 0 | 40.3397 | 0.00912 | 60
CALE | STEEL/E24-2 | 5171.53 | 2396.01 | 71869.2 | +5.141 | +5.202 | Y2 | Y2 | 1 | 1009 | E24-2 | CALE | 0.22608 | 0.0000288 | 0 | 40.3397 | 0.00912 | 60
CALE | STEEL/E24-2 | 5156.5 | 1940.59 | 72354.1 | +5.126 | +5.187 | Y2 | Y2 | 1 | 1009 | E24-2 | CALE | 0.22608 | 0.0000288 | 0 | 40.3397 | 0.00912 | 60
CALE | STEEL/E24-2 | 4802.76 | 67215 | 61712.5 | +4.795 | +4.810 | Y2 | Y2 | 1 | 1004 | E24-2 | CALE | 0.22608 | 0.0000288 | 0 | 40.3397 | 0.00912 | 60
CALE | STEEL/E24-2 | 4802.76 | 67800 | 61712.5 | +4.795 | +4.810 | Y2 | Y2 | 1 | 1004 | E24-2 | CALE | 0.22608 | 0.0000288 | 0 | 40.3397 | 0.00912 | 60
CALE | STEEL/E24-2 | 4802.76 | 68385 | 61712.5 | +4.795 | +4.810 | Y2 | Y2 | 1 | 1004 | E24-2 | CALE | 0.22608 | 0.0000288 | 0 | 40.3397 | 0.00912 | 60
CALE | STEEL/E24-2 | 4802.76 | 725 | 61712.5 | +4.795 | +4.810 | Y2 | Y2 | 1 | 1004 | E24-2 | CALE | 0.22608 | 0.0000288 | 0 | 40.3397 | 0.00912 | 60
CALE | STEEL/E24-2 | 4802.76 | 1275 | 61712.5 | +4.795 | +4.810 | Y2 | Y2 | 1 | 1004 | E24-2 | CALE | 0.22608 | 0.0000288 | 0 | 40.3397 | 0.00912 | 60
CALE | STEEL/E24-2 | 4802.76 | 1825 | 61712.5 | +4.795 | +4.810 | Y2 | Y2 | 1 | 1004 | E24-2 | CALE | 0.22608 | 0.0000288 | 0 | 40.3397 | 0.00912 | 60
CALE | STEEL/E24-2 | 4802.76 | 4375 | 61712.5 | +4.795 | +4.810 | Y2 | Y2 | 1 | 1004 | E24-2 | CALE | 0.22608 | 0.0000288 | 0 | 40.3397 | 0.00912 | 60
CALE | STEEL/E24-2 | 4802.76 | 3275 | 61712.5 | +4.795 | +4.810 | Y2 | Y2 | 1 | 1004 | E24-2 | CALE | 0.22608 | 0.0000288 | 0 | 40.3397 | 0.00912 | 60
CALE | STEEL/E24-2 | 4802.76 | 3825 | 61712.5 | +4.795 | +4.810 | Y2 | Y2 | 1 | 1004 | E24-2 | CALE | 0.22608 | 0.0000288 | 0 | 40.3397 | 0.00912 | 60
CALE | STEEL/E24-2 | 4802.76 | 65685 | 61712.5 | +4.795 | +4.810 | Y2 | Y2 | 1 | 1004 | E24-2 | CALE | 0.22608 | 0.0000288 | 0 | 40.3397 | 0.00912 | 60
CALE | STEEL/E24-2 | 4802.76 | 64515 | 61712.5 | +4.795 | +4.810 | Y2 | Y2 | 1 | 1004 | E24-2 | CALE | 0.22608 | 0.0000288 | 0 | 40.3397 | 0.00912 | 60
CALE | STEEL/E24-2 | 4802.76 | 65100 | 61712.5 | +4.795 | +4.810 | Y2 | Y2 | 1 | 1004 | E24-2 | CALE | 0.22608 | 0.0000288 | 0 | 40.3397 | 0.00912 | 60
CALE | STEEL/E24-2 | 4802.76 | 3275 | 50037.5 | +4.795 | +4.810 | Y2 | Y2 | 1 | 1004 | E24-2 | CALE | 0.22608 | 0.0000288 | 0 | 40.3397 | 0.00912 | 60
CALE | STEEL/E24-2 | 4802.76 | 64515 | 50037.5 | +4.795 | +4.810 | Y2 | Y2 | 1 | 1004 | E24-2 | CALE | 0.22608 | 0.0000288 | 0 | 40.3397 | 0.00912 | 60
CALE | STEEL/E24-2 | 4802.76 | 68385 | 50037.5 | +4.795 | +4.810 | Y2 | Y2 | 1 | 1004 | E24-2 | CALE | 0.22608 | 0.0000288 | 0 | 40.3397 | 0.00912 | 60
CALE | STEEL/E24-2 | 4802.76 | 67800 | 50037.5 | +4.795 | +4.810 | Y2 | Y2 | 1 | 1004 | E24-2 | CALE | 0.22608 | 0.0000288 | 0 | 40.3397 | 0.00912 | 60
CALE | STEEL/E24-2 | 4802.76 | 67215 | 50037.5 | +4.795 | +4.810 | Y2 | Y2 | 1 | 1004 | E24-2 | CALE | 0.22608 | 0.0000288 | 0 | 40.3397 | 0.00912 | 60
CALE | STEEL/E24-2 | 4802.76 | 1825 | 50037.5 | +4.795 | +4.810 | Y2 | Y2 | 1 | 1004 | E24-2 | CALE | 0.22608 | 0.0000288 | 0 | 40.3397 | 0.00912 | 60
CALE | STEEL/E24-2 | 4802.76 | 1275 | 50037.5 | +4.795 | +4.810 | Y2 | Y2 | 1 | 1004 | E24-2 | CALE | 0.22608 | 0.0000288 | 0 | 40.3397 | 0.00912 | 60
CALE | STEEL/E24-2 | 4802.76 | 725 | 50037.5 | +4.795 | +4.810 | Y2 | Y2 | 1 | 1004 | E24-2 | CALE | 0.22608 | 0.0000288 | 0 | 40.3397 | 0.00912 | 60
CALE | STEEL/E24-2 | 4802.76 | 725 | 38362.5 | +4.795 | +4.810 | Y2 | Y2 | 3 | 3004 | E24-2 | CALE | 0.22608 | 0.0000288 | 0 | 40.3397 | 0.00912 | 60
CALE | STEEL/E24-2 | 4802.76 | 65100 | 50037.5 | +4.795 | +4.810 | Y2 | Y2 | 1 | 1004 | E24-2 | CALE | 0.22608 | 0.0000288 | 0 | 40.3397 | 0.00912 | 60
CALE | STEEL/E24-2 | 4802.76 | 65685 | 50037.5 | +4.795 | +4.810 | Y2 | Y2 | 1 | 1004 | E24-2 | CALE | 0.22608 | 0.0000288 | 0 | 40.3397 | 0.00912 | 60
CALE | STEEL/E24-2 | 4802.76 | 3825 | 50037.5 | +4.795 | +4.810 | Y2 | Y2 | 1 | 1004 | E24-2 | CALE | 0.22608 | 0.0000288 | 0 | 40.3397 | 0.00912 | 60
CALE | STEEL/E24-2 | 4802.76 | 4375 | 50037.5 | +4.795 | +4.810 | Y2 | Y2 | 1 | 1004 | E24-2 | CALE | 0.22608 | 0.0000288 | 0 | 40.3397 | 0.00912 | 60
CALE | STEEL/E24-2 | 531.359 | 69150 | 53871.9 | +0.492 | +0.571 | Y2 | Y2 | 1 | 1002 | E24-2 | CALE | 0.22608 | 0.0000288 | 0 | 40.3397 | 0.00912 | 60
CALE | STEEL/E24-2 | 255.149 | 69150 | 54482.3 | +0.215 | +0.295 | Y2 | Y2 | 1 | 1002 | E24-2 | CALE | 0.22608 | 0.0000288 | 0 | 40.3397 | 0.00912 | 60
CALE | STEEL/E24-2 | 4802.76 | 3825 | 38362.5 | +4.795 | +4.810 | Y2 | Y2 | 3 | 3004 | E24-2 | CALE | 0.22608 | 0.0000288 | 0 | 40.3397 | 0.00912 | 60
CALE | STEEL/E24-2 | 4802.76 | 3275 | 38362.5 | +4.795 | +4.810 | Y2 | Y2 | 3 | 3004 | E24-2 | CALE | 0.22608 | 0.0000288 | 0 | 40.3397 | 0.00912 | 60
CALE | STEEL/E24-2 | 4802.76 | 4375 | 38362.5 | +4.795 | +4.810 | Y2 | Y2 | 3 | 3004 | E24-2 | CALE | 0.22608 | 0.0000288 | 0 | 40.3397 | 0.00912 | 60
CALE | STEEL/E24-2 | 4802.76 | 1825 | 38362.5 | +4.795 | +4.810 | Y2 | Y2 | 3 | 3004 | E24-2 | CALE | 0.22608 | 0.0000288 | 0 | 40.3397 | 0.00912 | 60
CALE | STEEL/E24-2 | 4802.76 | 1275 | 38362.5 | +4.795 | +4.810 | Y2 | Y2 | 3 | 3004 | E24-2 | CALE | 0.22608 | 0.0000288 | 0 | 40.3397 | 0.00912 | 60
CALE | STEEL/E24-2 | 4802.76 | 1825 | 26687.5 | +4.795 | +4.810 | Y2 | Y2 | 3 | 3004 | E24-2 | CALE | 0.22608 | 0.0000288 | 0 | 40.3397 | 0.00912 | 60
CALE | STEEL/E24-2 | 4802.76 | 725 | 26687.5 | +4.795 | +4.810 | Y2 | Y2 | 3 | 3004 | E24-2 | CALE | 0.22608 | 0.0000288 | 0 | 40.3397 | 0.00912 | 60
CALE | STEEL/E24-2 | 4802.76 | 3275 | 26687.5 | +4.795 | +4.810 | Y2 | Y2 | 3 | 3004 | E24-2 | CALE | 0.22608 | 0.0000288 | 0 | 40.3397 | 0.00912 | 60
CALE | STEEL/E24-2 | 4802.76 | 1275 | 26687.5 | +4.795 | +4.810 | Y2 | Y2 | 3 | 3004 | E24-2 | CALE | 0.22608 | 0.0000288 | 0 | 40.3397 | 0.00912 | 60
CALE | STEEL/E24-2 | 4802.76 | 3825 | 26687.5 | +4.795 | +4.810 | Y2 | Y2 | 3 | 3004 | E24-2 | CALE | 0.22608 | 0.0000288 | 0 | 40.3397 | 0.00912 | 60
CALE | STEEL/E24-2 | 4802.76 | 61815 | 73387.5 | +4.795 | +4.810 | Y2 | Y2 | 1 | 1004 | E24-2 | CALE | 0.22608 | 0.0000288 | 0 | 40.3397 | 0.00912 | 60
CALE | STEEL/E24-2 | 4802.76 | 65685 | 73387.5 | +4.795 | +4.810 | Y2 | Y2 | 1 | 1004 | E24-2 | CALE | 0.22608 | 0.0000288 | 0 | 40.3397 | 0.00912 | 60
CALE | STEEL/E24-2 | 4802.76 | 64515 | 73387.5 | +4.795 | +4.810 | Y2 | Y2 | 1 | 1004 | E24-2 | CALE | 0.22608 | 0.0000288 | 0 | 40.3397 | 0.00912 | 60
CALE | STEEL/E24-2 | 4802.76 | 67215 | 73387.5 | +4.795 | +4.810 | Y2 | Y2 | 1 | 1004 | E24-2 | CALE | 0.22608 | 0.0000288 | 0 | 40.3397 | 0.00912 | 60
CALE | STEEL/E24-2 | 4802.76 | 67800 | 73387.5 | +4.795 | +4.810 | Y2 | Y2 | 1 | 1004 | E24-2 | CALE | 0.22608 | 0.0000288 | 0 | 40.3397 | 0.00912 | 60
CALE | STEEL/E24-2 | 4802.76 | 68385 | 73387.5 | +4.795 | +4.810 | Y2 | Y2 | 1 | 1004 | E24-2 | CALE | 0.22608 | 0.0000288 | 0 | 40.3397 | 0.00912 | 60
CALE | STEEL/E24-2 | 5010.2 | 6925 | 71700.1 | +5.005 | +5.015 | Y2 | Y2 | 1 | 1009 | E24-2 | CALE | 0.22608 | 0.0000288 | 0 | 40.3397 | 0.00912 | 60
CALE | STEEL/E24-2 | 5010.2 | 6375 | 71700.1 | +5.005 | +5.015 | Y2 | Y2 | 1 | 1009 | E24-2 | CALE | 0.22608 | 0.0000288 | 0 | 40.3397 | 0.00912 | 60
CALE | STEEL/E24-2 | 5010.2 | 5825 | 71700.1 | +5.005 | +5.015 | Y2 | Y2 | 1 | 1009 | E24-2 | CALE | 0.22608 | 0.0000288 | 0 | 40.3397 | 0.00912 | 60
CALE | STEEL/E24-2 | 5010.2 | 9380 | 71700.1 | +5.005 | +5.015 | Y2 | Y2 | 1 | 1009 | E24-2 | CALE | 0.22608 | 0.0000288 | 0 | 40.3397 | 0.00912 | 60
CALE | STEEL/E24-2 | 5010.2 | 8830 | 71700.1 | +5.005 | +5.015 | Y2 | Y2 | 1 | 1009 | E24-2 | CALE | 0.22608 | 0.0000288 | 0 | 40.3397 | 0.00912 | 60
CALE | STEEL/E24-2 | 5010.2 | 8280 | 71700.1 | +5.005 | +5.015 | Y2 | Y2 | 1 | 1009 | E24-2 | CALE | 0.22608 | 0.0000288 | 0 | 40.3397 | 0.00912 | 60
CALE | STEEL/E24-2 | 5010.2 | 11740 | 71700.1 | +5.005 | +5.015 | Y2 | Y2 | 1 | 1009 | E24-2 | CALE | 0.22608 | 0.0000288 | 0 | 40.3397 | 0.00912 | 60
CALE | STEEL/E24-2 | 5010.2 | 11190 | 71700.1 | +5.005 | +5.015 | Y2 | Y2 | 1 | 1009 | E24-2 | CALE | 0.22608 | 0.0000288 | 0 | 40.3397 | 0.00912 | 60
CALE | STEEL/E24-2 | 5010.2 | 10640 | 71700.1 | +5.005 | +5.015 | Y2 | Y2 | 1 | 1009 | E24-2 | CALE | 0.22608 | 0.0000288 | 0 | 40.3397 | 0.00912 | 60
CALE | STEEL/E24-2 | 5029.11 | 13200 | 71090 | +5.024 | +5.034 | Y2 | Y2 | 1 | 1009 | E24-2 | CALE | 0.22608 | 0.0000288 | 0 | 40.3397 | 0.00912 | 60
CALE | STEEL/E24-2 | 5047.26 | 12864.2 | 70504.8 | +5.042 | +5.053 | Y2 | Y2 | 1 | 1009 | E24-2 | CALE | 0.22608 | 0.0000288 | 0 | 40.3397 | 0.00912 | 60
CALE | STEEL/E24-2 | 5010.2 | 16460 | 71700.1 | +5.005 | +5.015 | Y2 | Y2 | 1 | 1009 | E24-2 | CALE | 0.22608 | 0.0000288 | 0 | 40.3397 | 0.00912 | 60
CALE | STEEL/E24-2 | 5010.2 | 15910 | 71700.1 | +5.005 | +5.015 | Y2 | Y2 | 1 | 1009 | E24-2 | CALE | 0.22608 | 0.0000288 | 0 | 40.3397 | 0.00912 | 60
CALE | STEEL/E24-2 | 5010.2 | 15360 | 71700.1 | +5.005 | +5.015 | Y2 | Y2 | 1 | 1009 | E24-2 | CALE | 0.22608 | 0.0000288 | 0 | 40.3397 | 0.00912 | 60
CALE | STEEL/E24-2 | 5010.2 | 18820 | 71700.1 | +5.005 | +5.015 | Y2 | Y2 | 1 | 1009 | E24-2 | CALE | 0.22608 | 0.0000288 | 0 | 40.3397 | 0.00912 | 60
CALE | STEEL/E24-2 | 5010.2 | 18270 | 71700.1 | +5.005 | +5.015 | Y2 | Y2 | 1 | 1009 | E24-2 | CALE | 0.22608 | 0.0000288 | 0 | 40.3397 | 0.00912 | 60
CALE | STEEL/E24-2 | 5010.2 | 17720 | 71700.1 | +5.005 | +5.015 | Y2 | Y2 | 1 | 1009 | E24-2 | CALE | 0.22608 | 0.0000288 | 0 | 40.3397 | 0.00912 | 60
CALE | STEEL/E24-2 | 5064.12 | -5.51647e-17 | 45024.7 | +5.023 | +5.105 | Y2 | Y2 | 1 | 1002 | E24-2 | CALE | 0.22608 | 0.0000288 | 0 | 40.3397 | 0.00912 | 60
CALE | STEEL/E24-2 | 4735.09 | -1.8132e-16 | 45625.5 | +4.694 | +4.776 | Y2 | Y2 | 1 | 1002 | E24-2 | CALE | 0.22608 | 0.0000288 | 0 | 40.3397 | 0.00912 | 60
CALE | STEEL/E24-2 | 4406.06 | 7.14784e-17 | 46226.3 | +4.365 | +4.447 | Y2 | Y2 | 1 | 1002 | E24-2 | CALE | 0.22608 | 0.0000288 | 0 | 40.3397 | 0.00912 | 60
CALE | STEEL/E24-2 | 4077.03 | 7.16406e-17 | 46827.1 | +4.036 | +4.118 | Y2 | Y2 | 1 | 1002 | E24-2 | CALE | 0.22608 | 0.0000288 | 0 | 40.3397 | 0.00912 | 60
CALE | STEEL/E24-2 | 3748 | 7.18019e-17 | 47427.9 | +3.707 | +3.789 | Y2 | Y2 | 1 | 1002 | E24-2 | CALE | 0.22608 | 0.0000288 | 0 | 40.3397 | 0.00912 | 60
CALE | STEEL/E24-2 | 3418.97 | 7.19645e-17 | 48028.7 | +3.378 | +3.460 | Y2 | Y2 | 1 | 1002 | E24-2 | CALE | 0.22608 | 0.0000288 | 0 | 40.3397 | 0.00912 | 60
CALE | STEEL/E24-2 | 3089.94 | 7.21263e-17 | 48629.5 | +3.049 | +3.131 | Y2 | Y2 | 1 | 1002 | E24-2 | CALE | 0.22608 | 0.0000288 | 0 | 40.3397 | 0.00912 | 60
CALE | STEEL/E24-2 | 2760.91 | 7.22873e-17 | 49230.3 | +2.720 | +2.802 | Y2 | Y2 | 1 | 1002 | E24-2 | CALE | 0.22608 | 0.0000288 | 0 | 40.3397 | 0.00912 | 60
CALE | STEEL/E24-2 | 5008.89 | 20190 | 71699.9 | +5.001 | +5.016 | Y2 | Y2 | 1 | 1009 | E24-2 | CALE | 0.22608 | 0.0000288 | 0 | 40.3397 | 0.00912 | 60
CALE | STEEL/E24-2 | 5008.89 | 20750 | 71699.9 | +5.001 | +5.016 | Y2 | Y2 | 1 | 1009 | E24-2 | CALE | 0.22608 | 0.0000288 | 0 | 40.3397 | 0.00912 | 60
CALE | STEEL/E24-2 | 5008.89 | 21310 | 71699.9 | +5.001 | +5.016 | Y2 | Y2 | 1 | 1009 | E24-2 | CALE | 0.22608 | 0.0000288 | 0 | 40.3397 | 0.00912 | 60
CALE | STEEL/E24-2 | 5008.89 | 23910 | 71699.9 | +5.001 | +5.016 | Y2 | Y2 | 1 | 1009 | E24-2 | CALE | 0.22608 | 0.0000288 | 0 | 40.3397 | 0.00912 | 60
CALE | STEEL/E24-2 | 5008.89 | 23350 | 71699.9 | +5.001 | +5.016 | Y2 | Y2 | 1 | 1009 | E24-2 | CALE | 0.22608 | 0.0000288 | 0 | 40.3397 | 0.00912 | 60
CALE | STEEL/E24-2 | 5008.89 | 22790 | 71699.9 | +5.001 | +5.016 | Y2 | Y2 | 1 | 1009 | E24-2 | CALE | 0.22608 | 0.0000288 | 0 | 40.3397 | 0.00912 | 60
CALE | STEEL/E24-2 | 4802.76 | 65100 | 73387.5 | +4.795 | +4.810 | Y2 | Y2 | 1 | 1004 | E24-2 | CALE | 0.22608 | 0.0000288 | 0 | 40.3397 | 0.00912 | 60
CALE | STEEL/E24-2 | 2551.93 | 69150 | 50951.8 | +2.514 | +2.590 | Y2 | Y2 | 1 | 1002 | E24-2 | CALE | 0.22608 | 0.0000288 | 0 | 40.3397 | 0.00912 | 60
CALE | STEEL/E24-2 | 2760.64 | 69150 | 51619.9 | +2.723 | +2.798 | Y2 | Y2 | 1 | 1002 | E24-2 | CALE | 0.22608 | 0.0000288 | 0 | 40.3397 | 0.00912 | 60
CALE | STEEL/E24-2 | 2969.35 | 69150 | 52288.1 | +2.932 | +3.007 | Y2 | Y2 | 1 | 1002 | E24-2 | CALE | 0.22608 | 0.0000288 | 0 | 40.3397 | 0.00912 | 60
CALE | STEEL/E24-2 | 3178.06 | 69150 | 52956.3 | +3.140 | +3.216 | Y2 | Y2 | 1 | 1002 | E24-2 | CALE | 0.22608 | 0.0000288 | 0 | 40.3397 | 0.00912 | 60
CALE | STEEL/E24-2 | 3595.48 | 69150 | 54292.6 | +3.558 | +3.633 | Y2 | Y2 | 1 | 1002 | E24-2 | CALE | 0.22608 | 0.0000288 | 0 | 40.3397 | 0.00912 | 60
CALE | STEEL/E24-2 | 3804.19 | 69150 | 54960.7 | +3.767 | +3.842 | Y2 | Y2 | 1 | 1002 | E24-2 | CALE | 0.22608 | 0.0000288 | 0 | 40.3397 | 0.00912 | 60
CALE | STEEL/E24-2 | -21.0609 | 69150 | 55092.7 | -0.061 | +0.019 | Y2 | Y2 | 1 | 1002 | E24-2 | CALE | 0.22608 | 0.0000288 | 0 | 40.3397 | 0.00912 | 60
CALE | STEEL/E24-2 | 3386.77 | 69150 | 53624.4 | +3.349 | +3.424 | Y2 | Y2 | 1 | 1002 | E24-2 | CALE | 0.22608 | 0.0000288 | 0 | 40.3397 | 0.00912 | 60
CALE | STEEL/E24-2 | 5264.56 | 33170 | 69606.7 | +5.257 | +5.272 | Y2 | Y2 | 1 | 1009 | E24-2 | CALE | 0.22608 | 0.0000288 | 0 | 40.3397 | 0.00912 | 60
CALE | STEEL/E24-2 | 5264.56 | 33755 | 69606.7 | +5.257 | +5.272 | Y2 | Y2 | 1 | 1009 | E24-2 | CALE | 0.22608 | 0.0000288 | 0 | 40.3397 | 0.00912 | 60
CALE | STEEL/E24-2 | 5264.56 | 34340 | 69606.7 | +5.257 | +5.272 | Y2 | Y2 | 1 | 1009 | E24-2 | CALE | 0.22608 | 0.0000288 | 0 | 40.3397 | 0.00912 | 60
CALE | STEEL/E24-2 | 5245.22 | 25390 | 69765 | +5.238 | +5.253 | Y2 | Y2 | 1 | 1009 | E24-2 | CALE | 0.22608 | 0.0000288 | 0 | 40.3397 | 0.00912 | 60
CALE | STEEL/E24-2 | 5245.22 | 25950 | 69765 | +5.238 | +5.253 | Y2 | Y2 | 1 | 1009 | E24-2 | CALE | 0.22608 | 0.0000288 | 0 | 40.3397 | 0.00912 | 60
CALE | STEEL/E24-2 | 5245.22 | 26510 | 69765 | +5.238 | +5.253 | Y2 | Y2 | 1 | 1009 | E24-2 | CALE | 0.22608 | 0.0000288 | 0 | 40.3397 | 0.00912 | 60
CALE | STEEL/E24-2 | 4833.39 | 2109.92 | 77403.7 | +4.828 | +4.838 | Y2 | Y2 | 1 | 1009 | E24-2 | CALE | 0.22608 | 0.0000288 | 0 | 40.3397 | 0.00912 | 60
CALE | STEEL/E24-2 | 4814.54 | 1989.78 | 78011.7 | +4.809 | +4.820 | Y2 | Y2 | 1 | 1009 | E24-2 | CALE | 0.22608 | 0.0000288 | 0 | 40.3397 | 0.00912 | 60
CALE | STEEL/E24-2 | 4795.7 | 1869.64 | 78619.6 | +4.791 | +4.801 | Y2 | Y2 | 1 | 1009 | E24-2 | CALE | 0.22608 | 0.0000288 | 0 | 40.3397 | 0.00912 | 60
CALE | STEEL/E24-2 | 4852.24 | 2230.06 | 76795.7 | +4.847 | +4.857 | Y2 | Y2 | 1 | 1009 | E24-2 | CALE | 0.22608 | 0.0000288 | 0 | 40.3397 | 0.00912 | 60
CALE | STEEL/E24-2 | 4871.08 | 2350.2 | 76187.8 | +4.866 | +4.876 | Y2 | Y2 | 1 | 1009 | E24-2 | CALE | 0.22608 | 0.0000288 | 0 | 40.3397 | 0.00912 | 60
CALE | STEEL/E24-2 | 3582.99 | 24344.5 | 77392.1 | +3.578 | +3.588 | Y2 | Y2 | 1 | 1009 | E24-2 | CALE | 0.22608 | 0.0000288 | 0 | 40.3397 | 0.00912 | 60
CALE | STEEL/E24-2 | 3564.04 | 24446.4 | 78003.4 | +3.559 | +3.569 | Y2 | Y2 | 1 | 1009 | E24-2 | CALE | 0.22608 | 0.0000288 | 0 | 40.3397 | 0.00912 | 60
CALE | STEEL/E24-2 | 3545.09 | 24548.3 | 78614.7 | +3.540 | +3.550 | Y2 | Y2 | 1 | 1009 | E24-2 | CALE | 0.22608 | 0.0000288 | 0 | 40.3397 | 0.00912 | 60
CALE | STEEL/E24-2 | 3601.94 | 24242.6 | 76780.8 | +3.597 | +3.607 | Y2 | Y2 | 1 | 1009 | E24-2 | CALE | 0.22608 | 0.0000288 | 0 | 40.3397 | 0.00912 | 60
CALE | STEEL/E24-2 | 3620.89 | 24140.8 | 76169.6 | +3.616 | +3.626 | Y2 | Y2 | 1 | 1009 | E24-2 | CALE | 0.22608 | 0.0000288 | 0 | 40.3397 | 0.00912 | 60
CALE | STEEL/E24-2 | 3386.35 | 20135.6 | 15072.5 | +3.381 | +3.391 | Y2 | Y2 | 2 | 2004 | E24-2 | CALE | 0.22608 | 0.0000288 | 0 | 40.3397 | 0.00912 | 60
CALE | STEEL/E24-2 | 3386.35 | 20715.6 | 15072.5 | +3.381 | +3.391 | Y2 | Y2 | 2 | 2004 | E24-2 | CALE | 0.22608 | 0.0000288 | 0 | 40.3397 | 0.00912 | 60
CALE | STEEL/E24-2 | 3386.35 | 21295.6 | 15072.5 | +3.381 | +3.391 | Y2 | Y2 | 2 | 2004 | E24-2 | CALE | 0.22608 | 0.0000288 | 0 | 40.3397 | 0.00912 | 60
CALE | STEEL/E24-2 | 3386.35 | 23826.9 | 15072.5 | +3.381 | +3.391 | Y2 | Y2 | 2 | 2004 | E24-2 | CALE | 0.22608 | 0.0000288 | 0 | 40.3397 | 0.00912 | 60
CALE | STEEL/E24-2 | 3386.35 | 23246.9 | 15072.5 | +3.381 | +3.391 | Y2 | Y2 | 2 | 2004 | E24-2 | CALE | 0.22608 | 0.0000288 | 0 | 40.3397 | 0.00912 | 60
CALE | STEEL/E24-2 | 3386.35 | 22666.9 | 15072.5 | +3.381 | +3.391 | Y2 | Y2 | 2 | 2004 | E24-2 | CALE | 0.22608 | 0.0000288 | 0 | 40.3397 | 0.00912 | 60
CALE | STEEL/E24-2 | 3386.35 | 26358.1 | 15072.5 | +3.381 | +3.391 | Y2 | Y2 | 2 | 2004 | E24-2 | CALE | 0.22608 | 0.0000288 | 0 | 40.3397 | 0.00912 | 60
CALE | STEEL/E24-2 | 3386.35 | 25778.1 | 15072.5 | +3.381 | +3.391 | Y2 | Y2 | 2 | 2004 | E24-2 | CALE | 0.22608 | 0.0000288 | 0 | 40.3397 | 0.00912 | 60
CALE | STEEL/E24-2 | 3386.35 | 25198.1 | 15072.5 | +3.381 | +3.391 | Y2 | Y2 | 2 | 2004 | E24-2 | CALE | 0.22608 | 0.0000288 | 0 | 40.3397 | 0.00912 | 60
CALE | STEEL/E24-2 | 3386.35 | 28889.4 | 15072.5 | +3.381 | +3.391 | Y2 | Y2 | 2 | 2004 | E24-2 | CALE | 0.22608 | 0.0000288 | 0 | 40.3397 | 0.00912 | 60
CALE | STEEL/E24-2 | 3386.35 | 28309.4 | 15072.5 | +3.381 | +3.391 | Y2 | Y2 | 2 | 2004 | E24-2 | CALE | 0.22608 | 0.0000288 | 0 | 40.3397 | 0.00912 | 60
CALE | STEEL/E24-2 | 3386.35 | 27729.4 | 15072.5 | +3.381 | +3.391 | Y2 | Y2 | 2 | 2004 | E24-2 | CALE | 0.22608 | 0.0000288 | 0 | 40.3397 | 0.00912 | 60
CALE | STEEL/E24-2 | 3386.35 | 31489.4 | 15072.5 | +3.381 | +3.391 | Y2 | Y2 | 2 | 2004 | E24-2 | CALE | 0.22608 | 0.0000288 | 0 | 40.3397 | 0.00912 | 60
CALE | STEEL/E24-2 | 3386.35 | 30909.4 | 15072.5 | +3.381 | +3.391 | Y2 | Y2 | 2 | 2004 | E24-2 | CALE | 0.22608 | 0.0000288 | 0 | 40.3397 | 0.00912 | 60
CALE | STEEL/E24-2 | 3386.35 | 30329.4 | 15072.5 | +3.381 | +3.391 | Y2 | Y2 | 2 | 2004 | E24-2 | CALE | 0.22608 | 0.0000288 | 0 | 40.3397 | 0.00912 | 60
CALE | STEEL/E24-2 | 3386.35 | 34158.1 | 15072.5 | +3.381 | +3.391 | Y2 | Y2 | 2 | 2004 | E24-2 | CALE | 0.22608 | 0.0000288 | 0 | 40.3397 | 0.00912 | 60
CALE | STEEL/E24-2 | 3386.35 | 33578.1 | 15072.5 | +3.381 | +3.391 | Y2 | Y2 | 2 | 2004 | E24-2 | CALE | 0.22608 | 0.0000288 | 0 | 40.3397 | 0.00912 | 60
CALE | STEEL/E24-2 | 3386.35 | 32998.1 | 15072.5 | +3.381 | +3.391 | Y2 | Y2 | 2 | 2004 | E24-2 | CALE | 0.22608 | 0.0000288 | 0 | 40.3397 | 0.00912 | 60
CALE | STEEL/E24-2 | 3386.35 | 36826.9 | 15072.5 | +3.381 | +3.391 | Y2 | Y2 | 2 | 2004 | E24-2 | CALE | 0.22608 | 0.0000288 | 0 | 40.3397 | 0.00912 | 60
CALE | STEEL/E24-2 | 3386.35 | 36246.9 | 15072.5 | +3.381 | +3.391 | Y2 | Y2 | 2 | 2004 | E24-2 | CALE | 0.22608 | 0.0000288 | 0 | 40.3397 | 0.00912 | 60
CALE | STEEL/E24-2 | 3386.35 | 35666.9 | 15072.5 | +3.381 | +3.391 | Y2 | Y2 | 2 | 2004 | E24-2 | CALE | 0.22608 | 0.0000288 | 0 | 40.3397 | 0.00912 | 60
CALE | STEEL/E24-2 | 3386.35 | 39495.6 | 15072.5 | +3.381 | +3.391 | Y2 | Y2 | 2 | 2004 | E24-2 | CALE | 0.22608 | 0.0000288 | 0 | 40.3397 | 0.00912 | 60
CALE | STEEL/E24-2 | 3386.35 | 38915.6 | 15072.5 | +3.381 | +3.391 | Y2 | Y2 | 2 | 2004 | E24-2 | CALE | 0.22608 | 0.0000288 | 0 | 40.3397 | 0.00912 | 60
CALE | STEEL/E24-2 | 3386.35 | 38335.6 | 15072.5 | +3.381 | +3.391 | Y2 | Y2 | 2 | 2004 | E24-2 | CALE | 0.22608 | 0.0000288 | 0 | 40.3397 | 0.00912 | 60
CALE | STEEL/E24-2 | 3576.15 | 34158.1 | 4647.5 | +3.571 | +3.581 | Y2 | Y2 | 2 | 2004 | E24-2 | CALE | 0.22608 | 0.0000288 | 0 | 40.3397 | 0.00912 | 60
CALE | STEEL/E24-2 | 3576.15 | 33578.1 | 4647.5 | +3.571 | +3.581 | Y2 | Y2 | 2 | 2004 | E24-2 | CALE | 0.22608 | 0.0000288 | 0 | 40.3397 | 0.00912 | 60
CALE | STEEL/E24-2 | 3576.15 | 32998.1 | 4647.5 | +3.571 | +3.581 | Y2 | Y2 | 2 | 2004 | E24-2 | CALE | 0.22608 | 0.0000288 | 0 | 40.3397 | 0.00912 | 60
CALE | STEEL/E24-2 | 3576.15 | 31489.4 | 4647.5 | +3.571 | +3.581 | Y2 | Y2 | 2 | 2004 | E24-2 | CALE | 0.22608 | 0.0000288 | 0 | 40.3397 | 0.00912 | 60
CALE | STEEL/E24-2 | 3576.15 | 30909.4 | 4647.5 | +3.571 | +3.581 | Y2 | Y2 | 2 | 2004 | E24-2 | CALE | 0.22608 | 0.0000288 | 0 | 40.3397 | 0.00912 | 60
CALE | STEEL/E24-2 | 3576.15 | 30329.4 | 4647.5 | +3.571 | +3.581 | Y2 | Y2 | 2 | 2004 | E24-2 | CALE | 0.22608 | 0.0000288 | 0 | 40.3397 | 0.00912 | 60

# IfcBeam: PL6000*180 (3)
In: Undefined
Description: PL6000*180; Material: CONCRETE/BETON COURANT
Tekla Common - Bottom elevation: -0.000; Top elevation: +6.000; Phase: 10; Class: 76; Grade: BETON COURANT; Profile: PL6000*180; Name: PREFA; sets with these values: 2
Tekla Quantity - Height: 6000 mm; Width: 180 mm; sets with these values: 2
Name | Center of gravity Z (mm) | Center of gravity Y (mm) | Center of gravity X (mm) | Part mark = Assembly mark | Net weight (kg) = Weight (kg) = NetWeight (kg) | Gross weight (kg) | Net volume (m3) = NetVolume (m3) | Gross volume (m3) | Gross footprint area (m2) | Area per tons (m2) | Net surface area (m2) = OuterSurfaceArea (m2) | Gross area (m2) | Tekla Quantity, Length (mm) = BaseQuantities, Length (mm)
PREFA | 3000 | 69485 | 56230 | Z12 | 105711 | 105711 | 50.3388 | 50.3388 | 8.3898 | 5.47017 | 578.26 | 578.26 | 46610
PREFA | 3006.94 | 34618.8 | 79445 | Z1 | 156946 | 158760 | 74.736 | 75.6 | 12.6 | 5.47634 | 859.488 | 867.36 | 70000
PREFA | 3253.47 | -335 | 49695.1 | Z2 | 109855 | 133880 | 52.312 | 63.7524 | 10.6254 | 5.55196 | 609.911 | 731.771 | 59030

# IfcBeam: PL6000*200 (4)
In: Undefined
Description: PL6000*200; Material: CONCRETE/BETON COURANT
Tekla Common - Bottom elevation: -0.000; Phase: 10; Class: 75; Grade: BETON COURANT; Profile: PL6000*200; Name: PREFA; sets with these values: 2
Tekla Quantity - Width: 200 mm; sets with these values: 2
Name | Center of gravity Z (mm) | Center of gravity Y (mm) | Center of gravity X (mm) | Top elevation | Part mark = Assembly mark | Net weight (kg) = Weight (kg) = NetWeight (kg) | Gross weight (kg) | Net volume (m3) = NetVolume (m3) | Gross volume (m3) | Gross footprint area (m2) | Area per tons (m2) | Net surface area (m2) = OuterSurfaceArea (m2) | Gross area (m2) | Height (mm) | Tekla Quantity, Length (mm) = BaseQuantities, Length (mm)
PREFA | 1999.88 | 43749.6 | 1149.76 | +4.046 | Z55 | 4501.92 | 4554.71 | 2.14377 | 3.216 | 0 | 5.35546 | 24.1099 | 35.632 | 4046.48 | 2680
PREFA | 1978.09 | 38674.8 | 2394.97 | +3.960 | Z56 | 17196.8 | 17212 | 8.18896 | 12.4195 | 0 | 5.09473 | 87.6132 | 130.735 | 3959.67 | 10349.6
PREFA | 2001.64 | 33600 | 1048.96 | +4.053 | Z57 | 4842.12 | 4903.08 | 2.30577 | 3.456 | 0 | 5.33058 | 25.8113 | 38.112 | 4053.48 | 2880
PREFA | 3000 | 5195 | 20615 | +6.000 | Z52 | 27417.6 | 27417.6 | 13.056 | 13.056 | 2.176 | 5.00817 | 137.312 | 137.312 | 6000 | 10880

# IfcBeam: PL6140*200 (4)
In: Undefined
Description: PL6140*200; Material: CONCRETE/BETON COURANT
Tekla Common - Center of gravity Z: 3070 mm; Bottom elevation: +0.000; Top elevation: +6.140; Phase: 10; Class: 72; Grade: BETON COURANT; Profile: PL6140*200; Name: MACONNERIE; sets with these values: 2
Tekla Quantity - Height: 6140 mm; Width: 200 mm; sets with these values: 2
Name | Center of gravity Y (mm) | Center of gravity X (mm) | Part mark = Assembly mark | Net weight (kg) = Gross weight (kg) = Weight (kg) = NetWeight (kg) | Net volume (m3) = Gross volume (m3) = NetVolume (m3) | Gross footprint area (m2) | Area per tons (m2) | Net surface area (m2) = Gross area (m2) = OuterSurfaceArea (m2) | Tekla Quantity, Length (mm) = BaseQuantities, Length (mm)
MACONNERIE | 69475 | 32054 | Z36 | 4492.53 | 2.1393 | 0.34842 | 5.4637 | 24.5458 | 1742.1
MACONNERIE | 48525 | 27745 | Z35 | 2063.04 | 0.9824 | 0.16 | 6.10749 | 12.6 | 800
MACONNERIE | 51837.3 | 27745 | Z35 | 2063.04 | 0.9824 | 0.16 | 6.10749 | 12.6 | 800
MACONNERIE | 68925 | 27745 | Z35 | 2063.04 | 0.9824 | 0.16 | 6.10749 | 12.6 | 800

# IfcBeam: PL6140*400 (3)
In: Undefined
Description: PL6140*400; Material: CONCRETE/BETON COURANT
Tekla Common - Center of gravity Z: 3070 mm; Bottom elevation: +0.000; Top elevation: +6.140; Phase: 10; Class: 72; Grade: BETON COURANT; Profile: PL6140*400; Name: MACONNERIE; sets with these values: 2
Tekla Quantity - Height: 6140 mm; Width: 400 mm; sets with these values: 2
Name | Center of gravity Y (mm) | Center of gravity X (mm) | Part mark = Assembly mark | Net weight (kg) = Gross weight (kg) = Weight (kg) = NetWeight (kg) | Net volume (m3) = Gross volume (m3) = NetVolume (m3) | Gross footprint area (m2) | Area per tons (m2) | Net surface area (m2) = Gross area (m2) = OuterSurfaceArea (m2) | Tekla Quantity, Length (mm) = BaseQuantities, Length (mm)
MACONNERIE | 69175 | 32525 | Z77 | 2063.04 | 0.9824 | 0.16 | 4.91702 | 10.144 | 400
MACONNERIE | 61050 | 32325 | Z78 | 4126.08 | 1.9648 | 0.32 | 3.72654 | 15.376 | 800
MACONNERIE | 51514.2 | 32525 | Z77 | 2063.04 | 0.9824 | 0.16 | 4.91702 | 10.144 | 400

# IfcBeam: PL66*3 (96)
In: Undefined
Description: PL66*3; Material: STEEL/E24-2
Tekla Common - Part mark: 1242; Phase: 4; Class: 4001; Finish: GRENAILLE-PEINT; Grade: E24-2; Profile: PL66*3; sets with these values: 2
Tekla Quantity - Net weight: 0.102584 kg; Gross weight: 0.102584 kg; Weight: 0.102584 kg; Net volume: 0.000013068 m3; Gross volume: 0.000013068 m3; Area per tons: 92.6462 m2; Height: 66 mm; Width: 3 mm; sets with these values: 2
BaseQuantities - NetVolume: 0.000013068 m3; NetWeight: 0.102584 kg
Name | Center of gravity Z (mm) | Center of gravity Y (mm) | Center of gravity X (mm) | Bottom elevation | Top elevation | Assembly mark | Gross footprint area (m2) | Net surface area (m2) = Gross area (m2) = OuterSurfaceArea (m2) | Tekla Quantity, Length (mm) = BaseQuantities, Length (mm)
 | 3878.5 | 27915 | 55985 | +3.877 | +3.880 | M18 | 0.004356 | 0.009504 | 66
 | 5566.24 | 27915 | 56038.7 | +5.533 | +5.599 | M20 | 0 | 0.009504 | 66
 | 4281.21 | 27915 | 54383.7 | +4.248 | +4.314 | M21 | 0 | 0.009504 | 66
 | 3878.5 | 27915 | 55715 | +3.877 | +3.880 | M21 | 0.004356 | 0.009504 | 66
 | 4298.5 | 27915 | 55715 | +4.297 | +4.300 | M21 | 0.004356 | 0.009504 | 66
 | 3535 | 27915 | 54448.5 | +3.502 | +3.568 | M19 | 0.000198 | 0.009504 | 66
 | 5279.77 | 27915 | 58366.3 | +5.247 | +5.313 | M20 | 0 | 0.009504 | 66
 | 4298.5 | 23985 | 55715 | +4.297 | +4.300 | M22 | 0.004356 | 0.009504 | 66
 | 3878.5 | 23985 | 55715 | +3.877 | +3.880 | M22 | 0.004356 | 0.009504 | 66
 | 3878.5 | 23985 | 55985 | +3.877 | +3.880 | M17 | 0.004356 | 0.009504 | 66
 | 5566.24 | 23985 | 56038.7 | +5.533 | +5.599 | M20 | 0 | 0.009504 | 66
 | 3535 | 23985 | 58301.5 | +3.502 | +3.568 | M19 | 0.000198 | 0.009504 | 66
 | 4281.21 | 23985 | 54383.7 | +4.248 | +4.314 | M22 | 0 | 0.009504 | 66
 | 5279.77 | 23985 | 58366.3 | +5.247 | +5.313 | M20 | 0 | 0.009504 | 66
 | 4352 | 66502 | 44030 | +4.319 | +4.385 | L79 | 0.000198 | 0.00950399 | 65.9999
 | 4352 | 69111.6 | 44030 | +4.319 | +4.385 | L79 | 0.000198 | 0.00950399 | 66
 | 4352 | 63711.6 | 44030 | +4.319 | +4.385 | L78 | 0.000198 | 0.00950399 | 66
 | 4352 | 61168.5 | 44030 | +4.319 | +4.385 | L78 | 0.000198 | 0.00950399 | 65.9999
 | 4282 | 60926.5 | 44030 | +4.249 | +4.315 | L77 | 0.000198 | 0.00950399 | 66
 | 4282 | 58504.6 | 44030 | +4.249 | +4.315 | L77 | 0.000198 | 0.00950399 | 65.9999
 | 4352 | 66411.6 | 44030 | +4.319 | +4.385 | L76 | 0.000198 | 0.00950399 | 66
 | 4352 | 63802 | 44030 | +4.319 | +4.385 | L76 | 0.000198 | 0.00950399 | 65.9999
 | 4352 | 58411.6 | 44030 | +4.319 | +4.385 | L72 | 0.000198 | 0.00950399 | 66
 | 4352 | 55902 | 44030 | +4.319 | +4.385 | L72 | 0.000198 | 0.00950399 | 65.9999
 | 4352 | 55811.6 | 44030 | +4.319 | +4.385 | L72 | 0.000198 | 0.00950399 | 66
 | 4352 | 53302 | 44030 | +4.319 | +4.385 | L72 | 0.000198 | 0.00950399 | 65.9999
 | 4352 | 53211.6 | 44030 | +4.319 | +4.385 | L72 | 0.000198 | 0.00950399 | 66
 | 4352 | 50702 | 44030 | +4.319 | +4.385 | L72 | 0.000198 | 0.00950399 | 65.9999
 | 4352 | 50611.6 | 44030 | +4.319 | +4.385 | L72 | 0.000198 | 0.00950399 | 66
 | 4352 | 48102 | 44030 | +4.319 | +4.385 | L72 | 0.000198 | 0.00950399 | 65.9999
 | 4352 | 48011.6 | 44030 | +4.319 | +4.385 | L72 | 0.000198 | 0.00950399 | 66
 | 4352 | 45502 | 44030 | +4.319 | +4.385 | L72 | 0.000198 | 0.00950399 | 65.9999
 | 4352 | 42902 | 44030 | +4.319 | +4.385 | L72 | 0.000198 | 0.00950399 | 65.9999
 | 4352 | 45411.6 | 44030 | +4.319 | +4.385 | L72 | 0.000198 | 0.00950399 | 66
 | 4282 | 40368.5 | 44030 | +4.249 | +4.315 | L75 | 0.000198 | 0.00950399 | 65.9999
 | 4282 | 42795.5 | 44030 | +4.249 | +4.315 | L75 | 0.000198 | 0.00950399 | 66
 | 4352 | 40131.5 | 44030 | +4.319 | +4.385 | L74 | 0.000198 | 0.00950399 | 66
 | 4352 | 37704.6 | 44030 | +4.319 | +4.385 | L74 | 0.000198 | 0.00950399 | 65.9999
 | 4352 | 37611.6 | 44030 | +4.319 | +4.385 | L72 | 0.000198 | 0.00950399 | 66
 | 4352 | 35102 | 44030 | +4.319 | +4.385 | L72 | 0.000198 | 0.00950399 | 65.9999
 | 4352 | 35011.6 | 44030 | +4.319 | +4.385 | L72 | 0.000198 | 0.00950399 | 66
 | 4352 | 32502 | 44030 | +4.319 | +4.385 | L72 | 0.000198 | 0.00950399 | 65.9999
 | 4352 | 32411.6 | 44030 | +4.319 | +4.385 | L72 | 0.000198 | 0.00950399 | 66
 | 4352 | 29902 | 44030 | +4.319 | +4.385 | L72 | 0.000198 | 0.00950399 | 65.9999
 | 4352 | 29811.6 | 44030 | +4.319 | +4.385 | L72 | 0.000198 | 0.00950399 | 66
 | 4352 | 27302 | 44030 | +4.319 | +4.385 | L72 | 0.000198 | 0.00950399 | 65.9999
 | 4352 | 27211.6 | 44030 | +4.319 | +4.385 | L72 | 0.000198 | 0.00950399 | 66
 | 4352 | 24702 | 44030 | +4.319 | +4.385 | L72 | 0.000198 | 0.00950399 | 65.9999
 | 4282 | 22008.6 | 44030 | +4.249 | +4.315 | L73 | 0.000198 | 0.00950399 | 66
 | 4282 | 19568.5 | 44030 | +4.249 | +4.315 | L73 | 0.000198 | 0.00950399 | 65.9999
 | 4352 | 24611.6 | 44030 | +4.319 | +4.385 | L72 | 0.000198 | 0.00950399 | 66
 | 4352 | 22102 | 44030 | +4.319 | +4.385 | L72 | 0.000198 | 0.00950399 | 65.9999
 | 4352 | 19331.5 | 44030 | +4.319 | +4.385 | L71 | 0.000198 | 0.00950399 | 66
 | 4352 | 17142 | 44030 | +4.319 | +4.385 | L71 | 0.000198 | 0.00950399 | 65.9999
 | 4352 | 17051.6 | 44030 | +4.319 | +4.385 | L70 | 0.000198 | 0.00950399 | 66
 | 4352 | 14782 | 44030 | +4.319 | +4.385 | L70 | 0.000198 | 0.00950399 | 65.9999
 | 4352 | 14691.6 | 44030 | +4.319 | +4.385 | L70 | 0.000198 | 0.00950399 | 66
 | 4352 | 12422 | 44030 | +4.319 | +4.385 | L70 | 0.000198 | 0.00950399 | 66
 | 3635 | 69373.1 | 44030 | +3.602 | +3.668 | L65 | 0.000198 | 0.00950399 | 66
 | 3635 | 64009 | 44030 | +3.602 | +3.668 | L64 | 0.000198 | 0.00950399 | 66
 | 3635 | 64022 | 44030 | +3.602 | +3.668 | L65 | 0.000198 | 0.00950399 | 65.9999
 | 3635 | 59089.9 | 44030 | +3.602 | +3.668 | L64 | 0.000198 | 0.00950399 | 65.9999
 | 3635 | 59076.9 | 44030 | +3.602 | +3.668 | L62 | 0.000198 | 0.00950399 | 66
 | 3635 | 53522 | 44030 | +3.602 | +3.668 | L62 | 0.000198 | 0.00950399 | 65.9999
 | 3635 | 53509 | 44030 | +3.602 | +3.668 | L61 | 0.000198 | 0.00950399 | 66
 | 3635 | 48322 | 44030 | +3.602 | +3.668 | L61 | 0.000198 | 0.00950399 | 65.9999
 | 3635 | 48309 | 44030 | +3.602 | +3.668 | L61 | 0.000198 | 0.00950399 | 66
 | 3635 | 43122 | 44030 | +3.602 | +3.668 | L61 | 0.000198 | 0.00950399 | 65.9999
 | 3635 | 43109 | 44030 | +3.602 | +3.668 | L63 | 0.000198 | 0.00950399 | 66
 | 3635 | 38276.9 | 44030 | +3.602 | +3.668 | L62 | 0.000198 | 0.00950399 | 66
 | 3635 | 32709 | 44030 | +3.602 | +3.668 | L61 | 0.000198 | 0.00950399 | 66
 | 3635 | 38289.9 | 44030 | +3.602 | +3.668 | L63 | 0.000198 | 0.00950399 | 65.9999
 | 3635 | 32722 | 44030 | +3.602 | +3.668 | L62 | 0.000198 | 0.00950399 | 65.9999
 | 3635 | 27509 | 44030 | +3.602 | +3.668 | L61 | 0.000198 | 0.00950399 | 66
 | 3635 | 27522 | 44030 | +3.602 | +3.668 | L61 | 0.000198 | 0.00950399 | 65.9999
 | 3635 | 22309 | 44030 | +3.602 | +3.668 | L60 | 0.000198 | 0.00950399 | 66
 | 3635 | 22322 | 44030 | +3.602 | +3.668 | L61 | 0.000198 | 0.00950399 | 65.9999
 | 3635 | 17349 | 44030 | +3.602 | +3.668 | L59 | 0.000198 | 0.009504 | 66
 | 3635 | 17362 | 44030 | +3.602 | +3.668 | L60 | 0.000198 | 0.00950399 | 65.9999
 | 3635 | 12629 | 44030 | +3.602 | +3.668 | L58 | 0.000198 | 0.009504 | 66
 | 3635 | 12642 | 44030 | +3.602 | +3.668 | L59 | 0.000198 | 0.00950399 | 65.9999
 | 3635 | 7850.5 | 44030 | +3.602 | +3.668 | L57 | 0.000198 | 0.009504 | 66
 | 3635 | -221.5 | 44030 | +3.602 | +3.668 | L56 | 0.000198 | 0.009504 | 66
 | 3635 | 2822 | 44030 | +3.602 | +3.668 | L57 | 0.000198 | 0.009504 | 66
 | 3635 | 2809 | 44030 | +3.602 | +3.668 | L56 | 0.000198 | 0.009504 | 66
 | 4352 | 38.5003 | 44030 | +4.319 | +4.385 | L66 | 0.000198 | 0.009504 | 66
 | 4352 | 2511.5 | 44030 | +4.319 | +4.385 | L66 | 0.000198 | 0.009504 | 66
 | 4352 | 2602 | 44030 | +4.319 | +4.385 | L67 | 0.000198 | 0.009504 | 66
 | 4352 | 5063 | 44030 | +4.319 | +4.385 | L67 | 0.000198 | 0.009504 | 66
 | 4282 | 5152 | 44030 | +4.249 | +4.315 | L68 | 0.000198 | 0.00950399 | 66
 | 4282 | 7541.5 | 44030 | +4.249 | +4.315 | L68 | 0.000198 | 0.00950399 | 66
 | 4352 | 7758.5 | 44030 | +4.319 | +4.385 | L69 | 0.000198 | 0.00950399 | 65.9999
 | 3635 | 7863.5 | 44030 | +3.602 | +3.668 | L58 | 0.000198 | 0.00950399 | 66
 | 4352 | 9973 | 44030 | +4.319 | +4.385 | L69 | 0.000198 | 0.00950399 | 66
 | 4352 | 12331.6 | 44030 | +4.319 | +4.385 | L70 | 0.000198 | 0.00950399 | 66
 | 4352 | 10062 | 44030 | +4.319 | +4.385 | L70 | 0.000198 | 0.00950399 | 66

# IfcBeam: PL70*10 (8)
In: Undefined
Description: PL70*10; Material: STEEL/E24-2
Tekla Common - Part mark: 195; Phase: 2; Class: 2003; Finish: GRENAILLE-PEINT; Grade: E24-2; Profile: PL70*10; Name: PLAT; sets with these values: 2
Tekla Quantity - Net weight: 1.04405 kg; Gross weight: 1.04405 kg; Weight: 1.04405 kg; Net volume: 0.000133 m3; Gross volume: 0.000133 m3; Gross footprint area: 0.0019 m2; Area per tons: 30.4583 m2; Net surface area: 0.0318 m2; Gross area: 0.0318 m2; Height: 70 mm; Width: 10 mm; Length: 190 mm; sets with these values: 2
BaseQuantities - Length: 190 mm; OuterSurfaceArea: 0.0318 m2; NetVolume: 0.000133 m3; NetWeight: 1.04405 kg
Name | Center of gravity Z (mm) | Center of gravity Y (mm) | Center of gravity X (mm) | Bottom elevation | Top elevation | Assembly mark
PLAT | 2970.64 | 15193.4 | 6414.02 | +2.936 | +3.006 | L35
PLAT | 2970.64 | 15202.6 | 6409.92 | +2.936 | +3.006 | L36
PLAT | 2970.34 | 19476.7 | 4745.04 | +2.935 | +3.005 | L36
PLAT | 2970.34 | 19486.2 | 4741.9 | +2.935 | +3.005 | L34
PLAT | 2970 | 24511.5 | 3400.15 | +2.935 | +3.005 | L34
PLAT | 2970 | 24521.3 | 3398.14 | +2.935 | +3.005 | L37
PLAT | 2969.67 | 29581.7 | 2662.15 | +2.935 | +3.005 | L33
PLAT | 2969.67 | 29571.7 | 2663.02 | +2.935 | +3.005 | L37

# IfcBeam: PL70*6 (174)
In: Undefined
Description: PL70*6
Tekla Common - Profile: PL70*6; sets with these values: 2
Tekla Quantity - Height: 70 mm; Width: 6 mm; sets with these values: 2
Name | Material | Center of gravity Z (mm) | Center of gravity Y (mm) | Center of gravity X (mm) | Bottom elevation | Top elevation | Part mark | Assembly mark | Phase | Class | Finish | Grade | Name | Net weight (kg) = Weight (kg) = NetWeight (kg) | Gross weight (kg) | Net volume (m3) = NetVolume (m3) | Gross volume (m3) | Gross footprint area (m2) | Area per tons (m2) | Net surface area (m2) = OuterSurfaceArea (m2) | Gross area (m2) | Tekla Quantity, Length (mm) = BaseQuantities, Length (mm)
MONTANT | STEEL/E24-2 | 5605.2 | 27915 | 55967.5 | +5.602 | +5.608 | 328 | M18 | 4 | 4001 | GRENAILLE-PEINT | E24-2 | MONTANT | 0.379155 | 0.379155 | 0.0000483 | 0.0000483 | 0.00805 | 48.318 | 0.01832 | 0.01832 | 115
MONTANT | STEEL/E24-2 | 5605.2 | 23985 | 55967.5 | +5.602 | +5.608 | 328 | M17 | 4 | 4001 | GRENAILLE-PEINT | E24-2 | MONTANT | 0.379155 | 0.379155 | 0.0000483 | 0.0000483 | 0.00805 | 48.318 | 0.01832 | 0.01832 | 115
ATTACHE | STEEL/S235JR | 4311.91 | 40164.9 | 8343 | +4.265 | +4.359 | 331 | P67 | 2 | 2007 | GALVANISE | S235JR | ATTACHE | 0.309329 | 0.309918 | 0.000039405 | 0.00003948 | 0.00039 | 48.7682 | 0.0150854 | 0.015128 | 94
ATTACHE | STEEL/S235JR | 4311.91 | 40335.1 | 8343 | +4.265 | +4.359 | 331 | P67 | 2 | 2007 | GALVANISE | S235JR | ATTACHE | 0.309329 | 0.309918 | 0.000039405 | 0.00003948 | 0.00039 | 48.7682 | 0.0150854 | 0.015128 | 94
ATTACHE | STEEL/S235JR | 4311.91 | 40335.1 | 5694.67 | +4.265 | +4.359 | 331 | P66 | 2 | 2007 | GALVANISE | S235JR | ATTACHE | 0.309329 | 0.309918 | 0.000039405 | 0.00003948 | 0.00039 | 48.7682 | 0.0150854 | 0.015128 | 94
ATTACHE | STEEL/S235JR | 4311.91 | 40164.9 | 5694.67 | +4.265 | +4.359 | 331 | P66 | 2 | 2007 | GALVANISE | S235JR | ATTACHE | 0.309329 | 0.309918 | 0.000039405 | 0.00003948 | 0.00039 | 48.7682 | 0.0150854 | 0.015128 | 94
ATTACHE | STEEL/S235JR | 4311.91 | 37496.2 | 8343 | +4.265 | +4.359 | 331 | P67 | 2 | 2007 | GALVANISE | S235JR | ATTACHE | 0.309329 | 0.309918 | 0.000039405 | 0.00003948 | 0.00039 | 48.7682 | 0.0150854 | 0.015128 | 94
ATTACHE | STEEL/S235JR | 4311.91 | 37666.3 | 8343 | +4.265 | +4.359 | 331 | P67 | 2 | 2007 | GALVANISE | S235JR | ATTACHE | 0.309329 | 0.309918 | 0.000039405 | 0.00003948 | 0.00039 | 48.7682 | 0.0150854 | 0.015128 | 94
ATTACHE | STEEL/S235JR | 4311.91 | 37666.3 | 5694.67 | +4.265 | +4.359 | 331 | P66 | 2 | 2007 | GALVANISE | S235JR | ATTACHE | 0.309329 | 0.309918 | 0.000039405 | 0.00003948 | 0.00039 | 48.7682 | 0.0150854 | 0.015128 | 94
ATTACHE | STEEL/S235JR | 4311.91 | 37496.2 | 5694.67 | +4.265 | +4.359 | 331 | P66 | 2 | 2007 | GALVANISE | S235JR | ATTACHE | 0.309329 | 0.309918 | 0.000039405 | 0.00003948 | 0.00039 | 48.7682 | 0.0150854 | 0.015128 | 94
ATTACHE | STEEL/S235JR | 4311.91 | 34827.4 | 8343 | +4.265 | +4.359 | 331 | P67 | 2 | 2007 | GALVANISE | S235JR | ATTACHE | 0.309329 | 0.309918 | 0.000039405 | 0.00003948 | 0.00039 | 48.7682 | 0.0150854 | 0.015128 | 94
ATTACHE | STEEL/S235JR | 4311.91 | 34997.6 | 8343 | +4.265 | +4.359 | 331 | P67 | 2 | 2007 | GALVANISE | S235JR | ATTACHE | 0.309329 | 0.309918 | 0.000039405 | 0.00003948 | 0.00039 | 48.7682 | 0.0150854 | 0.015128 | 94
ATTACHE | STEEL/S235JR | 4311.91 | 34997.6 | 5694.67 | +4.265 | +4.359 | 331 | P66 | 2 | 2007 | GALVANISE | S235JR | ATTACHE | 0.309329 | 0.309918 | 0.000039405 | 0.00003948 | 0.00039 | 48.7682 | 0.0150854 | 0.015128 | 94
ATTACHE | STEEL/S235JR | 4311.91 | 34827.4 | 5694.67 | +4.265 | +4.359 | 331 | P66 | 2 | 2007 | GALVANISE | S235JR | ATTACHE | 0.309329 | 0.309918 | 0.000039405 | 0.00003948 | 0.00039 | 48.7682 | 0.0150854 | 0.015128 | 94
ATTACHE | STEEL/S235JR | 4311.91 | 32158.7 | 5694.67 | +4.265 | +4.359 | 331 | P66 | 2 | 2007 | GALVANISE | S235JR | ATTACHE | 0.309329 | 0.309918 | 0.000039405 | 0.00003948 | 0.00039 | 48.7682 | 0.0150854 | 0.015128 | 94
ATTACHE | STEEL/S235JR | 4311.91 | 32328.8 | 5694.67 | +4.265 | +4.359 | 331 | P66 | 2 | 2007 | GALVANISE | S235JR | ATTACHE | 0.309329 | 0.309918 | 0.000039405 | 0.00003948 | 0.00039 | 48.7682 | 0.0150854 | 0.015128 | 94
ATTACHE | STEEL/S235JR | 4311.91 | 32328.8 | 8343 | +4.265 | +4.359 | 331 | P67 | 2 | 2007 | GALVANISE | S235JR | ATTACHE | 0.309329 | 0.309918 | 0.000039405 | 0.00003948 | 0.00039 | 48.7682 | 0.0150854 | 0.015128 | 94
ATTACHE | STEEL/S235JR | 4311.91 | 32158.7 | 8343 | +4.265 | +4.359 | 331 | P67 | 2 | 2007 | GALVANISE | S235JR | ATTACHE | 0.309329 | 0.309918 | 0.000039405 | 0.00003948 | 0.00039 | 48.7682 | 0.0150854 | 0.015128 | 94
ATTACHE | STEEL/S235JR | 4311.91 | 29489.9 | 8343 | +4.265 | +4.359 | 331 | P67 | 2 | 2007 | GALVANISE | S235JR | ATTACHE | 0.309329 | 0.309918 | 0.000039405 | 0.00003948 | 0.00039 | 48.7682 | 0.0150854 | 0.015128 | 94
ATTACHE | STEEL/S235JR | 4311.91 | 29660.1 | 8343 | +4.265 | +4.359 | 331 | P67 | 2 | 2007 | GALVANISE | S235JR | ATTACHE | 0.309329 | 0.309918 | 0.000039405 | 0.00003948 | 0.00039 | 48.7682 | 0.0150854 | 0.015128 | 94
ATTACHE | STEEL/S235JR | 4311.91 | 29660.1 | 5694.67 | +4.265 | +4.359 | 331 | P66 | 2 | 2007 | GALVANISE | S235JR | ATTACHE | 0.309329 | 0.309918 | 0.000039405 | 0.00003948 | 0.00039 | 48.7682 | 0.0150854 | 0.015128 | 94
ATTACHE | STEEL/S235JR | 4311.91 | 29489.9 | 5694.67 | +4.265 | +4.359 | 331 | P66 | 2 | 2007 | GALVANISE | S235JR | ATTACHE | 0.309329 | 0.309918 | 0.000039405 | 0.00003948 | 0.00039 | 48.7682 | 0.0150854 | 0.015128 | 94
ATTACHE | STEEL/S235JR | 4311.91 | 26958.7 | 8343 | +4.265 | +4.359 | 331 | P67 | 2 | 2007 | GALVANISE | S235JR | ATTACHE | 0.309329 | 0.309918 | 0.000039405 | 0.00003948 | 0.00039 | 48.7682 | 0.0150854 | 0.015128 | 94
ATTACHE | STEEL/S235JR | 4311.91 | 27128.8 | 8343 | +4.265 | +4.359 | 331 | P67 | 2 | 2007 | GALVANISE | S235JR | ATTACHE | 0.309329 | 0.309918 | 0.000039405 | 0.00003948 | 0.00039 | 48.7682 | 0.0150854 | 0.015128 | 94
ATTACHE | STEEL/S235JR | 4311.91 | 27128.8 | 5694.67 | +4.265 | +4.359 | 331 | P66 | 2 | 2007 | GALVANISE | S235JR | ATTACHE | 0.309329 | 0.309918 | 0.000039405 | 0.00003948 | 0.00039 | 48.7682 | 0.0150854 | 0.015128 | 94
ATTACHE | STEEL/S235JR | 4311.91 | 26958.7 | 5694.67 | +4.265 | +4.359 | 331 | P66 | 2 | 2007 | GALVANISE | S235JR | ATTACHE | 0.309329 | 0.309918 | 0.000039405 | 0.00003948 | 0.00039 | 48.7682 | 0.0150854 | 0.015128 | 94
ATTACHE | STEEL/S235JR | 4311.91 | 24427.4 | 8343 | +4.265 | +4.359 | 331 | P67 | 2 | 2007 | GALVANISE | S235JR | ATTACHE | 0.309329 | 0.309918 | 0.000039405 | 0.00003948 | 0.00039 | 48.7682 | 0.0150854 | 0.015128 | 94
ATTACHE | STEEL/S235JR | 4311.91 | 24597.6 | 8343 | +4.265 | +4.359 | 331 | P67 | 2 | 2007 | GALVANISE | S235JR | ATTACHE | 0.309329 | 0.309918 | 0.000039405 | 0.00003948 | 0.00039 | 48.7682 | 0.0150854 | 0.015128 | 94
ATTACHE | STEEL/S235JR | 4311.91 | 24597.6 | 5694.67 | +4.265 | +4.359 | 331 | P66 | 2 | 2007 | GALVANISE | S235JR | ATTACHE | 0.309329 | 0.309918 | 0.000039405 | 0.00003948 | 0.00039 | 48.7682 | 0.0150854 | 0.015128 | 94
ATTACHE | STEEL/S235JR | 4311.91 | 24427.4 | 5694.67 | +4.265 | +4.359 | 331 | P66 | 2 | 2007 | GALVANISE | S235JR | ATTACHE | 0.309329 | 0.309918 | 0.000039405 | 0.00003948 | 0.00039 | 48.7682 | 0.0150854 | 0.015128 | 94
ATTACHE | STEEL/S235JR | 4311.91 | 21896.2 | 5694.67 | +4.265 | +4.359 | 331 | P66 | 2 | 2007 | GALVANISE | S235JR | ATTACHE | 0.309329 | 0.309918 | 0.000039405 | 0.00003948 | 0.00039 | 48.7682 | 0.0150854 | 0.015128 | 94
ATTACHE | STEEL/S235JR | 4311.91 | 22066.3 | 5694.67 | +4.265 | +4.359 | 331 | P66 | 2 | 2007 | GALVANISE | S235JR | ATTACHE | 0.309329 | 0.309918 | 0.000039405 | 0.00003948 | 0.00039 | 48.7682 | 0.0150854 | 0.015128 | 94
ATTACHE | STEEL/S235JR | 4311.91 | 22066.3 | 8343 | +4.265 | +4.359 | 331 | P67 | 2 | 2007 | GALVANISE | S235JR | ATTACHE | 0.309329 | 0.309918 | 0.000039405 | 0.00003948 | 0.00039 | 48.7682 | 0.0150854 | 0.015128 | 94
ATTACHE | STEEL/S235JR | 4311.91 | 21896.2 | 8343 | +4.265 | +4.359 | 331 | P67 | 2 | 2007 | GALVANISE | S235JR | ATTACHE | 0.309329 | 0.309918 | 0.000039405 | 0.00003948 | 0.00039 | 48.7682 | 0.0150854 | 0.015128 | 94
ATTACHE | STEEL/S235JR | 4311.91 | 19535.1 | 5694.67 | +4.265 | +4.359 | 331 | P66 | 2 | 2007 | GALVANISE | S235JR | ATTACHE | 0.309329 | 0.309918 | 0.000039405 | 0.00003948 | 0.00039 | 48.7682 | 0.0150854 | 0.015128 | 94
ATTACHE | STEEL/S235JR | 4311.91 | 19364.9 | 5694.67 | +4.265 | +4.359 | 331 | P66 | 2 | 2007 | GALVANISE | S235JR | ATTACHE | 0.309329 | 0.309918 | 0.000039405 | 0.00003948 | 0.00039 | 48.7682 | 0.0150854 | 0.015128 | 94
ATTACHE | STEEL/S235JR | 4311.91 | 19364.9 | 8343 | +4.265 | +4.359 | 331 | P67 | 2 | 2007 | GALVANISE | S235JR | ATTACHE | 0.309329 | 0.309918 | 0.000039405 | 0.00003948 | 0.00039 | 48.7682 | 0.0150854 | 0.015128 | 94
ATTACHE | STEEL/S235JR | 4311.91 | 19535.1 | 8343 | +4.265 | +4.359 | 331 | P67 | 2 | 2007 | GALVANISE | S235JR | ATTACHE | 0.309329 | 0.309918 | 0.000039405 | 0.00003948 | 0.00039 | 48.7682 | 0.0150854 | 0.015128 | 94
ATTACHE | STEEL/S235JR | 4311.91 | 17405.1 | 5694.67 | +4.265 | +4.359 | 331 | P66 | 2 | 2007 | GALVANISE | S235JR | ATTACHE | 0.309329 | 0.309918 | 0.000039405 | 0.00003948 | 0.00039 | 48.7682 | 0.0150854 | 0.015128 | 94
ATTACHE | STEEL/S235JR | 4311.91 | 17234.9 | 5694.67 | +4.265 | +4.359 | 331 | P66 | 2 | 2007 | GALVANISE | S235JR | ATTACHE | 0.309329 | 0.309918 | 0.000039405 | 0.00003948 | 0.00039 | 48.7682 | 0.0150854 | 0.015128 | 94
ATTACHE | STEEL/S235JR | 4311.91 | 17234.9 | 8343 | +4.265 | +4.359 | 331 | P67 | 2 | 2007 | GALVANISE | S235JR | ATTACHE | 0.309329 | 0.309918 | 0.000039405 | 0.00003948 | 0.00039 | 48.7682 | 0.0150854 | 0.015128 | 94
ATTACHE | STEEL/S235JR | 4311.91 | 17405.1 | 8343 | +4.265 | +4.359 | 331 | P67 | 2 | 2007 | GALVANISE | S235JR | ATTACHE | 0.309329 | 0.309918 | 0.000039405 | 0.00003948 | 0.00039 | 48.7682 | 0.0150854 | 0.015128 | 94
ATTACHE | STEEL/S235JR | 4311.91 | 15275.1 | 5694.67 | +4.265 | +4.359 | 331 | P66 | 2 | 2007 | GALVANISE | S235JR | ATTACHE | 0.309329 | 0.309918 | 0.000039405 | 0.00003948 | 0.00039 | 48.7682 | 0.0150854 | 0.015128 | 94
ATTACHE | STEEL/S235JR | 4311.91 | 15104.9 | 5694.67 | +4.265 | +4.359 | 331 | P66 | 2 | 2007 | GALVANISE | S235JR | ATTACHE | 0.309329 | 0.309918 | 0.000039405 | 0.00003948 | 0.00039 | 48.7682 | 0.0150854 | 0.015128 | 94
ATTACHE | STEEL/S235JR | 4311.91 | 15104.9 | 8343 | +4.265 | +4.359 | 331 | P67 | 2 | 2007 | GALVANISE | S235JR | ATTACHE | 0.309329 | 0.309918 | 0.000039405 | 0.00003948 | 0.00039 | 48.7682 | 0.0150854 | 0.015128 | 94
ATTACHE | STEEL/S235JR | 4311.91 | 15275.1 | 8343 | +4.265 | +4.359 | 331 | P67 | 2 | 2007 | GALVANISE | S235JR | ATTACHE | 0.309329 | 0.309918 | 0.000039405 | 0.00003948 | 0.00039 | 48.7682 | 0.0150854 | 0.015128 | 94
ATTACHE | STEEL/S235JR | 4311.91 | 12974.9 | 5694.67 | +4.265 | +4.359 | 331 | P66 | 2 | 2007 | GALVANISE | S235JR | ATTACHE | 0.309329 | 0.309918 | 0.000039405 | 0.00003948 | 0.00039 | 48.7682 | 0.0150854 | 0.015128 | 94
ATTACHE | STEEL/S235JR | 4311.91 | 13145.1 | 5694.67 | +4.265 | +4.359 | 331 | P66 | 2 | 2007 | GALVANISE | S235JR | ATTACHE | 0.309329 | 0.309918 | 0.000039405 | 0.00003948 | 0.00039 | 48.7682 | 0.0150854 | 0.015128 | 94
ATTACHE | STEEL/S235JR | 4311.91 | 13145.1 | 8343 | +4.265 | +4.359 | 331 | P67 | 2 | 2007 | GALVANISE | S235JR | ATTACHE | 0.309329 | 0.309918 | 0.000039405 | 0.00003948 | 0.00039 | 48.7682 | 0.0150854 | 0.015128 | 94
ATTACHE | STEEL/S235JR | 4311.91 | 12974.9 | 8343 | +4.265 | +4.359 | 331 | P67 | 2 | 2007 | GALVANISE | S235JR | ATTACHE | 0.309329 | 0.309918 | 0.000039405 | 0.00003948 | 0.00039 | 48.7682 | 0.0150854 | 0.015128 | 94
ATTACHE | STEEL/S235JR | 5797 | 24564.9 | 70905 | +5.750 | +5.844 | 355 | P74 | 1 | 1008 | GALVANISE | S235JR | ATTACHE | 0.308741 | 0.309918 | 0.00003933 | 0.00003948 | 0.00039 | 48.7233 | 0.0150429 | 0.015128 | 94
ATTACHE | STEEL/S235JR | 5796.91 | 17175.1 | 70603 | +5.750 | +5.844 | 331 | P71 | 1 | 1008 | GALVANISE | S235JR | ATTACHE | 0.309329 | 0.309918 | 0.000039405 | 0.00003948 | 0.00039 | 48.7682 | 0.0150854 | 0.015128 | 94
ATTACHE | STEEL/S235JR | 5796.91 | 17004.9 | 70603 | +5.750 | +5.844 | 331 | P71 | 1 | 1008 | GALVANISE | S235JR | ATTACHE | 0.309329 | 0.309918 | 0.000039405 | 0.00003948 | 0.00039 | 48.7682 | 0.0150854 | 0.015128 | 94
ATTACHE | STEEL/S235JR | 5797 | 17004.9 | 68128 | +5.750 | +5.844 | 355 | P73 | 1 | 1008 | GALVANISE | S235JR | ATTACHE | 0.30874 | 0.309918 | 0.00003933 | 0.00003948 | 0.00039 | 48.7233 | 0.0150429 | 0.015128 | 94
ATTACHE | STEEL/S235JR | 5797 | 17175.1 | 68128 | +5.750 | +5.844 | 355 | P73 | 1 | 1008 | GALVANISE | S235JR | ATTACHE | 0.30874 | 0.309918 | 0.00003933 | 0.00003948 | 0.00039 | 48.7233 | 0.0150429 | 0.015128 | 94
ATTACHE | STEEL/S235JR | 5796.91 | 14815.1 | 70603 | +5.750 | +5.844 | 331 | P71 | 1 | 1008 | GALVANISE | S235JR | ATTACHE | 0.309329 | 0.309918 | 0.000039405 | 0.00003948 | 0.00039 | 48.7682 | 0.0150854 | 0.015128 | 94
ATTACHE | STEEL/S235JR | 5796.91 | 14644.9 | 70603 | +5.750 | +5.844 | 331 | P71 | 1 | 1008 | GALVANISE | S235JR | ATTACHE | 0.309329 | 0.309918 | 0.000039405 | 0.00003948 | 0.00039 | 48.7682 | 0.0150854 | 0.015128 | 94
ATTACHE | STEEL/S235JR | 5797 | 14644.9 | 68128 | +5.750 | +5.844 | 355 | P73 | 1 | 1008 | GALVANISE | S235JR | ATTACHE | 0.308741 | 0.309918 | 0.00003933 | 0.00003948 | 0.00039 | 48.7233 | 0.0150429 | 0.015128 | 94
ATTACHE | STEEL/S235JR | 5797 | 14815.1 | 68128 | +5.750 | +5.844 | 355 | P73 | 1 | 1008 | GALVANISE | S235JR | ATTACHE | 0.30874 | 0.309918 | 0.00003933 | 0.00003948 | 0.00039 | 48.7233 | 0.0150429 | 0.015128 | 94
ATTACHE | STEEL/S235JR | 5796.91 | 10095.1 | 78028 | +5.750 | +5.844 | 331 | P68 | 1 | 1008 | GALVANISE | S235JR | ATTACHE | 0.309329 | 0.309918 | 0.000039405 | 0.00003948 | 0.00039 | 48.7682 | 0.0150854 | 0.015128 | 94
ATTACHE | STEEL/S235JR | 5796.91 | 9924.94 | 78028 | +5.750 | +5.844 | 331 | P68 | 1 | 1008 | GALVANISE | S235JR | ATTACHE | 0.309329 | 0.309918 | 0.000039405 | 0.00003948 | 0.00039 | 48.7682 | 0.0150854 | 0.015128 | 94
ATTACHE | STEEL/S235JR | 5796.91 | 9924.94 | 75553 | +5.750 | +5.844 | 331 | P69 | 1 | 1008 | GALVANISE | S235JR | ATTACHE | 0.309329 | 0.309918 | 0.000039405 | 0.00003948 | 0.00039 | 48.7682 | 0.0150854 | 0.015128 | 94
ATTACHE | STEEL/S235JR | 5796.91 | 10095.1 | 75553 | +5.750 | +5.844 | 331 | P69 | 1 | 1008 | GALVANISE | S235JR | ATTACHE | 0.309329 | 0.309918 | 0.000039405 | 0.00003948 | 0.00039 | 48.7682 | 0.0150854 | 0.015128 | 94
ATTACHE | STEEL/S235JR | 5796.91 | 9924.94 | 73078 | +5.750 | +5.844 | 331 | P70 | 1 | 1008 | GALVANISE | S235JR | ATTACHE | 0.309329 | 0.309918 | 0.000039405 | 0.00003948 | 0.00039 | 48.7682 | 0.0150854 | 0.015128 | 94
ATTACHE | STEEL/S235JR | 5796.91 | 10095.1 | 73078 | +5.750 | +5.844 | 331 | P70 | 1 | 1008 | GALVANISE | S235JR | ATTACHE | 0.309329 | 0.309918 | 0.000039405 | 0.00003948 | 0.00039 | 48.7682 | 0.0150854 | 0.015128 | 94
ATTACHE | STEEL/S235JR | 5796.91 | 9924.94 | 70603 | +5.750 | +5.844 | 331 | P71 | 1 | 1008 | GALVANISE | S235JR | ATTACHE | 0.309329 | 0.309918 | 0.000039405 | 0.00003948 | 0.00039 | 48.7682 | 0.0150854 | 0.015128 | 94
ATTACHE | STEEL/S235JR | 5796.91 | 10095.1 | 70603 | +5.750 | +5.844 | 331 | P71 | 1 | 1008 | GALVANISE | S235JR | ATTACHE | 0.309329 | 0.309918 | 0.000039405 | 0.00003948 | 0.00039 | 48.7682 | 0.0150854 | 0.015128 | 94
ATTACHE | STEEL/S235JR | 5797 | 9924.87 | 68128 | +5.750 | +5.844 | 355 | P73 | 1 | 1008 | GALVANISE | S235JR | ATTACHE | 0.308741 | 0.309918 | 0.00003933 | 0.00003948 | 0.00039 | 48.7233 | 0.0150429 | 0.015128 | 94
ATTACHE | STEEL/S235JR | 5797 | 10095.1 | 68128 | +5.750 | +5.844 | 355 | P73 | 1 | 1008 | GALVANISE | S235JR | ATTACHE | 0.30874 | 0.309918 | 0.00003933 | 0.00003948 | 0.00039 | 48.7233 | 0.0150429 | 0.015128 | 94
ATTACHE | STEEL/S235JR | 5796.91 | 7735.06 | 78028 | +5.750 | +5.844 | 331 | P68 | 1 | 1008 | GALVANISE | S235JR | ATTACHE | 0.309329 | 0.309918 | 0.000039405 | 0.00003948 | 0.00039 | 48.7682 | 0.0150854 | 0.015128 | 94
ATTACHE | STEEL/S235JR | 5797 | 7564.87 | 68128 | +5.750 | +5.844 | 355 | P73 | 1 | 1008 | GALVANISE | S235JR | ATTACHE | 0.30874 | 0.309918 | 0.00003933 | 0.00003948 | 0.00039 | 48.7233 | 0.0150429 | 0.015128 | 94
ATTACHE | STEEL/S235JR | 5796.91 | 7735.06 | 75553 | +5.750 | +5.844 | 331 | P69 | 1 | 1008 | GALVANISE | S235JR | ATTACHE | 0.309329 | 0.309918 | 0.000039405 | 0.00003948 | 0.00039 | 48.7682 | 0.0150854 | 0.015128 | 94
ATTACHE | STEEL/S235JR | 5796.91 | 7564.94 | 70603 | +5.750 | +5.844 | 331 | P71 | 1 | 1008 | GALVANISE | S235JR | ATTACHE | 0.309329 | 0.309918 | 0.000039405 | 0.00003948 | 0.00039 | 48.7682 | 0.0150854 | 0.015128 | 94
ATTACHE | STEEL/S235JR | 5796.91 | 7735.06 | 73078 | +5.750 | +5.844 | 331 | P70 | 1 | 1008 | GALVANISE | S235JR | ATTACHE | 0.309329 | 0.309918 | 0.000039405 | 0.00003948 | 0.00039 | 48.7682 | 0.0150854 | 0.015128 | 94
ATTACHE | STEEL/S235JR | 5796.91 | 7564.94 | 73078 | +5.750 | +5.844 | 331 | P70 | 1 | 1008 | GALVANISE | S235JR | ATTACHE | 0.309329 | 0.309918 | 0.000039405 | 0.00003948 | 0.00039 | 48.7682 | 0.0150854 | 0.015128 | 94
ATTACHE | STEEL/S235JR | 5796.91 | 7564.94 | 78028 | +5.750 | +5.844 | 331 | P68 | 1 | 1008 | GALVANISE | S235JR | ATTACHE | 0.309329 | 0.309918 | 0.000039405 | 0.00003948 | 0.00039 | 48.7682 | 0.0150854 | 0.015128 | 94
ATTACHE | STEEL/S235JR | 5796.91 | 7735.06 | 70603 | +5.750 | +5.844 | 331 | P71 | 1 | 1008 | GALVANISE | S235JR | ATTACHE | 0.309329 | 0.309918 | 0.000039405 | 0.00003948 | 0.00039 | 48.7682 | 0.0150854 | 0.015128 | 94
ATTACHE | STEEL/S235JR | 5797 | 12455.1 | 68128 | +5.750 | +5.844 | 355 | P73 | 1 | 1008 | GALVANISE | S235JR | ATTACHE | 0.30874 | 0.309918 | 0.00003933 | 0.00003948 | 0.00039 | 48.7233 | 0.0150429 | 0.015128 | 94
ATTACHE | STEEL/S235JR | 5797 | 12284.9 | 68128 | +5.750 | +5.844 | 355 | P73 | 1 | 1008 | GALVANISE | S235JR | ATTACHE | 0.30874 | 0.309918 | 0.00003933 | 0.00003948 | 0.00039 | 48.7233 | 0.0150429 | 0.015128 | 94
ATTACHE | STEEL/S235JR | 5797 | 7735.13 | 68128 | +5.750 | +5.844 | 355 | P73 | 1 | 1008 | GALVANISE | S235JR | ATTACHE | 0.30874 | 0.309918 | 0.00003933 | 0.00003948 | 0.00039 | 48.7233 | 0.0150429 | 0.015128 | 94
ATTACHE | STEEL/S235JR | 5796.91 | 2464.94 | 78028 | +5.750 | +5.844 | 331 | P68 | 1 | 1008 | GALVANISE | S235JR | ATTACHE | 0.309329 | 0.309918 | 0.000039405 | 0.00003948 | 0.00039 | 48.7682 | 0.0150854 | 0.015128 | 94
ATTACHE | STEEL/S235JR | 5796.91 | 2635.06 | 78028 | +5.750 | +5.844 | 331 | P68 | 1 | 1008 | GALVANISE | S235JR | ATTACHE | 0.309329 | 0.309918 | 0.000039405 | 0.00003948 | 0.00039 | 48.7682 | 0.0150854 | 0.015128 | 94
ATTACHE | STEEL/S235JR | 5796.91 | 2635.06 | 75553 | +5.750 | +5.844 | 331 | P69 | 1 | 1008 | GALVANISE | S235JR | ATTACHE | 0.309329 | 0.309918 | 0.000039405 | 0.00003948 | 0.00039 | 48.7682 | 0.0150854 | 0.015128 | 94
ATTACHE | STEEL/S235JR | 5796.91 | 2464.94 | 75553 | +5.750 | +5.844 | 331 | P69 | 1 | 1008 | GALVANISE | S235JR | ATTACHE | 0.309329 | 0.309918 | 0.000039405 | 0.00003948 | 0.00039 | 48.7682 | 0.0150854 | 0.015128 | 94
ATTACHE | STEEL/S235JR | 5796.91 | 2635.06 | 73078 | +5.750 | +5.844 | 331 | P70 | 1 | 1008 | GALVANISE | S235JR | ATTACHE | 0.309329 | 0.309918 | 0.000039405 | 0.00003948 | 0.00039 | 48.7682 | 0.0150854 | 0.015128 | 94
ATTACHE | STEEL/S235JR | 5796.91 | 2464.94 | 73078 | +5.750 | +5.844 | 331 | P70 | 1 | 1008 | GALVANISE | S235JR | ATTACHE | 0.309329 | 0.309918 | 0.000039405 | 0.00003948 | 0.00039 | 48.7682 | 0.0150854 | 0.015128 | 94
ATTACHE | STEEL/S235JR | 5796.91 | 2635.06 | 70603 | +5.750 | +5.844 | 331 | P71 | 1 | 1008 | GALVANISE | S235JR | ATTACHE | 0.309329 | 0.309918 | 0.000039405 | 0.00003948 | 0.00039 | 48.7682 | 0.0150854 | 0.015128 | 94
ATTACHE | STEEL/S235JR | 5796.91 | 2464.94 | 70603 | +5.750 | +5.844 | 331 | P71 | 1 | 1008 | GALVANISE | S235JR | ATTACHE | 0.309329 | 0.309918 | 0.000039405 | 0.00003948 | 0.00039 | 48.7682 | 0.0150854 | 0.015128 | 94
ATTACHE | STEEL/S235JR | 5797 | 2635.13 | 68128 | +5.750 | +5.844 | 355 | P73 | 1 | 1008 | GALVANISE | S235JR | ATTACHE | 0.30874 | 0.309918 | 0.00003933 | 0.00003948 | 0.00039 | 48.7233 | 0.0150429 | 0.015128 | 94
ATTACHE | STEEL/S235JR | 5797 | 2464.87 | 68128 | +5.750 | +5.844 | 355 | P73 | 1 | 1008 | GALVANISE | S235JR | ATTACHE | 0.308741 | 0.309918 | 0.00003933 | 0.00003948 | 0.00039 | 48.7233 | 0.0150429 | 0.015128 | 94
ATTACHE | STEEL/S235JR | 5796.91 | 5014.94 | 78028 | +5.750 | +5.844 | 331 | P68 | 1 | 1008 | GALVANISE | S235JR | ATTACHE | 0.309329 | 0.309918 | 0.000039405 | 0.00003948 | 0.00039 | 48.7682 | 0.0150854 | 0.015128 | 94
ATTACHE | STEEL/S235JR | 5796.91 | 5185.06 | 78028 | +5.750 | +5.844 | 331 | P68 | 1 | 1008 | GALVANISE | S235JR | ATTACHE | 0.309329 | 0.309918 | 0.000039405 | 0.00003948 | 0.00039 | 48.7682 | 0.0150854 | 0.015128 | 94
ATTACHE | STEEL/S235JR | 5796.91 | 5185.06 | 75553 | +5.750 | +5.844 | 331 | P69 | 1 | 1008 | GALVANISE | S235JR | ATTACHE | 0.309329 | 0.309918 | 0.000039405 | 0.00003948 | 0.00039 | 48.7682 | 0.0150854 | 0.015128 | 94
ATTACHE | STEEL/S235JR | 5796.91 | 5014.94 | 75553 | +5.750 | +5.844 | 331 | P69 | 1 | 1008 | GALVANISE | S235JR | ATTACHE | 0.309329 | 0.309918 | 0.000039405 | 0.00003948 | 0.00039 | 48.7682 | 0.0150854 | 0.015128 | 94
ATTACHE | STEEL/S235JR | 5796.91 | 5185.06 | 73078 | +5.750 | +5.844 | 331 | P70 | 1 | 1008 | GALVANISE | S235JR | ATTACHE | 0.309329 | 0.309918 | 0.000039405 | 0.00003948 | 0.00039 | 48.7682 | 0.0150854 | 0.015128 | 94
ATTACHE | STEEL/S235JR | 5796.91 | 5014.94 | 73078 | +5.750 | +5.844 | 331 | P70 | 1 | 1008 | GALVANISE | S235JR | ATTACHE | 0.309329 | 0.309918 | 0.000039405 | 0.00003948 | 0.00039 | 48.7682 | 0.0150854 | 0.015128 | 94
ATTACHE | STEEL/S235JR | 5796.91 | 5185.06 | 70603 | +5.750 | +5.844 | 331 | P71 | 1 | 1008 | GALVANISE | S235JR | ATTACHE | 0.309329 | 0.309918 | 0.000039405 | 0.00003948 | 0.00039 | 48.7682 | 0.0150854 | 0.015128 | 94
ATTACHE | STEEL/S235JR | 5796.91 | 5014.94 | 70603 | +5.750 | +5.844 | 331 | P71 | 1 | 1008 | GALVANISE | S235JR | ATTACHE | 0.309329 | 0.309918 | 0.000039405 | 0.00003948 | 0.00039 | 48.7682 | 0.0150854 | 0.015128 | 94
ATTACHE | STEEL/S235JR | 5797 | 5185.13 | 68128 | +5.750 | +5.844 | 355 | P73 | 1 | 1008 | GALVANISE | S235JR | ATTACHE | 0.30874 | 0.309918 | 0.00003933 | 0.00003948 | 0.00039 | 48.7233 | 0.0150429 | 0.015128 | 94
ATTACHE | STEEL/S235JR | 5797 | 5014.87 | 68128 | +5.750 | +5.844 | 355 | P73 | 1 | 1008 | GALVANISE | S235JR | ATTACHE | 0.308741 | 0.309918 | 0.00003933 | 0.00003948 | 0.00039 | 48.7233 | 0.0150429 | 0.015128 | 94
ATTACHE | STEEL/S235JR | 5796.91 | 7564.94 | 75553 | +5.750 | +5.844 | 331 | P69 | 1 | 1008 | GALVANISE | S235JR | ATTACHE | 0.309329 | 0.309918 | 0.000039405 | 0.00003948 | 0.00039 | 48.7682 | 0.0150854 | 0.015128 | 94
ATTACHE | STEEL/S235JR | 5796.91 | 12284.9 | 70603 | +5.750 | +5.844 | 331 | P71 | 1 | 1008 | GALVANISE | S235JR | ATTACHE | 0.309329 | 0.309918 | 0.000039405 | 0.00003948 | 0.00039 | 48.7682 | 0.0150854 | 0.015128 | 94
ATTACHE | STEEL/S235JR | 5796.91 | 12455.1 | 70603 | +5.750 | +5.844 | 331 | P71 | 1 | 1008 | GALVANISE | S235JR | ATTACHE | 0.309329 | 0.309918 | 0.000039405 | 0.00003948 | 0.00039 | 48.7682 | 0.0150854 | 0.015128 | 94
ATTACHE | STEEL/S235JR | 5797 | 22135.1 | 70905 | +5.750 | +5.844 | 355 | P74 | 1 | 1008 | GALVANISE | S235JR | ATTACHE | 0.30874 | 0.309918 | 0.00003933 | 0.00003948 | 0.00039 | 48.7233 | 0.0150429 | 0.015128 | 94
ATTACHE | STEEL/S235JR | 5797 | 21964.9 | 70905 | +5.750 | +5.844 | 355 | P74 | 1 | 1008 | GALVANISE | S235JR | ATTACHE | 0.308741 | 0.309918 | 0.00003933 | 0.00003948 | 0.00039 | 48.7233 | 0.0150429 | 0.015128 | 94
ATTACHE | STEEL/S235JR | 5797 | 24735.1 | 70905 | +5.750 | +5.844 | 355 | P74 | 1 | 1008 | GALVANISE | S235JR | ATTACHE | 0.30874 | 0.309918 | 0.00003933 | 0.00003948 | 0.00039 | 48.7233 | 0.0150429 | 0.015128 | 94
ATTACHE | STEEL/S235JR | 5797 | 26630.1 | 70905 | +5.750 | +5.844 | 355 | P75 | 1 | 1008 | GALVANISE | S235JR | ATTACHE | 0.30874 | 0.309918 | 0.00003933 | 0.00003948 | 0.00039 | 48.7233 | 0.0150429 | 0.015128 | 94
ATTACHE | STEEL/S235JR | 5797 | 26459.9 | 70905 | +5.750 | +5.844 | 355 | P75 | 1 | 1008 | GALVANISE | S235JR | ATTACHE | 0.308741 | 0.309918 | 0.00003933 | 0.00003948 | 0.00039 | 48.7233 | 0.0150429 | 0.015128 | 94
ATTACHE | STEEL/S235JR | 4311.91 | 42923.3 | 8343 | +4.265 | +4.359 | 331 | P67 | 2 | 2007 | GALVANISE | S235JR | ATTACHE | 0.309329 | 0.309918 | 0.000039405 | 0.00003948 | 0.00039 | 48.7682 | 0.0150854 | 0.015128 | 94
